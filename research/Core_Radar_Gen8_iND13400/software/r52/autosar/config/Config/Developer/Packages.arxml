<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00050.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="B91A6584-A75A-496B-97AE-EAB57E6141C9">
      <SHORT-NAME>MICROSAR_MemMap</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="517A4772-7B9E-47D0-9D55-5DAAAF144BAD">
          <SHORT-NAME>SwAddrMethods</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5FAB6D9A-B894-4031-98BC-7497E256922E">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="76EE484F-00D0-42A5-9324-A83A65765B40">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6A853C5D-7F0C-49AD-9DA0-36EE69E06DE4">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B5841A23-56DB-4C83-A2B3-F1B365618CB8">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="CDAAC2F0-DC4D-4DCE-921E-522BD156256D">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C2BE4963-B88B-41BC-B268-6E2EFCEE158B">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ff55d029-386d-43a2-b3c2-dfef4c7a5e36">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="ED8DCE33-9296-4B41-884F-1A31DCED360D">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="6A727E6B-1D2B-4DBA-9370-CB8945005822">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="8102E257-B85C-4882-89E3-678864CE0333">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="98F1B060-8E35-471D-A19E-5CD1C7993405">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="BEBFA79C-6D00-4CD2-812D-E41EB5A78EB4">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3DAF0FCD-3CD5-411C-AA93-9FC719D1D0D2">
          <SHORT-NAME>WdgM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="3A32DA89-7BE7-45F8-89F2-9914A7ACFCF7">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="B46970A3-F451-456A-BB2F-2D34CC0F1E3A">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="CD00DEA0-98CF-45B6-A1C4-44AA3D81538F">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="C62D5E34-D4B6-4516-AB06-69728B5C8C55">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="18664EC6-1450-4E58-813E-D4E68B6873A2">
          <SHORT-NAME>Dem_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="00613D53-CC89-481B-BA01-3C630757E9ED">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="2D08792E-077F-432D-845F-C1A6C948C7D7">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="31EF65CB-20FE-485D-9C03-7DAE1BD64960">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="9CE8A6A9-5085-4058-AFC6-C1E11BAD337C">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AF0B1CF6-C6C4-4675-88BF-F3BA2BC0AECA">
          <SHORT-NAME>Dcm_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="2D31CF76-48C6-4230-BD89-1C0538BDD28E">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7370E570-C4BD-4CF7-9AAD-5014993E4DA5">
      <SHORT-NAME>Clusters</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A86EE6E4-8444-4684-B675-AE5D16177E84">
      <SHORT-NAME>PDUs</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="98DC5945-4B9C-4CD6-ACA8-3FFDEDC8F0E0">
          <SHORT-NAME>PDU_RdrNet</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="BB0606D8-0B0E-4D39-AE0D-5551BBFEF080">
          <SHORT-NAME>GeneralPurposePDUs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="32EDFFC7-8FFA-45B3-AD1F-6E1889886828">
          <SHORT-NAME>ISignalIPDUs</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1F1C251F-1C65-48DF-80A8-2681A9B8E1D2">
      <SHORT-NAME>ISignals</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="2C4E6640-62BD-4449-8546-174A6EA61AE4">
          <SHORT-NAME>iSignal_RdrNet</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="BFA51C93-2CDE-4FDD-BDAC-4568D0416655">
          <SHORT-NAME>CAN1</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3F4C1CDB-0297-47CC-A462-A56B2D22BD4D">
      <SHORT-NAME>Transformer</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D8A19E0F-9262-4C51-B843-70FF5E299432">
      <SHORT-NAME>System</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D23D778B-EE90-4DB1-9A2B-C037C9A6A42D">
      <SHORT-NAME>ECUs</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B0D3B80B-D2D3-4020-A27A-859063E58158">
      <SHORT-NAME>SystemSignals</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="470CB700-5673-48E6-AFE9-7C657868DD2C">
          <SHORT-NAME>SysSignal_RdrNet</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FD90F798-E73A-4982-BF5D-C59A43A49606">
      <SHORT-NAME>SoAdRoutingGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2997924F-E799-4C14-A2EB-77D16E96AA65">
      <SHORT-NAME>SomeIpTpConfig</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3753DDD9-A01E-4C17-B95E-A5FFA136BBCB">
      <SHORT-NAME>TP</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0FF47EE7-7B11-47E3-ABEE-07CF3C8ED607">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9A2D71B2-D1C4-4705-A5D9-48B7E0DBBB07">
      <SHORT-NAME>Gateway</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EE4F508B-63A0-47D3-A01C-CA70488515AC">
      <SHORT-NAME>IPDUGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8A62C188-49F1-426E-8AB6-9BA0813FDE53">
      <SHORT-NAME>CanFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="70EA4856-896A-432D-A798-CD44E1A9198D">
      <SHORT-NAME>PDU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C81600A2-50C2-4E2B-B138-72722F0CBE25">
      <SHORT-NAME>ISignal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EB7C64ED-9C90-42E4-9CEC-08C40BA00501">
      <SHORT-NAME>DataTransformations</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BDB4DDCE-4396-4BBC-A85E-06BC61498988">
      <SHORT-NAME>Signal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4EB928B2-FBB8-4EF0-B6E8-DB2D85EDEA9E">
      <SHORT-NAME>VariantDefinition</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="E0F43489-105C-41C7-84DF-7D28EDBDEEBF">
          <SHORT-NAME>Variant</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="46C1BE09-2E92-48DA-B09E-3A42FDED4C61">
              <SHORT-NAME>CriterionValueSet</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="545FE7BF-E957-476E-86E6-7DB367BC5A8D">
          <SHORT-NAME>Criterion</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="4E28EAA9-343C-4292-96C2-D1D5789214D4">
              <SHORT-NAME>Value</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3E213735-791C-4069-80C1-D41ED9823077">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B026E376-C182-4785-AA5E-7104824957F5">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="2925F25D-22AC-44D6-9960-3858E1D1D582">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="722AD225-E17A-420E-9FA3-9A76526CF418">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="63825BFF-4F6D-484D-940F-C1F42A419759">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B684DA80-8DC9-455A-8E62-CC6A9A8FB63B">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AE673790-4125-454F-9CAF-85331AEFB1EF">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="661885D0-1954-42E4-8C01-AD1CCC62F79B">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="239C1A7A-3ED4-4B01-9ACD-1B1DFD9C2A5C">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BC8BE386-30A2-4E8E-B375-D54F15DE030E">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="60D2E179-86E9-4C19-A41D-34ABBFA2026A">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="989CBE9E-3DB2-493C-84B2-9BA2A31C246F">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7873DE6B-EC92-403A-BAC2-F6C3D628A9CB">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D8A022C6-EBCC-4DC1-8103-11EDF57BD03C">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9D3C34F3-7F55-4998-8BF9-BB0EB8B5D0E7">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7A57A3FF-BE14-4170-A2C0-8DB36C7EAACB">
      <SHORT-NAME>Units</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="E847ACA6-54A0-4FF2-80D8-BF871E5B3968">
          <SHORT-NAME>CAN1</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ADA539E5-925A-460C-9C74-46339C2B1A51">
      <SHORT-NAME>DataConstr</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="08D0B6BD-A412-45AF-B051-C02D3F049CD5">
          <SHORT-NAME>CAN1</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="311135F5-E250-4F9E-8F5E-47BD114F2A5F">
      <SHORT-NAME>CompuMethod</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="437ED5CE-C840-4C20-8DE3-B35C6EDCF8CF">
          <SHORT-NAME>CAN1</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8246123D-94CC-4885-BB11-CACC1C59DC50">
      <SHORT-NAME>DataType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C4B2ECB0-C10A-43C2-B57F-6918509431A3">
          <SHORT-NAME>Unit</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B21C4F4F-54B0-4C8F-88AA-31FC7E501D99">
          <SHORT-NAME>Semantics</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FD92B662-9018-42F1-B4CA-5FC351E35FBA">
          <SHORT-NAME>Constraint</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="09FEFB91-C5B1-4A97-9097-4862E7FF732E">
      <SHORT-NAME>SoftwareComponents</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="F2DE5EEB-01E5-41A9-BEFB-974AF4005BB5">
          <SHORT-NAME>CompositionSWComponents</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="34737725-DFD6-46BE-B05E-11D7B8417B0C">
          <SHORT-NAME>ApplicationSWComponents</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6BFA7587-D122-4807-82D6-2F8DB8072622">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9F9A35DD-23CA-434D-83B5-246579B82B19">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4248DC35-95BC-415D-8759-FFECE5307EDC">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9B970A2D-1D6C-4545-8F77-CE73812BDD11">
      <SHORT-NAME>Diagnostics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4E449012-8FDA-4CEB-93A8-894FF7AB058F">
      <SHORT-NAME>Signals</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8219DE75-D46F-4272-A749-8D884542A421">
      <SHORT-NAME>SYSTEM_SIGNALS</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FFEF651F-7F55-48FC-8A5A-F6DB49688CA2">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="CB9EA3AA-FE19-429C-A583-73A4EE0E987A">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="23A92928-6C8B-4FDF-8997-8FAD78D5C7A0">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="74A14137-4145-42A4-8D60-5E114B0056DE">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="20CF0803-5611-49D7-9A9C-69C0D7A8EFBD">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="14CC9656-EA0E-4F20-A9EA-BF4656C6C665">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B281609D-CF3B-4F43-A57D-C3E645C38A82">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0DEFEC3F-B0BA-4EFB-B2B3-BD95DB795401">
      <SHORT-NAME>Interfaces</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C5A75BF9-D4EB-43AD-A5BC-E1A760B43FF1">
          <SHORT-NAME>Events</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8BD51F78-A076-49C8-9C4C-330E4BC5E366">
      <SHORT-NAME>NM</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>