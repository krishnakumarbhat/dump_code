<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00049.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="ff55d029-386d-43a2-b3c2-dfef4c7a5e36">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="345b1097-f18c-4fdf-b915-90135eb3d8ec">
          <SHORT-NAME>J1939Rm_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="1b9b4385-0e96-400d-be23-f47acfc4c291">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="a86d969e-8624-40e7-a16d-5614dac017c5">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="c2cd22ed-aa44-4e6c-bdf5-46081f52c582">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="1a440ea9-8e22-462c-88df-10c09bbb4f4f">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
