TRANSlation.RESet

ENDDO
