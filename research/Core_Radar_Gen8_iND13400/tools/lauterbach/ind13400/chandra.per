            hexmask.long.byte 0x00 16.--23. 1. "CTL_HSM_RETAIN_02,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "CTL_HSM_RETAIN_01,Reserved"
            hexmask.long.byte 0x00 0.--7. 1. "CTL_HSM_RETAIN_00,Reserved"
    group.long 0x628++0x03
        line.long 0x00 "HSM_RETAIN1,Retain for HSM register 0"
            hexmask.long.byte 0x00 24.--31. 1. "CTL_HSM_RETAIN_13,Reserved"
            hexmask.long.byte 0x00 16.--23. 1. "CTL_HSM_RETAIN_12,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "CTL_HSM_RETAIN_11,Reserved"
            hexmask.long.byte 0x00 0.--7. 1. "CTL_HSM_RETAIN_10,Reserved"
    group.long 0x62C++0x03
        line.long 0x00 "CTL_LOCK,Lock control"
            hexmask.long 0x00 0.--31. 1. "CTL_SYS_LOCK_KEY,Write 0x9bd8ca97 to allow write access to this SFR bank"

    rgroup.long 0x630++0x03
        line.long 0x00 "STS_LOCK,Lock status"
            bitfld.long 0x00 0. "STS_SYS_LOCK_N,Lock status for this SFR bank" "0,1"
tree.end

tree "SYSMEM ()"
    base ad:0x84400000
    group.long 0x00++0x03
        line.long 0x00 "PORT0_MISC_CTRL0,Sysmem Port0 Top Control"
            bitfld.long 0x00 0. "CTL_P0_SCRUB_EN,If set (1) single-bit-errors detected in the memories are automatically re-written with corrected value" "0,1"
    group.long 0x04++0x03
        line.long 0x00 "PORT0_ECC_CTRL0,Sysmem Port0 ECC Control"
            hexmask.long.byte 0x00 8.--15. 1. "CTL_P0_ECC_ENC_PARITY,Bypass parity bits for ECC encoder"
            bitfld.long 0x00 1. "CTL_P0_ECC_DEC_BYP,If set (1) ECC decoder is bypassed" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_P0_ECC_ENC_BYP,If set (1) ECC encoder is bypassed" "0,1"
    group.long 0x08++0x03
        line.long 0x00 "PORT0_MODE_CTRL0,Sysmem Port0 Mode Control"
            hexmask.long.word 0x00 16.--27. 1. "CTL_P0_TWIST_SIZE,Set this field to maximize memory access performance for transpose accesses when using bit swizzling"
            abitfld.long 0x00 0.--11. "CTL_P0_DAT_SIZE,Bits [2:0] used for view 0" "0x000=0: 128 bits,0x001=1: 96 bits,0x002=2: 64 bits,0x003=3: 48 bits,0x004=4: 32 bits"
    group.long 0x0C++0x03
        line.long 0x00 "PORT0_TRNP_CTRL0,Sysmem Port0 Transpose Control"
            abitfld.long 0x00 16.--27. "CTL_P0_TRNP_RSH,Transpose address by right-shift MSBs by this number of bits" "0x001=1: right-shift by 10 bits,0x002=2: right-shift by 9 bits,0x003=3: right-shift by 8 bits,0x004=4: right-shift by 7 bits,0x005=5: right-shift by 6 bits else"
            abitfld.long 0x00 0.--11. "CTL_P0_TRNP_LSH,Transpose address by left-shift LSBs by this number of bits" "0x001=1: left-shift by 10 bits,0x002=2: left-shift by 9 bits,0x003=3: left-shift by 8 bits,0x004=4: left-shift by 7 bits,0x005=5: left-shift by 6 bits else"
    group.long 0x10++0x03
        line.long 0x00 "PORT0_SEC_CNT_CTRL0,Sysmem Port0 SEC Control"
            bitfld.long 0x00 16. "CTL_P0_SNAP_SEC_CNT,Toggle to '1' then back to '0' to take a snapshot of the SEC counter" "0,1"
            hexmask.long.word 0x00 0.--15. 1. "CTL_P0_ERR_SEC_LIM,If SEC count exceeds the value of this field then trigger an interrrupt request"

    rgroup.long 0x14++0x03
        line.long 0x00 "PORT0_SEC_DED_STAT0,Sysmem Port0 SEC DED Status 0"
            hexmask.long.word 0x00 16.--31. 1. "STS_P0_ECC_SEC_STICKY,Keep track of which RAM instances has had a SEC error"
            hexmask.long.word 0x00 0.--15. 1. "STS_P0_ECC_DED_STICKY,Keep track of which RAM instances has had a DED error"
    rgroup.long 0x18++0x03
        line.long 0x00 "PORT0_SEC_DED_STAT1,Sysmem Port0 SEC DED Status 1"
            hexmask.long.word 0x00 0.--15. 1. "STS_P0_ECC_SEC_CNT,Counter of all SEC events in this port"

    group.long 0x1C++0x03
        line.long 0x00 "PORT0_CLEAR_ERR_CTRL0,Sysmem Port0 Clear Sticky Error Control"
            bitfld.long 0x00 2. "CLR_P0_ECC_SEC_CNT,Toggle to '1' to clear SEC counter" "0,1"
            bitfld.long 0x00 1. "CLR_P0_ECC_SEC_STICKY,Toggle to '1' to clear SEC sticky tracker" "0,1"
            newline
            bitfld.long 0x00 0. "CLR_P0_ECC_DED_STICKY,Toggle to '1' to clear DED sticky tracker" "0,1"
    group.long 0x20++0x03
        line.long 0x00 "PORT0_INITFSM_CTRL0,Sysmem Port0 Init FSM Control"
            bitfld.long 0x00 0.--1. "CTL_P0_INITFSM_START,Toggle both bits to '1' to initialize all memory entries to {initfsm_seed1 initfsm_seed0}" "0,1,2,3"
    group.long 0x24++0x03
        line.long 0x00 "PORT0_INITFSM_CTRL1,Sysmem Port0 Init FSM Seed 0"
            hexmask.long 0x00 0.--31. 1. "CTL_P0_INITFSM_SEED0,This value is used for initializie sysmem memories for bits [31:0]"
    group.long 0x28++0x03
        line.long 0x00 "PORT0_INITFSM_CTRL2,Sysmem Port0 Init FSM Seed 1"
            hexmask.long 0x00 0.--31. 1. "CTL_P0_INITFSM_SEED1,This value is used for initializie sysmem memories for bits [63:32]"

    rgroup.long 0x2C++0x03
        line.long 0x00 "PORT0_INITFSM_STAT0,Sysmem Port0 Init FSM Status"
            hexmask.long.word 0x00 0.--15. 1. "STS_P0_INITFSM_ACTIVE,Indicate initialization status"

    group.long 0x30++0x03
        line.long 0x00 "PORT0_RAM_CTRL0,Sysmem Port0 RAM Control"
            bitfld.long 0x00 9. "CTL_P0_STOV,Do NOT modify" "0,1"
            bitfld.long 0x00 8. "CTL_P0_EMAS,Do NOT modify" "0,1"
            newline
            bitfld.long 0x00 4.--5. "CTL_P0_EMAW,Do NOT modify" "0,1,2,3"
            bitfld.long 0x00 0.--2. "CTL_P0_EMA,Do NOT modify" "0,1,2,3,4,5,6,7"
    group.long 0x34++0x03
        line.long 0x00 "PORT0_VW0_FITO_CTRL0,Sysmem Port0 View 0 First-In Transpose-Out Control 0"
            bitfld.long 0x00 24. "CTL_P0_VW0_FITO_USE,If set (1) then FITO mode will be used for view 0" "0,1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW0_FITO_WR_OFF,FITO pre-size-mode address write offset for View 0"
    group.long 0x38++0x03
        line.long 0x00 "PORT0_VW0_FITO_CTRL1,Sysmem Port0 View 0 First-In Transpose-Out Control 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW0_FITO_WR_STEP,FITO write step size view 0"
    group.long 0x3C++0x03
        line.long 0x00 "PORT0_VW0_FITO_CTRL2,Sysmem Port0 View 0 First-In Transpose-Out Control 2"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW0_FITO_WR_LIM,FITO write size limit view 0"
    group.long 0x40++0x03
        line.long 0x00 "PORT0_VW0_FITO_CTRL3,Sysmem Port0 View 0 First-In Transpose-Out Control 3"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW0_FITO_WR_PTR_VAL,FITO write pointer value"
    group.long 0x44++0x03
        line.long 0x00 "PORT0_VW0_FITO_CTRL4,Sysmem Port0 View 0 First-In Transpose-Out Control 4"
            bitfld.long 0x00 0. "CTL_P0_VW0_FITO_WR_PTR_PUSH,FITO write pointer push" "0,1"

    rgroup.long 0x48++0x03
        line.long 0x00 "PORT0_VW0_FITO_STAT0,Sysmem Port0 View 0 First-In Transpose-Out Status 0"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P0_VW0_FITO_WR_CURR,FITO write current pointer"

    group.long 0x4C++0x03
        line.long 0x00 "PORT0_VW0_FITO_CTRL5,Sysmem Port0 View 0 First-In Transpose-Out Control 5"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW0_FITO_RD_OFF,FITO pre-size-mode address offset for View 0"
    group.long 0x50++0x03
        line.long 0x00 "PORT0_VW0_FITO_CTRL6,Sysmem Port0 View 0 First-In Transpose-Out Control 6"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW0_FITO_RD_STEP,FITO read step size view 0"
    group.long 0x54++0x03
        line.long 0x00 "PORT0_VW0_FITO_CTRL7,Sysmem Port0 View 0 First-In Transpose-Out Control 7"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW0_FITO_RD_LIM,FITO read size limit view 0"
    group.long 0x58++0x03
        line.long 0x00 "PORT0_VW0_FITO_CTRL8,Sysmem Port0 View 0 First-In Transpose-Out Control 8"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW0_FITO_RD_PTR_VAL,FITO read pointer value"
    group.long 0x5C++0x03
        line.long 0x00 "PORT0_VW0_FITO_CTRL9,Sysmem Port0 View 0 First-In Transpose-Out Control 9"
            bitfld.long 0x00 0. "CTL_P0_VW0_FITO_RD_PTR_PUSH,FITO read pointer push" "0,1"

    rgroup.long 0x60++0x03
        line.long 0x00 "PORT0_VW0_FITO_STAT1,Sysmem Port0 View 0 First-In Transpose-Out Status 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P0_VW0_FITO_RD_CURR,FITO read current pointer"

    group.long 0x64++0x03
        line.long 0x00 "PORT0_VW1_FITO_CTRL0,Sysmem Port0 View 1 First-In Transpose-Out Control 0"
            bitfld.long 0x00 24. "CTL_P0_VW1_FITO_USE,If set (1) then FITO mode will be used for view 1" "0,1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW1_FITO_WR_OFF,FITO pre-size-mode address write offset for View 1"
    group.long 0x68++0x03
        line.long 0x00 "PORT0_VW1_FITO_CTRL1,Sysmem Port0 View 1 First-In Transpose-Out Control 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW1_FITO_WR_STEP,FITO write step size view 1"
    group.long 0x6C++0x03
        line.long 0x00 "PORT0_VW1_FITO_CTRL2,Sysmem Port0 View 1 First-In Transpose-Out Control 2"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW1_FITO_WR_LIM,FITO write size limit view 1"
    group.long 0x70++0x03
        line.long 0x00 "PORT0_VW1_FITO_CTRL3,Sysmem Port0 View 1 First-In Transpose-Out Control 3"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW1_FITO_WR_PTR_VAL,FITO write pointer value"
    group.long 0x74++0x03
        line.long 0x00 "PORT0_VW1_FITO_CTRL4,Sysmem Port0 View 1 First-In Transpose-Out Control 4"
            bitfld.long 0x00 0. "CTL_P0_VW1_FITO_WR_PTR_PUSH,FITO write pointer push" "0,1"

    rgroup.long 0x78++0x03
        line.long 0x00 "PORT0_VW1_FITO_STAT0,Sysmem Port0 View 1 First-In Transpose-Out Status 0"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P0_VW1_FITO_WR_CURR,FITO write current pointer"

    group.long 0x7C++0x03
        line.long 0x00 "PORT0_VW1_FITO_CTRL5,Sysmem Port0 View 1 First-In Transpose-Out Control 5"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW1_FITO_RD_OFF,FITO pre-size-mode address offset for View 1"
    group.long 0x80++0x03
        line.long 0x00 "PORT0_VW1_FITO_CTRL6,Sysmem Port0 View 1 First-In Transpose-Out Control 6"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW1_FITO_RD_STEP,FITO read step size view 1"
    group.long 0x84++0x03
        line.long 0x00 "PORT0_VW1_FITO_CTRL7,Sysmem Port0 View 1 First-In Transpose-Out Control 7"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW1_FITO_RD_LIM,FITO read size limit view 1"
    group.long 0x88++0x03
        line.long 0x00 "PORT0_VW1_FITO_CTRL8,Sysmem Port0 View 1 First-In Transpose-Out Control 8"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW1_FITO_RD_PTR_VAL,FITO read pointer value"
    group.long 0x8C++0x03
        line.long 0x00 "PORT0_VW1_FITO_CTRL9,Sysmem Port0 View 1 First-In Transpose-Out Control 9"
            bitfld.long 0x00 0. "CTL_P0_VW1_FITO_RD_PTR_PUSH,FITO read pointer push" "0,1"

    rgroup.long 0x90++0x03
        line.long 0x00 "PORT0_VW1_FITO_STAT1,Sysmem Port0 View 1 First-In Transpose-Out Status 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P0_VW1_FITO_RD_CURR,FITO read current pointer"

    group.long 0x94++0x03
        line.long 0x00 "PORT0_VW2_FITO_CTRL0,Sysmem Port0 View 2 First-In Transpose-Out Control 0"
            bitfld.long 0x00 24. "CTL_P0_VW2_FITO_USE,If set (1) then FITO mode will be used for view 2" "0,1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW2_FITO_WR_OFF,FITO pre-size-mode address write offset for View 2"
    group.long 0x98++0x03
        line.long 0x00 "PORT0_VW2_FITO_CTRL1,Sysmem Port0 View 2 First-In Transpose-Out Control 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW2_FITO_WR_STEP,FITO write step size view 2"
    group.long 0x9C++0x03
        line.long 0x00 "PORT0_VW2_FITO_CTRL2,Sysmem Port0 View 2 First-In Transpose-Out Control 2"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW2_FITO_WR_LIM,FITO write size limit view 2"
    group.long 0xA0++0x03
        line.long 0x00 "PORT0_VW2_FITO_CTRL3,Sysmem Port0 View 2 First-In Transpose-Out Control 3"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW2_FITO_WR_PTR_VAL,FITO write pointer value"
    group.long 0xA4++0x03
        line.long 0x00 "PORT0_VW2_FITO_CTRL4,Sysmem Port0 View 2 First-In Transpose-Out Control 4"
            bitfld.long 0x00 0. "CTL_P0_VW2_FITO_WR_PTR_PUSH,FITO write pointer push" "0,1"

    rgroup.long 0xA8++0x03
        line.long 0x00 "PORT0_VW2_FITO_STAT0,Sysmem Port0 View 2 First-In Transpose-Out Status 0"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P0_VW2_FITO_WR_CURR,FITO write current pointer"

    group.long 0xAC++0x03
        line.long 0x00 "PORT0_VW2_FITO_CTRL5,Sysmem Port0 View 2 First-In Transpose-Out Control 5"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW2_FITO_RD_OFF,FITO pre-size-mode address offset for View 2"
    group.long 0xB0++0x03
        line.long 0x00 "PORT0_VW2_FITO_CTRL6,Sysmem Port0 View 2 First-In Transpose-Out Control 6"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW2_FITO_RD_STEP,FITO read step size view 2"
    group.long 0xB4++0x03
        line.long 0x00 "PORT0_VW2_FITO_CTRL7,Sysmem Port0 View 2 First-In Transpose-Out Control 7"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW2_FITO_RD_LIM,FITO read size limit view 2"
    group.long 0xB8++0x03
        line.long 0x00 "PORT0_VW2_FITO_CTRL8,Sysmem Port0 View 2 First-In Transpose-Out Control 8"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW2_FITO_RD_PTR_VAL,FITO read pointer value"
    group.long 0xBC++0x03
        line.long 0x00 "PORT0_VW2_FITO_CTRL9,Sysmem Port0 View 2 First-In Transpose-Out Control 9"
            bitfld.long 0x00 0. "CTL_P0_VW2_FITO_RD_PTR_PUSH,FITO read pointer push" "0,1"

    rgroup.long 0xC0++0x03
        line.long 0x00 "PORT0_VW2_FITO_STAT1,Sysmem Port0 View 2 First-In Transpose-Out Status 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P0_VW2_FITO_RD_CURR,FITO read current pointer"

    group.long 0xC4++0x03
        line.long 0x00 "PORT0_VW3_FITO_CTRL0,Sysmem Port0 View 3 First-In Transpose-Out Control 0"
            bitfld.long 0x00 24. "CTL_P0_VW3_FITO_USE,If set (1) then FITO mode will be used for view 3" "0,1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW3_FITO_WR_OFF,FITO pre-size-mode address write offset for View 3"
    group.long 0xC8++0x03
        line.long 0x00 "PORT0_VW3_FITO_CTRL1,Sysmem Port0 View 3 First-In Transpose-Out Control 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW3_FITO_WR_STEP,FITO write step size view 3"
    group.long 0xCC++0x03
        line.long 0x00 "PORT0_VW3_FITO_CTRL2,Sysmem Port0 View 3 First-In Transpose-Out Control 2"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW3_FITO_WR_LIM,FITO write size limit view 3"
    group.long 0xD0++0x03
        line.long 0x00 "PORT0_VW3_FITO_CTRL3,Sysmem Port0 View 3 First-In Transpose-Out Control 3"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW3_FITO_WR_PTR_VAL,FITO write pointer value"
    group.long 0xD4++0x03
        line.long 0x00 "PORT0_VW3_FITO_CTRL4,Sysmem Port0 View 3 First-In Transpose-Out Control 4"
            bitfld.long 0x00 0. "CTL_P0_VW3_FITO_WR_PTR_PUSH,FITO write pointer push" "0,1"

    rgroup.long 0xD8++0x03
        line.long 0x00 "PORT0_VW3_FITO_STAT0,Sysmem Port0 View 3 First-In Transpose-Out Status 0"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P0_VW3_FITO_WR_CURR,FITO write current pointer"

    group.long 0xDC++0x03
        line.long 0x00 "PORT0_VW3_FITO_CTRL5,Sysmem Port0 View 3 First-In Transpose-Out Control 5"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW3_FITO_RD_OFF,FITO pre-size-mode address offset for View 3"
    group.long 0xE0++0x03
        line.long 0x00 "PORT0_VW3_FITO_CTRL6,Sysmem Port0 View 3 First-In Transpose-Out Control 6"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW3_FITO_RD_STEP,FITO read step size view 3"
    group.long 0xE4++0x03
        line.long 0x00 "PORT0_VW3_FITO_CTRL7,Sysmem Port0 View 3 First-In Transpose-Out Control 7"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW3_FITO_RD_LIM,FITO read size limit view 3"
    group.long 0xE8++0x03
        line.long 0x00 "PORT0_VW3_FITO_CTRL8,Sysmem Port0 View 3 First-In Transpose-Out Control 8"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P0_VW3_FITO_RD_PTR_VAL,FITO read pointer value"
    group.long 0xEC++0x03
        line.long 0x00 "PORT0_VW3_FITO_CTRL9,Sysmem Port0 View 3 First-In Transpose-Out Control 9"
            bitfld.long 0x00 0. "CTL_P0_VW3_FITO_RD_PTR_PUSH,FITO read pointer push" "0,1"

    rgroup.long 0xF0++0x03
        line.long 0x00 "PORT0_VW3_FITO_STAT1,Sysmem Port0 View 3 First-In Transpose-Out Status 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P0_VW3_FITO_RD_CURR,FITO read current pointer"

    group.long 0xF4++0x03
        line.long 0x00 "PORT1_MISC_CTRL0,Sysmem Port1 Top Control"
            bitfld.long 0x00 0. "CTL_P1_SCRUB_EN,If set (1) single-bit-errors detected in the memories are automatically re-written with corrected value" "0,1"
    group.long 0xF8++0x03
        line.long 0x00 "PORT1_ECC_CTRL0,Sysmem Port1 ECC Control"
            hexmask.long.byte 0x00 8.--15. 1. "CTL_P1_ECC_ENC_PARITY,Bypass parity bits for ECC encoder"
            bitfld.long 0x00 1. "CTL_P1_ECC_DEC_BYP,If set (1) ECC decoder is bypassed" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_P1_ECC_ENC_BYP,If set (1) ECC encoder is bypassed" "0,1"
    group.long 0xFC++0x03
        line.long 0x00 "PORT1_MODE_CTRL0,Sysmem Port1 Mode Control"
            hexmask.long.word 0x00 16.--27. 1. "CTL_P1_TWIST_SIZE,Set this field to maximize memory access performance for transpose accesses when using bit swizzling"
            abitfld.long 0x00 0.--11. "CTL_P1_DAT_SIZE,Bits [2:0] used for view 0" "0x000=0: 128 bits,0x001=1: 96 bits,0x002=2: 64 bits,0x003=3: 48 bits,0x004=4: 32 bits"
    group.long 0x100++0x03
        line.long 0x00 "PORT1_TRNP_CTRL0,Sysmem Port1 Transpose Control"
            abitfld.long 0x00 16.--27. "CTL_P1_TRNP_RSH,Transpose address by right-shift MSBs by this number of bits" "0x001=1: right-shift by 10 bits,0x002=2: right-shift by 9 bits,0x003=3: right-shift by 8 bits,0x004=4: right-shift by 7 bits,0x005=5: right-shift by 6 bits else"
            abitfld.long 0x00 0.--11. "CTL_P1_TRNP_LSH,Transpose address by left-shift LSBs by this number of bits" "0x001=1: left-shift by 10 bits,0x002=2: left-shift by 9 bits,0x003=3: left-shift by 8 bits,0x004=4: left-shift by 7 bits,0x005=5: left-shift by 6 bits else"
    group.long 0x104++0x03
        line.long 0x00 "PORT1_SEC_CNT_CTRL0,Sysmem Port1 SEC Control"
            bitfld.long 0x00 16. "CTL_P1_SNAP_SEC_CNT,Toggle to '1' then back to '0' to take a snapshot of the SEC counter" "0,1"
            hexmask.long.word 0x00 0.--15. 1. "CTL_P1_ERR_SEC_LIM,If SEC count exceeds the value of this field then trigger an interrrupt request"

    rgroup.long 0x108++0x03
        line.long 0x00 "PORT1_SEC_DED_STAT0,Sysmem Port1 SEC DED Status 0"
            hexmask.long.word 0x00 16.--31. 1. "STS_P1_ECC_SEC_STICKY,Keep track of which RAM instances has had a SEC error"
            hexmask.long.word 0x00 0.--15. 1. "STS_P1_ECC_DED_STICKY,Keep track of which RAM instances has had a DED error"
    rgroup.long 0x10C++0x03
        line.long 0x00 "PORT1_SEC_DED_STAT1,Sysmem Port1 SEC DED Status 1"
            hexmask.long.word 0x00 0.--15. 1. "STS_P1_ECC_SEC_CNT,Counter of all SEC events in this port"

    group.long 0x110++0x03
        line.long 0x00 "PORT1_CLEAR_ERR_CTRL0,Sysmem Port1 Clear Sticky Error Control"
            bitfld.long 0x00 2. "CLR_P1_ECC_SEC_CNT,Toggle to '1' to clear SEC counter" "0,1"
            bitfld.long 0x00 1. "CLR_P1_ECC_SEC_STICKY,Toggle to '1' to clear SEC sticky tracker" "0,1"
            newline
            bitfld.long 0x00 0. "CLR_P1_ECC_DED_STICKY,Toggle to '1' to clear DED sticky tracker" "0,1"
    group.long 0x114++0x03
        line.long 0x00 "PORT1_INITFSM_CTRL0,Sysmem Port1 Init FSM Control"
            bitfld.long 0x00 0.--1. "CTL_P1_INITFSM_START,Toggle both bits to '1' to initialize all memory entries to {initfsm_seed1 initfsm_seed0}" "0,1,2,3"
    group.long 0x118++0x03
        line.long 0x00 "PORT1_INITFSM_CTRL1,Sysmem Port1 Init FSM Seed 0"
            hexmask.long 0x00 0.--31. 1. "CTL_P1_INITFSM_SEED0,This value is used for initializie sysmem memories for bits [31:0]"
    group.long 0x11C++0x03
        line.long 0x00 "PORT1_INITFSM_CTRL2,Sysmem Port1 Init FSM Seed 1"
            hexmask.long 0x00 0.--31. 1. "CTL_P1_INITFSM_SEED1,This value is used for initializie sysmem memories for bits [63:32]"

    rgroup.long 0x120++0x03
        line.long 0x00 "PORT1_INITFSM_STAT0,Sysmem Port1 Init FSM Status"
            hexmask.long.word 0x00 0.--15. 1. "STS_P1_INITFSM_ACTIVE,Indicate initialization status"

    group.long 0x124++0x03
        line.long 0x00 "PORT1_RAM_CTRL0,Sysmem Port1 RAM Control"
            bitfld.long 0x00 9. "CTL_P1_STOV,Do NOT modify" "0,1"
            bitfld.long 0x00 8. "CTL_P1_EMAS,Do NOT modify" "0,1"
            newline
            bitfld.long 0x00 4.--5. "CTL_P1_EMAW,Do NOT modify" "0,1,2,3"
            bitfld.long 0x00 0.--2. "CTL_P1_EMA,Do NOT modify" "0,1,2,3,4,5,6,7"
    group.long 0x128++0x03
        line.long 0x00 "PORT1_VW0_FITO_CTRL0,Sysmem Port1 View 0 First-In Transpose-Out Control 0"
            bitfld.long 0x00 24. "CTL_P1_VW0_FITO_USE,If set (1) then FITO mode will be used for view 0" "0,1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW0_FITO_WR_OFF,FITO pre-size-mode address write offset for View 0"
    group.long 0x12C++0x03
        line.long 0x00 "PORT1_VW0_FITO_CTRL1,Sysmem Port1 View 0 First-In Transpose-Out Control 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW0_FITO_WR_STEP,FITO write step size view 0"
    group.long 0x130++0x03
        line.long 0x00 "PORT1_VW0_FITO_CTRL2,Sysmem Port1 View 0 First-In Transpose-Out Control 2"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW0_FITO_WR_LIM,FITO write size limit view 0"
    group.long 0x134++0x03
        line.long 0x00 "PORT1_VW0_FITO_CTRL3,Sysmem Port1 View 0 First-In Transpose-Out Control 3"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW0_FITO_WR_PTR_VAL,FITO write pointer value"
    group.long 0x138++0x03
        line.long 0x00 "PORT1_VW0_FITO_CTRL4,Sysmem Port1 View 0 First-In Transpose-Out Control 4"
            bitfld.long 0x00 0. "CTL_P1_VW0_FITO_WR_PTR_PUSH,FITO write pointer push" "0,1"

    rgroup.long 0x13C++0x03
        line.long 0x00 "PORT1_VW0_FITO_STAT0,Sysmem Port1 View 0 First-In Transpose-Out Status 0"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P1_VW0_FITO_WR_CURR,FITO write current pointer"

    group.long 0x140++0x03
        line.long 0x00 "PORT1_VW0_FITO_CTRL5,Sysmem Port1 View 0 First-In Transpose-Out Control 5"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW0_FITO_RD_OFF,FITO pre-size-mode address offset for View 0"
    group.long 0x144++0x03
        line.long 0x00 "PORT1_VW0_FITO_CTRL6,Sysmem Port1 View 0 First-In Transpose-Out Control 6"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW0_FITO_RD_STEP,FITO read step size view 0"
    group.long 0x148++0x03
        line.long 0x00 "PORT1_VW0_FITO_CTRL7,Sysmem Port1 View 0 First-In Transpose-Out Control 7"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW0_FITO_RD_LIM,FITO read size limit view 0"
    group.long 0x14C++0x03
        line.long 0x00 "PORT1_VW0_FITO_CTRL8,Sysmem Port1 View 0 First-In Transpose-Out Control 8"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW0_FITO_RD_PTR_VAL,FITO read pointer value"
    group.long 0x150++0x03
        line.long 0x00 "PORT1_VW0_FITO_CTRL9,Sysmem Port1 View 0 First-In Transpose-Out Control 9"
            bitfld.long 0x00 0. "CTL_P1_VW0_FITO_RD_PTR_PUSH,FITO read pointer push" "0,1"

    rgroup.long 0x154++0x03
        line.long 0x00 "PORT1_VW0_FITO_STAT1,Sysmem Port1 View 0 First-In Transpose-Out Status 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P1_VW0_FITO_RD_CURR,FITO read current pointer"

    group.long 0x158++0x03
        line.long 0x00 "PORT1_VW1_FITO_CTRL0,Sysmem Port1 View 1 First-In Transpose-Out Control 0"
            bitfld.long 0x00 24. "CTL_P1_VW1_FITO_USE,If set (1) then FITO mode will be used for view 1" "0,1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW1_FITO_WR_OFF,FITO pre-size-mode address write offset for View 1"
    group.long 0x15C++0x03
        line.long 0x00 "PORT1_VW1_FITO_CTRL1,Sysmem Port1 View 1 First-In Transpose-Out Control 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW1_FITO_WR_STEP,FITO write step size view 1"
    group.long 0x160++0x03
        line.long 0x00 "PORT1_VW1_FITO_CTRL2,Sysmem Port1 View 1 First-In Transpose-Out Control 2"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW1_FITO_WR_LIM,FITO write size limit view 1"
    group.long 0x164++0x03
        line.long 0x00 "PORT1_VW1_FITO_CTRL3,Sysmem Port1 View 1 First-In Transpose-Out Control 3"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW1_FITO_WR_PTR_VAL,FITO write pointer value"
    group.long 0x168++0x03
        line.long 0x00 "PORT1_VW1_FITO_CTRL4,Sysmem Port1 View 1 First-In Transpose-Out Control 4"
            bitfld.long 0x00 0. "CTL_P1_VW1_FITO_WR_PTR_PUSH,FITO write pointer push" "0,1"

    rgroup.long 0x16C++0x03
        line.long 0x00 "PORT1_VW1_FITO_STAT0,Sysmem Port1 View 1 First-In Transpose-Out Status 0"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P1_VW1_FITO_WR_CURR,FITO write current pointer"

    group.long 0x170++0x03
        line.long 0x00 "PORT1_VW1_FITO_CTRL5,Sysmem Port1 View 1 First-In Transpose-Out Control 5"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW1_FITO_RD_OFF,FITO pre-size-mode address offset for View 1"
    group.long 0x174++0x03
        line.long 0x00 "PORT1_VW1_FITO_CTRL6,Sysmem Port1 View 1 First-In Transpose-Out Control 6"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW1_FITO_RD_STEP,FITO read step size view 1"
    group.long 0x178++0x03
        line.long 0x00 "PORT1_VW1_FITO_CTRL7,Sysmem Port1 View 1 First-In Transpose-Out Control 7"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW1_FITO_RD_LIM,FITO read size limit view 1"
    group.long 0x17C++0x03
        line.long 0x00 "PORT1_VW1_FITO_CTRL8,Sysmem Port1 View 1 First-In Transpose-Out Control 8"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW1_FITO_RD_PTR_VAL,FITO read pointer value"
    group.long 0x180++0x03
        line.long 0x00 "PORT1_VW1_FITO_CTRL9,Sysmem Port1 View 1 First-In Transpose-Out Control 9"
            bitfld.long 0x00 0. "CTL_P1_VW1_FITO_RD_PTR_PUSH,FITO read pointer push" "0,1"

    rgroup.long 0x184++0x03
        line.long 0x00 "PORT1_VW1_FITO_STAT1,Sysmem Port1 View 1 First-In Transpose-Out Status 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P1_VW1_FITO_RD_CURR,FITO read current pointer"

    group.long 0x188++0x03
        line.long 0x00 "PORT1_VW2_FITO_CTRL0,Sysmem Port1 View 2 First-In Transpose-Out Control 0"
            bitfld.long 0x00 24. "CTL_P1_VW2_FITO_USE,If set (1) then FITO mode will be used for view 2" "0,1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW2_FITO_WR_OFF,FITO pre-size-mode address write offset for View 2"
    group.long 0x18C++0x03
        line.long 0x00 "PORT1_VW2_FITO_CTRL1,Sysmem Port1 View 2 First-In Transpose-Out Control 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW2_FITO_WR_STEP,FITO write step size view 2"
    group.long 0x190++0x03
        line.long 0x00 "PORT1_VW2_FITO_CTRL2,Sysmem Port1 View 2 First-In Transpose-Out Control 2"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW2_FITO_WR_LIM,FITO write size limit view 2"
    group.long 0x194++0x03
        line.long 0x00 "PORT1_VW2_FITO_CTRL3,Sysmem Port1 View 2 First-In Transpose-Out Control 3"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW2_FITO_WR_PTR_VAL,FITO write pointer value"
    group.long 0x198++0x03
        line.long 0x00 "PORT1_VW2_FITO_CTRL4,Sysmem Port1 View 2 First-In Transpose-Out Control 4"
            bitfld.long 0x00 0. "CTL_P1_VW2_FITO_WR_PTR_PUSH,FITO write pointer push" "0,1"

    rgroup.long 0x19C++0x03
        line.long 0x00 "PORT1_VW2_FITO_STAT0,Sysmem Port1 View 2 First-In Transpose-Out Status 0"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P1_VW2_FITO_WR_CURR,FITO write current pointer"

    group.long 0x1A0++0x03
        line.long 0x00 "PORT1_VW2_FITO_CTRL5,Sysmem Port1 View 2 First-In Transpose-Out Control 5"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW2_FITO_RD_OFF,FITO pre-size-mode address offset for View 2"
    group.long 0x1A4++0x03
        line.long 0x00 "PORT1_VW2_FITO_CTRL6,Sysmem Port1 View 2 First-In Transpose-Out Control 6"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW2_FITO_RD_STEP,FITO read step size view 2"
    group.long 0x1A8++0x03
        line.long 0x00 "PORT1_VW2_FITO_CTRL7,Sysmem Port1 View 2 First-In Transpose-Out Control 7"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW2_FITO_RD_LIM,FITO read size limit view 2"
    group.long 0x1AC++0x03
        line.long 0x00 "PORT1_VW2_FITO_CTRL8,Sysmem Port1 View 2 First-In Transpose-Out Control 8"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW2_FITO_RD_PTR_VAL,FITO read pointer value"
    group.long 0x1B0++0x03
        line.long 0x00 "PORT1_VW2_FITO_CTRL9,Sysmem Port1 View 2 First-In Transpose-Out Control 9"
            bitfld.long 0x00 0. "CTL_P1_VW2_FITO_RD_PTR_PUSH,FITO read pointer push" "0,1"

    rgroup.long 0x1B4++0x03
        line.long 0x00 "PORT1_VW2_FITO_STAT1,Sysmem Port1 View 2 First-In Transpose-Out Status 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P1_VW2_FITO_RD_CURR,FITO read current pointer"

    group.long 0x1B8++0x03
        line.long 0x00 "PORT1_VW3_FITO_CTRL0,Sysmem Port1 View 3 First-In Transpose-Out Control 0"
            bitfld.long 0x00 24. "CTL_P1_VW3_FITO_USE,If set (1) then FITO mode will be used for view 3" "0,1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW3_FITO_WR_OFF,FITO pre-size-mode address write offset for View 3"
    group.long 0x1BC++0x03
        line.long 0x00 "PORT1_VW3_FITO_CTRL1,Sysmem Port1 View 3 First-In Transpose-Out Control 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW3_FITO_WR_STEP,FITO write step size view 3"
    group.long 0x1C0++0x03
        line.long 0x00 "PORT1_VW3_FITO_CTRL2,Sysmem Port1 View 3 First-In Transpose-Out Control 2"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW3_FITO_WR_LIM,FITO write size limit view 3"
    group.long 0x1C4++0x03
        line.long 0x00 "PORT1_VW3_FITO_CTRL3,Sysmem Port1 View 3 First-In Transpose-Out Control 3"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW3_FITO_WR_PTR_VAL,FITO write pointer value"
    group.long 0x1C8++0x03
        line.long 0x00 "PORT1_VW3_FITO_CTRL4,Sysmem Port1 View 3 First-In Transpose-Out Control 4"
            bitfld.long 0x00 0. "CTL_P1_VW3_FITO_WR_PTR_PUSH,FITO write pointer push" "0,1"

    rgroup.long 0x1CC++0x03
        line.long 0x00 "PORT1_VW3_FITO_STAT0,Sysmem Port1 View 3 First-In Transpose-Out Status 0"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P1_VW3_FITO_WR_CURR,FITO write current pointer"

    group.long 0x1D0++0x03
        line.long 0x00 "PORT1_VW3_FITO_CTRL5,Sysmem Port1 View 3 First-In Transpose-Out Control 5"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW3_FITO_RD_OFF,FITO pre-size-mode address offset for View 3"
    group.long 0x1D4++0x03
        line.long 0x00 "PORT1_VW3_FITO_CTRL6,Sysmem Port1 View 3 First-In Transpose-Out Control 6"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW3_FITO_RD_STEP,FITO read step size view 3"
    group.long 0x1D8++0x03
        line.long 0x00 "PORT1_VW3_FITO_CTRL7,Sysmem Port1 View 3 First-In Transpose-Out Control 7"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW3_FITO_RD_LIM,FITO read size limit view 3"
    group.long 0x1DC++0x03
        line.long 0x00 "PORT1_VW3_FITO_CTRL8,Sysmem Port1 View 3 First-In Transpose-Out Control 8"
            hexmask.long.tbyte 0x00 0.--18. 1. "CTL_P1_VW3_FITO_RD_PTR_VAL,FITO read pointer value"
    group.long 0x1E0++0x03
        line.long 0x00 "PORT1_VW3_FITO_CTRL9,Sysmem Port1 View 3 First-In Transpose-Out Control 9"
            bitfld.long 0x00 0. "CTL_P1_VW3_FITO_RD_PTR_PUSH,FITO read pointer push" "0,1"

    rgroup.long 0x1E4++0x03
        line.long 0x00 "PORT1_VW3_FITO_STAT1,Sysmem Port1 View 3 First-In Transpose-Out Status 1"
            hexmask.long.tbyte 0x00 0.--18. 1. "STS_P1_VW3_FITO_RD_CURR,FITO read current pointer"

    group.long 0x1E8++0x03
        line.long 0x00 "IRQ_ENA_CTRL0,Error IRQ Enable control"
            abitfld.long 0x00 0.--31. "CTL_ERR_ENA,Each bit corresponds to enabling a SysMem interrupt source" "0x00000000=0: Mem Port 0 internal HW FSM error,0x00000001=1: Mem Port 0 internal HW FIFO overflow,0x00000002=2: Mem Port 0 AHB control parity..,0x00000003=3: Mem Port 0 AHB write data parity..,0x00000004=4: Mem Port 0 AHB address parity bit..,0x00000005=5: Mem Port 0 internal HW control..,0x00000006=6: Mem Port 0 internal HW read data..,0x00000007=7: Mem Port 0 internal HW interface..,0x00000008=8: Mem Port 0 internal HW interface..,0x00000009=9: Mem Port 0 internal HW FIFO..,0x0000000A=10: Mem Port 0 DED error,0x0000000B=11: Mem Port 0 SEC error counter has..,0x0000000C=12: Mem Port 0 internal HW mapping..,0x0000000D=13: Mem Port 0 internal HW first..,0x0000000E=14: Mem Port 0 internal HW second..,0x0000000F=15: Mem Port 0 internal HW final..,0x00000010=16: Mem Port 1 internal HW FSM error,0x00000011=17: Mem Port 1 internal HW FIFO..,0x00000012=18: Mem Port 1 AHB control parity error,0x00000013=19: Mem Port 1 AHB write data parity..,0x00000014=20: Mem Port 1 AHB address parity bit..,0x00000015=21: Mem Port 1 internal HW control..,0x00000016=22: Mem Port 1 internal HW read data..,0x00000017=23: Mem Port 1 internal HW interface..,0x00000018=24: Mem Port 1 internal HW interface..,0x00000019=25: Mem Port 1 internal HW FIFO..,0x0000001A=26: Mem Port 1 DED error,0x0000001B=27: Mem Port 1 SEC error counter has..,0x0000001C=28: Mem Port 1 internal HW mapping..,0x0000001D=29: Mem Port 1 internal HW first..,0x0000001E=30: Mem Port 1 internal HW second..,0x0000001F=31: Mem Port 1 internal HW final.."
    group.long 0x1EC++0x03
        line.long 0x00 "IRQ_STAT0,IRQ Status"
            hexmask.long 0x00 0.--31. 1. "STS_ERR,Each bit corresponds to a SysMem interrupt source having been issued"
    group.long 0x1F0++0x03
        line.long 0x00 "PORT0_ROC_A_CTRL0,Sysmem Port0 Read-Only-Check Control Region A Register 0"
            bitfld.long 0x00 24. "CTL_P0_ROC_A_ENA,If set (1) read-only-check region A is enabled" "0,1"
            hexmask.long.tbyte 0x00 0.--16. 1. "CTL_P0_ROC_A_BEG_ADDR,Read-Only-Check region A is defined by this field and ending address: beg_addr <= read-only-check region <= end_addr"
    group.long 0x1F4++0x03
        line.long 0x00 "PORT0_ROC_A_CTRL1,Sysmem Port0 Read-Only-Check Control Region A Register 1"
            hexmask.long.tbyte 0x00 0.--16. 1. "CTL_P0_ROC_A_END_ADDR,Read-Only-Check region A is defined by this field and beginning address: beg_addr <= read-only-check region <= end_addr"
    group.long 0x1F8++0x03
        line.long 0x00 "PORT0_ROC_B_CTRL0,Sysmem Port0 Read-Only-Check Control Region B Register 0"
            bitfld.long 0x00 24. "CTL_P0_ROC_B_ENA,If set (1) read-only-check region B is enabled" "0,1"
            hexmask.long.tbyte 0x00 0.--16. 1. "CTL_P0_ROC_B_BEG_ADDR,Read-Only-Check region B is defined by this field and ending address: beg_addr <= read-only-check region <= end_addr"
    group.long 0x1FC++0x03
        line.long 0x00 "PORT0_ROC_B_CTRL1,Sysmem Port0 Read-Only-Check Control Region B Register 1"
            hexmask.long.tbyte 0x00 0.--16. 1. "CTL_P0_ROC_B_END_ADDR,Read-Only-Check region B is defined by this field and beginning address: beg_addr <= read-only-check region <= end_addr"
    group.long 0x200++0x03
        line.long 0x00 "PORT1_ROC_A_CTRL0,Sysmem Port1 Read-Only-Check Control Region A Register 0"
            bitfld.long 0x00 24. "CTL_P1_ROC_A_ENA,If set (1) read-only-check region A is enabled" "0,1"
            hexmask.long.tbyte 0x00 0.--16. 1. "CTL_P1_ROC_A_BEG_ADDR,Read-Only-Check region A is defined by this field and ending address: beg_addr <= read-only-check region <= end_addr"
    group.long 0x204++0x03
        line.long 0x00 "PORT1_ROC_A_CTRL1,Sysmem Port1 Read-Only-Check Control Region A Register 1"
            hexmask.long.tbyte 0x00 0.--16. 1. "CTL_P1_ROC_A_END_ADDR,Read-Only-Check region A is defined by this field and beginning address: beg_addr <= read-only-check region <= end_addr"
    group.long 0x208++0x03
        line.long 0x00 "PORT1_ROC_B_CTRL0,Sysmem Port1 Read-Only-Check Control Region B Register 0"
            bitfld.long 0x00 24. "CTL_P1_ROC_B_ENA,If set (1) read-only-check region B is enabled" "0,1"
            hexmask.long.tbyte 0x00 0.--16. 1. "CTL_P1_ROC_B_BEG_ADDR,Read-Only-Check region B is defined by this field and ending address: beg_addr <= read-only-check region <= end_addr"
    group.long 0x20C++0x03
        line.long 0x00 "PORT1_ROC_B_CTRL1,Sysmem Port1 Read-Only-Check Control Region B Register 1"
            hexmask.long.tbyte 0x00 0.--16. 1. "CTL_P1_ROC_B_END_ADDR,Read-Only-Check region B is defined by this field and beginning address: beg_addr <= read-only-check region <= end_addr"
    group.long 0x210++0x03
        line.long 0x00 "INFO_IRQ_ENA_CTRL0,Informative IRQ Enable control"
            bitfld.long 0x00 0.--3. "CTL_INFO_ENA,Each bit corresponds to enabling a SysMem interrupt source" "0: Read-only-check Port 0 region A write attempted,1: Read-only-check Port 0 region B write attempted,2: Read-only-check Port 1 region A write attempted,3: Read-only-check Port 1 region B write attempted,?..."
    group.long 0x214++0x03
        line.long 0x00 "INFO_IRQ_STAT0,Informative IRQ Status"
            bitfld.long 0x00 0.--3. "STS_INFO,Each bit corresponds to a SysMem informative interrupt source having been issued" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x218++0x03
        line.long 0x00 "SPARE,Spare Register"
            hexmask.long 0x00 0.--31. 1. "SPARE,Spare registers"
    group.long 0x21C++0x03
        line.long 0x00 "CTL_LOCK,Lock control"
            hexmask.long 0x00 0.--31. 1. "CTL_SYSMEM_LOCK_KEY,Write 0x9bd8ca97 to allow write access to this SFR bank"

    rgroup.long 0x220++0x03
        line.long 0x00 "STS_LOCK,Lock status"
            bitfld.long 0x00 0. "STS_SYSMEM_LOCK_N,Lock status for this SFR bank" "0,1"
tree.end

tree "TIMERS ()"
    repeat 2. (list 0. 1.) (list ad:0x91923000 ad:0x91926000)
        tree "TIMERS$1"
            base $2
            group.long 0x00++0x03
                line.long 0x00 "TIMER1LOADCOUNT,Value to be loaded into Timer N"
                    hexmask.long 0x00 0.--31. 1. "TIMER1LOADCOUNT,Value to be loaded into Timer 1"

            rgroup.long 0x04++0x03
                line.long 0x00 "TIMER1CURRENTVAL,Current value of Timer N"
                    hexmask.long 0x00 0.--31. 1. "TIMER1CURRENTVAL,Current Value of Timer 1"

            group.long 0x08++0x03
                line.long 0x00 "TIMER1CONTROLREG,Control Register for Timer N"
                    hexmask.long 0x00 5.--31. 1. "RSVD_TimerNControlReg,TimerNControlReg 31to5 Reserved field"
                    rbitfld.long 0x00 4. "RSVD_TIMER_0N100PWM_EN,TimerNControlReg 4 Reserved field" "0: UNKN_DESC,1: UNKN_DESC"
                    newline
                    bitfld.long 0x00 3. "TIMER_PWM,Pulse Width Modulation of timer_N_toggle output" "0: PWM for timer_N_toggle o/p is disabled,1: PWM for timer_N_toggle o/p is enabled"
                    bitfld.long 0x00 2. "TIMER_INTERRUPT_MASK,Timer interrupt mask for Timer N" "0: Timer N interrupt is unmasked,1: Timer N interrupt is masked"
                    newline
                    bitfld.long 0x00 1. "TIMER_MODE,Timer mode for Timer N" "0: Free Running mode of operation,1: User-Defined mode of operation"
                    bitfld.long 0x00 0. "TIMER_ENABLE,Timer enable bit for Timer N" "0: Timer N is disabled,1: Timer N is enabled"

            rgroup.long 0x0C++0x03
                line.long 0x00 "TIMER1EOI,Clears the interrupt from Timer N"
                    hexmask.long 0x00 1.--31. 1. "RSVD_Timer1EOI,Timer1EOI 31to1 Reserved field"
                    bitfld.long 0x00 0. "Timer1EOI,Reading from this register returns all zeroes (0) and clears the interrupt from Timer 1" "0,1"
            rgroup.long 0x10++0x03
                line.long 0x00 "TIMER1INTSTAT,Contains the interrupt status for Timer N"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER1INTSTAT,Timer1IntStatus 31to1 Reserved field Note: - The reserved field name for Timer 2 will be RSVD_TIMER2INTSTAT"
                    bitfld.long 0x00 0. "TIMER1INTSTAT,Contains the interrupt status for Timer 1" "0: Timer N Interrupt is inactive,1: Timer N Interrupt is active"

            group.long 0x14++0x03
                line.long 0x00 "TIMER2LOADCOUNT,Name: Timer2 Load Count Register Size: 8-32 bits Address Offset: 20 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER2LOADCOUNT,Value to be loaded into Timer2"

            rgroup.long 0x18++0x03
                line.long 0x00 "TIMER2CURRENTVAL,Name: Timer2 Current Value Size: 8-32 bits Address Offset: 24 Read/Write Access: Read"
                    hexmask.long 0x00 0.--31. 1. "TIMER2CURRENTVAL,Current Value of Timer2"

            group.long 0x1C++0x03
                line.long 0x00 "TIMER2CONTROLREG,Name: Timer2 Control Register Size: 3 bits Address Offset: 28 Read/Write Access: Read/Write This register controls enabling operating mode (free-running or defined-count) and interrupt mask of Timer2"
                    hexmask.long 0x00 5.--31. 1. "RSVD_TIMER2CONTROLREG,TimerNControlReg 31to5 Reserved field"
                    rbitfld.long 0x00 4. "RSVD_TIMER_0N100PWM_EN,TimerNControlReg 4 Reserved field" "0: UNKN_DESC,1: UNKN_DESC"
                    newline
                    bitfld.long 0x00 3. "TIMER_PWM,Pulse Width Modulation of timer_2_toggle output" "0: PWM for timer_2_toggle o/p is disabled,1: PWM for timer_2_toggle o/p is enabled"
                    bitfld.long 0x00 2. "TIMER_INTERRUPT_MASK,Timer interrupt mask for Timer2" "0: Timer2 interrupt is unmasked,1: Timer2 interrupt is masked"
                    newline
                    bitfld.long 0x00 1. "TIMER_MODE,Timer mode for Timer2" "0: Free Running mode of operation,1: User-Defined mode of operation"
                    bitfld.long 0x00 0. "TIMER_ENABLE,Timer enable bit for Timer2" "0: Timer2 is disabled,1: Timer2 is enabled"

            rgroup.long 0x20++0x03
                line.long 0x00 "TIMER2EOI,Name: Timer2 End-of-Interrupt Register Size: 1 bit Address Offset: 32 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER2EOI,TimerNEOI 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER2EOI,Reading from this register returns all zeroes (0) and clears the interrupt from Timer2" "0,1"
            rgroup.long 0x24++0x03
                line.long 0x00 "TIMER2INTSTAT,Name: Timer2 Interrupt Status Register Size: 1 bit Address Offset: 36 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER2INTSTAT,TimerNIntStatus 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER2INTSTAT,Contains the interrupt status for Timer2" "0: Timer2 Interrupt is inactive,1: Timer2 Interrupt is active"

            group.long 0x28++0x03
                line.long 0x00 "TIMER3LOADCOUNT,Name: Timer3 Load Count Register Size: 8-32 bits Address Offset: 40 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER3LOADCOUNT,Value to be loaded into Timer3"

            rgroup.long 0x2C++0x03
                line.long 0x00 "TIMER3CURRENTVAL,Name: Timer3 Current Value Size: 8-32 bits Address Offset: 44 Read/Write Access: Read"
                    hexmask.long 0x00 0.--31. 1. "TIMER3CURRENTVAL,Current Value of Timer3"

            group.long 0x30++0x03
                line.long 0x00 "TIMER3CONTROLREG,Name: Timer3 Control Register Size: 4 bits Address Offset: 48 Read/Write Access: Read/Write This register controls enabling operating mode (free-running or defined-count) and interrupt mask of Timer3"
                    hexmask.long 0x00 5.--31. 1. "RSVD_TIMER3CONTROLREG,TimerNControlReg 31to5 Reserved field"
                    rbitfld.long 0x00 4. "RSVD_TIMER_0N100PWM_EN,TimerNControlReg 4 Reserved field" "0: UNKN_DESC,1: UNKN_DESC"
                    newline
                    bitfld.long 0x00 3. "TIMER_PWM,Pulse Width Modulation of timer_3_toggle output" "0: PWM for timer_3_toggle o/p is disabled,1: PWM for timer_3_toggle o/p is enabled"
                    bitfld.long 0x00 2. "TIMER_INTERRUPT_MASK,Timer interrupt mask for Timer3" "0: Timer3 interrupt is unmasked,1: Timer3 interrupt is masked"
                    newline
                    bitfld.long 0x00 1. "TIMER_MODE,Timer mode for Timer3" "0: Free Running mode of operation,1: User-Defined mode of operation"
                    bitfld.long 0x00 0. "TIMER_ENABLE,Timer enable bit for Timer3" "0: Timer3 is disabled,1: Timer3 is enabled"

            rgroup.long 0x34++0x03
                line.long 0x00 "TIMER3EOI,Name: Timer3 End-of-Interrupt Register Size: 1 bit Address Offset: 52 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER3EOI,TimerNEOI 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER3EOI,Reading from this register returns all zeroes (0) and clears the interrupt from Timer3" "0,1"
            rgroup.long 0x38++0x03
                line.long 0x00 "TIMER3INTSTAT,Name: Timer3 Interrupt Status Register Size: 1 bit Address Offset: 56 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER3INTSTAT,TimerNIntStatus 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER3INTSTAT,Contains the interrupt status for Timer3" "0: Timer3 Interrupt is inactive,1: Timer3 Interrupt is active"

            group.long 0x3C++0x03
                line.long 0x00 "TIMER4LOADCOUNT,Name: Timer4 Load Count Register Size: 8-32 bits Address Offset: 60 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER4LOADCOUNT,Value to be loaded into Timer4"

            rgroup.long 0x40++0x03
                line.long 0x00 "TIMER4CURRENTVAL,Name: Timer4 Current Value Size: 8-32 bits Address Offset: 64 Read/Write Access: Read"
                    hexmask.long 0x00 0.--31. 1. "TIMER4CURRENTVAL,Current Value of Timer4"

            group.long 0x44++0x03
                line.long 0x00 "TIMER4CONTROLREG,Name: Timer4 Control Register Size: 4 bits Address Offset: 68 Read/Write Access: Read/Write This register controls enabling operating mode (free-running or defined-count) and interrupt mask of Timer4"
                    hexmask.long 0x00 5.--31. 1. "RSVD_TIMER4CONTROLREG,TimerNControlReg 31to5 Reserved field"
                    rbitfld.long 0x00 4. "RSVD_TIMER_0N100PWM_EN,TimerNControlReg 4 Reserved field" "0: UNKN_DESC,1: UNKN_DESC"
                    newline
                    bitfld.long 0x00 3. "TIMER_PWM,Pulse Width Modulation of timer_4_toggle output" "0: PWM for timer_4_toggle o/p is disabled,1: PWM for timer_4_toggle o/p is enabled"
                    bitfld.long 0x00 2. "TIMER_INTERRUPT_MASK,Timer interrupt mask for Timer4" "0: Timer4 interrupt is unmasked,1: Timer4 interrupt is masked"
                    newline
                    bitfld.long 0x00 1. "TIMER_MODE,Timer mode for Timer4" "0: Free Running mode of operation,1: User-Defined mode of operation"
                    bitfld.long 0x00 0. "TIMER_ENABLE,Timer enable bit for Timer4" "0: Timer4 is disabled,1: Timer4 is enabled"

            rgroup.long 0x48++0x03
                line.long 0x00 "TIMER4EOI,Name: Timer4 End-of-Interrupt Register Size: 1 bit Address Offset: 72 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER4EOI,TimerNEOI 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER4EOI,Reading from this register returns all zeroes (0) and clears the interrupt from Timer4" "0,1"
            rgroup.long 0x4C++0x03
                line.long 0x00 "TIMER4INTSTAT,Name: Timer4 Interrupt Status Register Size: 1 bit Address Offset: 76 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER4INTSTAT,TimerNIntStatus 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER4INTSTAT,Contains the interrupt status for Timer4" "0: Timer4 Interrupt is inactive,1: Timer4 Interrupt is active"

            group.long 0x50++0x03
                line.long 0x00 "TIMER5LOADCOUNT,Name: Timer5 Load Count Register Size: 8-32 bits Address Offset: 80 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER5LOADCOUNT,Value to be loaded into Timer5"

            rgroup.long 0x54++0x03
                line.long 0x00 "TIMER5CURRENTVAL,Name: Timer5 Current Value Size: 8-32 bits Address Offset: 84 Read/Write Access: Read"
                    hexmask.long 0x00 0.--31. 1. "TIMER5CURRENTVAL,Current Value of Timer5"

            group.long 0x58++0x03
                line.long 0x00 "TIMER5CONTROLREG,Name: Timer5 Control Register Size: 4 bits Address Offset: 88 Read/Write Access: Read/Write This register controls enabling operating mode (free-running or defined-count) and interrupt mask of Timer5"
                    hexmask.long 0x00 5.--31. 1. "RSVD_TIMER5CONTROLREG,TimerNControlReg 31to5 Reserved field"
                    rbitfld.long 0x00 4. "RSVD_TIMER_0N100PWM_EN,TimerNControlReg 4 Reserved field" "0: UNKN_DESC,1: UNKN_DESC"
                    newline
                    bitfld.long 0x00 3. "TIMER_PWM,Pulse Width Modulation of timer_5_toggle output" "0: PWM for timer_5_toggle o/p is disabled,1: PWM for timer_5_toggle o/p is enabled"
                    bitfld.long 0x00 2. "TIMER_INTERRUPT_MASK,Timer interrupt mask for Timer5" "0: Timer5 interrupt is unmasked,1: Timer5 interrupt is masked"
                    newline
                    bitfld.long 0x00 1. "TIMER_MODE,Timer mode for Timer5" "0: Free Running mode of operation,1: User-Defined mode of operation"
                    bitfld.long 0x00 0. "TIMER_ENABLE,Timer enable bit for Timer5" "0: Timer5 is disabled,1: Timer5 is enabled"

            rgroup.long 0x5C++0x03
                line.long 0x00 "TIMER5EOI,Name: Timer5 End-of-Interrupt Register Size: 1 bit Address Offset: 92 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER5EOI,TimerNEOI 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER5EOI,Reading from this register returns all zeroes (0) and clears the interrupt from Timer5" "0,1"
            rgroup.long 0x60++0x03
                line.long 0x00 "TIMER5INTSTAT,Name: Timer5 Interrupt Status Register Size: 1 bit Address Offset: 96 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER5INTSTAT,TimerNIntStatus 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER5INTSTAT,Contains the interrupt status for Timer5" "0: Timer5 Interrupt is inactive,1: Timer5 Interrupt is active"

            group.long 0x64++0x03
                line.long 0x00 "TIMER6LOADCOUNT,Name: Timer6 Load Count Register Size: 8-32 bits Address Offset: 100 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER6LOADCOUNT,Value to be loaded into Timer6"

            rgroup.long 0x68++0x03
                line.long 0x00 "TIMER6CURRENTVAL,Name: Timer6 Current Value Size: 8-32 bits Address Offset: 104 Read/Write Access: Read"
                    hexmask.long 0x00 0.--31. 1. "TIMER6CURRENTVAL,Current Value of Timer6"

            group.long 0x6C++0x03
                line.long 0x00 "TIMER6CONTROLREG,Name: Timer6 Control Register Size: 4 bits Address Offset: 108 Read/Write Access: Read/Write This register controls enabling operating mode (free-running or defined-count) and interrupt mask of Timer6"
                    hexmask.long 0x00 5.--31. 1. "RSVD_TIMER6CONTROLREG,TimerNControlReg 31to5 Reserved field"
                    rbitfld.long 0x00 4. "RSVD_TIMER_0N100PWM_EN,TimerNControlReg 4 Reserved field" "0: UNKN_DESC,1: UNKN_DESC"
                    newline
                    bitfld.long 0x00 3. "TIMER_PWM,Pulse Width Modulation of timer_6_toggle output" "0: PWM for timer_6_toggle o/p is disabled,1: PWM for timer_6_toggle o/p is enabled"
                    bitfld.long 0x00 2. "TIMER_INTERRUPT_MASK,Timer interrupt mask for Timer6" "0: Timer6 interrupt is unmasked,1: Timer6 interrupt is masked"
                    newline
                    bitfld.long 0x00 1. "TIMER_MODE,Timer mode for Timer6" "0: Free Running mode of operation,1: User-Defined mode of operation"
                    bitfld.long 0x00 0. "TIMER_ENABLE,Timer enable bit for Timer6" "0: Timer6 is disabled,1: Timer6 is enabled"

            rgroup.long 0x70++0x03
                line.long 0x00 "TIMER6EOI,Name: Timer6 End-of-Interrupt Register Size: 1 bit Address Offset: 112 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER6EOI,TimerNEOI 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER6EOI,Reading from this register returns all zeroes (0) and clears the interrupt from Timer6" "0,1"
            rgroup.long 0x74++0x03
                line.long 0x00 "TIMER6INTSTAT,Name: Timer6 Interrupt Status Register Size: 1 bit Address Offset: 116 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER6INTSTAT,TimerNIntStatus 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER6INTSTAT,Contains the interrupt status for Timer6" "0: Timer6 Interrupt is inactive,1: Timer6 Interrupt is active"

            group.long 0x78++0x03
                line.long 0x00 "TIMER7LOADCOUNT,Name: Timer7 Load Count Register Size: 8-32 bits Address Offset: 120 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER7LOADCOUNT,Value to be loaded into Timer7"

            rgroup.long 0x7C++0x03
                line.long 0x00 "TIMER7CURRENTVAL,Name: Timer7 Current Value Size: 8-32 bits Address Offset: 124 Read/Write Access: Read"
                    hexmask.long 0x00 0.--31. 1. "TIMER7CURRENTVAL,Current Value of Timer7"

            group.long 0x80++0x03
                line.long 0x00 "TIMER7CONTROLREG,Name: Timer7 Control Register Size: 4 bits Address Offset: 128 Read/Write Access: Read/Write This register controls enabling operating mode (free-running or defined-count) and interrupt mask of Timer7"
                    hexmask.long 0x00 5.--31. 1. "RSVD_TIMER7CONTROLREG,TimerNControlReg 31to5 Reserved field"
                    rbitfld.long 0x00 4. "RSVD_TIMER_0N100PWM_EN,TimerNControlReg 4 Reserved field" "0: UNKN_DESC,1: UNKN_DESC"
                    newline
                    bitfld.long 0x00 3. "TIMER_PWM,Pulse Width Modulation of timer_7_toggle output" "0: PWM for timer_7_toggle o/p is disabled,1: PWM for timer_7_toggle o/p is enabled"
                    bitfld.long 0x00 2. "TIMER_INTERRUPT_MASK,Timer interrupt mask for Timer7" "0: Timer7 interrupt is unmasked,1: Timer7 interrupt is masked"
                    newline
                    bitfld.long 0x00 1. "TIMER_MODE,Timer mode for Timer7" "0: Free Running mode of operation,1: User-Defined mode of operation"
                    bitfld.long 0x00 0. "TIMER_ENABLE,Timer enable bit for Timer7" "0: Timer7 is disabled,1: Timer7 is enabled"

            rgroup.long 0x84++0x03
                line.long 0x00 "TIMER7EOI,Name: Timer7 End-of-Interrupt Register Size: 1 bit Address Offset: 132 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER7EOI,TimerNEOI 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER7EOI,Reading from this register returns all zeroes (0) and clears the interrupt from Timer7" "0,1"
            rgroup.long 0x88++0x03
                line.long 0x00 "TIMER7INTSTAT,Name: Timer7 Interrupt Status Register Size: 1 bit Address Offset: 136 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER7INTSTAT,TimerNIntStatus 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER7INTSTAT,Contains the interrupt status for Timer7" "0: Timer7 Interrupt is inactive,1: Timer7 Interrupt is active"

            group.long 0x8C++0x03
                line.long 0x00 "TIMER8LOADCOUNT,Name: Timer8 Load Count Register Size: 8-32 bits Address Offset: 140 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER8LOADCOUNT,Value to be loaded into Timer8"

            rgroup.long 0x90++0x03
                line.long 0x00 "TIMER8CURRENTVAL,Name: Timer8 Current Value Size: 8-32 bits Address Offset: 144 Read/Write Access: Read"
                    hexmask.long 0x00 0.--31. 1. "TIMER8CURRENTVAL,Current Value of Timer8"

            group.long 0x94++0x03
                line.long 0x00 "TIMER8CONTROLREG,Name: Timer8 Control Register Size: 4 bits Address Offset: 148 Read/Write Access: Read/Write This register controls enabling operating mode (free-running or defined-count) and interrupt mask of Timer8"
                    hexmask.long 0x00 5.--31. 1. "RSVD_TIMER8CONTROLREG,TimerNControlReg 31to5 Reserved field"
                    rbitfld.long 0x00 4. "RSVD_TIMER_0N100PWM_EN,TimerNControlReg 4 Reserved field" "0: UNKN_DESC,1: UNKN_DESC"
                    newline
                    bitfld.long 0x00 3. "TIMER_PWM,Pulse Width Modulation of timer_8_toggle output" "0: PWM for timer_8_toggle o/p is disabled,1: PWM for timer_8_toggle o/p is enabled"
                    bitfld.long 0x00 2. "TIMER_INTERRUPT_MASK,Timer interrupt mask for Timer8" "0: Timer8 interrupt is unmasked,1: Timer8 interrupt is masked"
                    newline
                    bitfld.long 0x00 1. "TIMER_MODE,Timer mode for Timer8" "0: Free Running mode of operation,1: User-Defined mode of operation"
                    bitfld.long 0x00 0. "TIMER_ENABLE,Timer enable bit for Timer8" "0: Timer8 is disabled,1: Timer8 is enabled"

            rgroup.long 0x98++0x03
                line.long 0x00 "TIMER8EOI,Name: Timer8 End-of-Interrupt Register Size: 1 bit Address Offset: 152 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER8EOI,TimerNEOI 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER8EOI,Reading from this register returns all zeroes (0) and clears the interrupt from Timer8" "0,1"
            rgroup.long 0x9C++0x03
                line.long 0x00 "TIMER8INTSTAT,Name: Timer8 Interrupt Status Register Size: 1 bit Address Offset: 156 Read/Write Access: Read"
                    hexmask.long 0x00 1.--31. 1. "RSVD_TIMER8INTSTAT,TimerNIntStatus 31to1 Reserved field"
                    bitfld.long 0x00 0. "TIMER8INTSTAT,Contains the interrupt status for Timer8" "0: Timer8 Interrupt is inactive,1: Timer8 Interrupt is active"
            rgroup.long 0xA0++0x03
                line.long 0x00 "TimersIntStatus,Contains the interrupt status of all timers in the component"
                    hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_TimersIntStatus,TimersIntStatus 31toNUM_TIMERS Reserved field"
                    hexmask.long.byte 0x00 0.--7. 1. "TimersIntStatus,Contains the interrupt status of all timers in the component"
            rgroup.long 0xA4++0x03
                line.long 0x00 "TimersEOI,Returns all zeroes (0) and clears all active interrupts"
                    hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_TIMERSEOI,TimersEOI 31toNUM_TIMERS Reserved field"
                    hexmask.long.byte 0x00 0.--7. 1. "TIMERSEOI,Reading this register returns all zeroes (0) and clears all active interrupts"
            rgroup.long 0xA8++0x03
                line.long 0x00 "TimersRawIntStatus,Contains the unmasked interrupt status of all timers in the component"
                    hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_TIMERSRAWINTSTAT,TimersRawIntStatus 31toNUM_TIMERS Reserved field"
                    hexmask.long.byte 0x00 0.--7. 1. "TIMERSRAWINTSTAT,The register contains the unmasked interrupt status of all timers in the component"
            rgroup.long 0xAC++0x03
                line.long 0x00 "TIMERS_COMP_VERSION,Current revision number of the DW_apb_timers component"
                    hexmask.long 0x00 0.--31. 1. "TIMERSCOMPVERSION,Current revision number of the DW_apb_timers component.For the value see the releases table in the AMBA 2 release notes"

            group.long 0xB0++0x03
                line.long 0x00 "TIMER1LOADCOUNT2,Value to be loaded into Timer N when toggle output changes from 0 to 1"
                    hexmask.long 0x00 0.--31. 1. "TIMERNLOADCOUNT2,Value to be loaded into Timer N when timer_N_toggle output changes from 0 to 1"
            group.long 0xB4++0x03
                line.long 0x00 "TIMER2LOADCOUNT2,Name: Timer2 Load Count2 Register Size: 8-32 bits Address Offset: 180 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER2LOADCOUNT2,Value to be loaded into Timer2 when timer_2_toggle output changes from 0 to 1"
            group.long 0xB8++0x03
                line.long 0x00 "TIMER3LOADCOUNT2,Name: Timer3 Load Count2 Register Size: 8-32 bits Address Offset: 184 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER3LOADCOUNT2,Value to be loaded into Timer3 when timer_3_toggle output changes from 0 to 1"
            group.long 0xBC++0x03
                line.long 0x00 "TIMER4LOADCOUNT2,Name: Timer4 Load Count2 Register Size: 8-32 bits Address Offset: 188 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER4LOADCOUNT2,Value to be loaded into Timer4 when timer_4_toggle output changes from 0 to 1"
            group.long 0xC0++0x03
                line.long 0x00 "TIMER5LOADCOUNT2,Name: Timer5 Load Count2 Register Size: 8-32 bits Address Offset: 192 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER5LOADCOUNT2,Value to be loaded into Timer5 when timer_5_toggle output changes from 0 to 1"
            group.long 0xC4++0x03
                line.long 0x00 "TIMER6LOADCOUNT2,Name: Timer6 Load Count2 Register Size: 8-32 bits Address Offset: 196 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER6LOADCOUNT2,Value to be loaded into Timer6 when timer_6_toggle output changes from 0 to 1"
            group.long 0xC8++0x03
                line.long 0x00 "TIMER7LOADCOUNT2,Name: Timer7 Load Count2 Register Size: 8-32 bits Address Offset: 200 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER7LOADCOUNT2,Value to be loaded into Timer7 when timer_7_toggle output changes from 0 to 1"
            group.long 0xCC++0x03
                line.long 0x00 "TIMER8LOADCOUNT2,Name: Timer8 Load Count2 Register Size: 8-32 bits Address Offset: 204 Read/Write Access: Read/"
                    hexmask.long 0x00 0.--31. 1. "TIMER8LOADCOUNT2,Value to be loaded into Timer8 when timer_8_toggle output changes from 0 to 1"
        tree.end
    repeat.end
tree.end

tree "UART (Universal Asynchronous Receiver/Transmitter)"
    base ad:0x91924000
    rgroup.long 0x00++0x03
        line.long 0x00 "RBR,Receive Buffer Register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_RBR,RBR 31to9or8 Reserved bits and read as zero (0)"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "RBR,Receive Buffer Register"

    group.long 0x04++0x03
        line.long 0x00 "IER,Interrupt Enable Register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_IER_31to8,IER 31to8 Reserved bits and read as zero (0)"
            newline
            bitfld.long 0x00 7. "PTIME,Programmable THRE Interrupt Mode Enable" "0: Disable Programmable THRE Interrupt Mode,1: Enable Programmable THRE Interrupt Mode"
            newline
            rbitfld.long 0x00 5.--6. "RSVD_IER_6to5,IER 6to5 Reserved bits read as zero (0)" "0,1,2,3"
            newline
            rbitfld.long 0x00 4. "ELCOLR,Interrupt Enable Register: ELCOLR this bit controls the method for clearing the status in the LSR register" "0: Disable ALC,1: Enable ALC"
            newline
            bitfld.long 0x00 3. "EDSSI,Enable Modem Status Interrupt" "0: Disable Modem Status Interrupt,1: Enable Modem Status Interrupt"
            newline
            bitfld.long 0x00 2. "ELSI,Enable Receiver Line Status Interrupt" "0: Disable Receiver Line Status Interrupt,1: Enable Receiver Line Status Interrupt"
            newline
            bitfld.long 0x00 1. "ETBEI,Enable Transmit Holding Register Empty Interrupt" "0: Disable Transmit empty interrupt,1: Enable Transmit empty interrupt"
            newline
            bitfld.long 0x00 0. "ERBFI,Enable Received Data Available Interrupt" "0: Disable Receive data Interrupt,1: Enable Receive data Interrupt"

    rgroup.long 0x08++0x03
        line.long 0x00 "IIR,Interrupt Identification Register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_IIR_31to8,IIR 31to8 Reserved bits and read as 0"
            newline
            bitfld.long 0x00 6.--7. "FIFOSE,FIFOs Enabled" "0: FIFOs are disabled,?,?,3: FIFOs are enabled"
            newline
            bitfld.long 0x00 4.--5. "RSVD_IIR_5to4,IIR 5to4 Reserved bits read as 0" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--3. "IID,Interrupt ID (or IID)" "0: MODEM_STATUS,1: NO_INTERRUPT_PENDING,2: THR_EMPTY,?,4: RECEIVED_DATA_AVAILABLE,?,6: RECEIVER_LINE_STATUS,7: BUSY_DETECT,?,?,?,?,12: CHARACTER_TIMEOUT,?..."

    group.long 0x0C++0x03
        line.long 0x00 "LCR,Line Control Register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_LCR_31to8,LCR 31to8 Reserved bits and read as 0"
            newline
            bitfld.long 0x00 7. "DLAB,Divisor Latch Access Bit" "0: Divisor Latch register is writable only when..,1: Divisor Latch register is always readable and.."
            newline
            bitfld.long 0x00 6. "BC,Break Control Bit" "0: Serial output is released for data transmission,1: Serial output is forced to spacing state"
            newline
            bitfld.long 0x00 5. "SP,Stick Parity" "0: Stick parity disabled,1: Stick parity enabled"
            newline
            bitfld.long 0x00 4. "EPS,Even Parity Select" "0: an odd parity is transmitted or checked,1: an even parity is transmitted or checked"
            newline
            bitfld.long 0x00 3. "PEN,Parity Enable" "0: disable parity,1: enable parity"
            newline
            bitfld.long 0x00 2. "STOP,Number of stop bits" "0: 1 stop bit,1: 1.5 stop bits when DLS (LCR[1:0]) is zero.."
            newline
            bitfld.long 0x00 0.--1. "DLS,Data Length Select (or CLS as used in legacy)" "0: 5 data bits per character,1: 6 data bits per character,2: 7 data bits per character,3: 8 data bits per character"
    group.long 0x10++0x03
        line.long 0x00 "MCR,Modem Control Register"
            hexmask.long 0x00 7.--31. 1. "RSVD_MCR_31to7,MCR 31to7 Reserved bits read as 0"
            newline
            rbitfld.long 0x00 6. "SIRE,SIR Mode Enable Writeable only when SIR_MODE == Enabled always readable" "0: IrDA SIR Mode disabled,1: IrDA SIR Mode enabled"
            newline
            rbitfld.long 0x00 5. "AFCE,Auto Flow Control Enable Writeable only when AFCE_MODE == Enabled always readable" "0: Auto Flow Control Mode disabled,1: Auto Flow Control Mode enabled"
            newline
            bitfld.long 0x00 4. "LoopBack,LoopBack Bit This is used to put the UART into a diagnostic mode for test purposes" "0: Loopback mode disabled,1: Loopback mode enabled"
            newline
            bitfld.long 0x00 3. "OUT2,OUT2 This is used to directly control the user-designated Output2 (out2_n) output" "0: out2_n de-asserted (logic 1),1: out2_n asserted (logic 0)"
            newline
            bitfld.long 0x00 2. "OUT1,OUT1 This is used to directly control the user-designated Output1 (out1_n) output" "0: out1_n de-asserted (logic 1),1: out1_n asserted (logic 0)"
            newline
            bitfld.long 0x00 1. "RTS,Request to Send" "0: Request to Send rts_n de-asserted (logic 1),1: Request to Send rts_n asserted (logic 0)"
            newline
            bitfld.long 0x00 0. "DTR,Data Terminal Ready" "0: dtr_n de-asserted (logic1),1: dtr_n asserted (logic 0)"

    rgroup.long 0x14++0x03
        line.long 0x00 "LSR,Line Status Register"
            hexmask.long.tbyte 0x00 9.--31. 1. "RSVD_LSR_31to9,LSR 31to9 Reserved bits read as zero"
            newline
            bitfld.long 0x00 8. "RSVD_ADDR_RCVD,lSR 8 Reserved bit for UART_9BIT_DATA_EN" "0,1"
            newline
            bitfld.long 0x00 7. "RFE,Receiver FIFO Error bit" "0: No error in RX FIFO,1: Error in RX FIFO"
            newline
            bitfld.long 0x00 6. "TEMT,Transmitter Empty bit" "0: Transmitter not empty,1: Transmitter empty"
            newline
            bitfld.long 0x00 5. "THRE,Transmit Holding Register Empty bit" "0: THRE interrupt control is disabled,1: THRE interrupt control is enabled"
            newline
            bitfld.long 0x00 4. "BI,Break Interrupt bit" "0: No break sequence detected,1: Break sequence detected"
            newline
            bitfld.long 0x00 3. "FE,Framing Error bit" "0: NO_FRAMING_ERROR,1: FRAMING_ERROR"
            newline
            bitfld.long 0x00 2. "PE,Parity Error bit" "0: NO_PARITY_ERROR,1: PARITY_ERROR"
            newline
            bitfld.long 0x00 1. "OE,Overrun error bit" "0: NO_OVER_RUN_ERROR,1: OVER_RUN_ERROR"
            newline
            bitfld.long 0x00 0. "DR,Data Ready bit" "0: data not ready,1: data ready"
    rgroup.long 0x18++0x03
        line.long 0x00 "MSR,Whenever bits 0 1 2 or 3 is set to logic one to indicate a change on the modem control inputs a modem status interrupt will be generated if enabled via the IER regardless of when the change occurred"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_MSR_31to8,MSR 31to8 Reserved bits read as 0"
            newline
            bitfld.long 0x00 7. "DCD,Data Carrier Detect" "0: dcd_n input is de-asserted (logic 1),1: dcd_n input is asserted (logic 0)"
            newline
            bitfld.long 0x00 6. "RI,Ring Indicator" "0: ri_n input is de-asserted (logic 1),1: ri_n input is asserted (logic 0)"
            newline
            bitfld.long 0x00 5. "DSR,Data Set Ready" "0: dsr_n input is de-asserted (logic 1),1: dsr_n input is asserted (logic 0)"
            newline
            bitfld.long 0x00 4. "CTS,Clear to Send" "0: cts_n input is de-asserted (logic 1),1: cts_n input is asserted (logic 0)"
            newline
            bitfld.long 0x00 3. "DDCD,Delta Data Carrier Detect" "0: No change on dcd_n since last read of MSR,1: change on dcd_n since last read of MSR"
            newline
            bitfld.long 0x00 2. "TERI,Trailing Edge of Ring Indicator" "0: no change on ri_n since last read of MSR,1: change on ri_n since last read of MSR"
            newline
            bitfld.long 0x00 1. "DDSR,Delta Data Set Ready" "0: no change on dsr_n since last read of MSR,1: change on dsr_n since last read of MSR"
            newline
            bitfld.long 0x00 0. "DCTS,Delta Clear to Send" "0: no change on cts_n since last read of MSR,1: change on cts_n since last read of MSR"

    group.long 0x1C++0x03
        line.long 0x00 "SCR,Scratchpad Register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SCR_31to8,SCR 31to8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SCR,This register is for programmers to use as a temporary storage space"

    rgroup.long 0x30++0x03
        line.long 0x00 "SRBR0,This register is valid only when the DW_apb_uart is configured to have additional shadow registers implemented (SHADOW = YES)"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBRn,SRBR0 31 to SRBRN_REG_SIZE Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBRn,Shadow Receive Buffer Register n"
    rgroup.long 0x34++0x03
        line.long 0x00 "SRBR1,Shadow Receive Buffer Register 1"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR1,SRBR1 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR1,See SRBR0 description"
    rgroup.long 0x38++0x03
        line.long 0x00 "SRBR2,Shadow Receive Buffer Register 2"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR2,SRBR2 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR2,See SRBR0 description"
    rgroup.long 0x3C++0x03
        line.long 0x00 "SRBR3,Shadow Receive Buffer Register 3"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR3,SRBR3 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR3,See SRBR0 description"
    rgroup.long 0x40++0x03
        line.long 0x00 "SRBR4,Shadow Receive Buffer Register 4"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR4,SRBR4 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR4,See SRBR0 description"
    rgroup.long 0x44++0x03
        line.long 0x00 "SRBR5,Shadow Receive Buffer Register 5"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR5,SRBR5 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR5,See SRBR0 description"
    rgroup.long 0x48++0x03
        line.long 0x00 "SRBR6,Shadow Receive Buffer Register 6"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR6,SRBR6 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR6,See SRBR0 description"
    rgroup.long 0x4C++0x03
        line.long 0x00 "SRBR7,Shadow Receive Buffer Register 7"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR7,SRBR7 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR7,See SRBR0 description"
    rgroup.long 0x50++0x03
        line.long 0x00 "SRBR8,Shadow Receive Buffer Register 8"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR8,SRBR8 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR8,See SRBR0 description"
    rgroup.long 0x54++0x03
        line.long 0x00 "SRBR9,Shadow Receive Buffer Register 9"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR9,SRBR9 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR9,See SRBR0 description"
    rgroup.long 0x58++0x03
        line.long 0x00 "SRBR10,Shadow Receive Buffer Register 10"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR10,SRBR10 31to9or8 Reserved bi read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR10,See SRBR0 description"
    rgroup.long 0x5C++0x03
        line.long 0x00 "SRBR11,Shadow Receive Buffer Register 11"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR11,SRBR11 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR11,See SRBR0 description"
    rgroup.long 0x60++0x03
        line.long 0x00 "SRBR12,Shadow Receive Buffer Register 12"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR12,SRBR12 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR12,See SRBR0 description"
    rgroup.long 0x64++0x03
        line.long 0x00 "SRBR13,Shadow Receive Buffer Register 13"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR13,SRBR13 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR13,See SRBR0 description"
    rgroup.long 0x68++0x03
        line.long 0x00 "SRBR14,Shadow Receive Buffer Register 14"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR14,SRBR14 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR14,See SRBR0 description"
    rgroup.long 0x6C++0x03
        line.long 0x00 "SRBR15,Shadow Receive Buffer Register 15"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_SRBR15,SRBR15 31to9or8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SRBR15,See SRBR0 description"

    group.long 0x70++0x03
        line.long 0x00 "FAR,FIFO Access Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_FAR_31to1,FAR 31to1 Reserved bits read as 0"
            newline
            bitfld.long 0x00 0. "FAR,Writes will have no effect when FIFO_ACCESS == No always readable" "0: FIFO access mode disabled,1: FIFO access mode enabled"

    rgroup.long 0x74++0x03
        line.long 0x00 "TFR,This register is valid only when the DW_apb_uart is configured to have the FIFO access test mode available (FIFO_ACCESS = YES)"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_TFR_31to8,TFR 31to8 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "TFR,Transmit FIFO"

    group.long 0x78++0x03
        line.long 0x00 "RFW,This register is valid only when the DW_apb_uart is configured to have the FIFO access test mode available (FIFO_ACCESS = YES)"
            hexmask.long.tbyte 0x00 10.--31. 1. "RSVD_RFW_31to10,RFW 31to10 Reserved bits read as 0"
            newline
            bitfld.long 0x00 9. "RFFE,Receive FIFO Framing Error" "0: Frame error disabled,1: Frame error enabled"
            newline
            bitfld.long 0x00 8. "RFPE,Receive FIFO Parity Error" "0: Parity error disabled,1: Parity error enabled"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "RFWD,Receive FIFO Write Data"

    rgroup.long 0x7C++0x03
        line.long 0x00 "USR,UART Status register"
            hexmask.long 0x00 5.--31. 1. "RSVD_USR_31to5,USR 31to5 Reserved bits read as 0"
            newline
            bitfld.long 0x00 4. "RFF,Receive FIFO Full" "0: Receive FIFO not full,1: Receive FIFO full"
            newline
            bitfld.long 0x00 3. "RFNE,Receive FIFO Not Empty" "0: Receive FIFO is empty,1: Receive FIFO is not empty"
            newline
            bitfld.long 0x00 2. "TFE,Transmit FIFO Empty" "0: Transmit FIFO is not empty,1: Transmit FIFO is empty"
            newline
            bitfld.long 0x00 1. "TFNF,Transmit FIFO Not Full" "0: Transmit FIFO is full,1: Transmit FIFO is not full"
            newline
            bitfld.long 0x00 0. "BUSY,UART Busy" "0: DW_apb_uart is idle or inactive,1: DW_apb_uart is busy (actively transferring.."
    rgroup.long 0x80++0x03
        line.long 0x00 "TFL,TFL register is valid only when the DW_apb_uart is configured to have additional FIFO status registers implemented (FIFO_STAT = YES)"
            hexmask.long 0x00 6.--31. 1. "RSVD_TFL_31toADDR_WIDTH,TFL 31 to ADDR_WIDTH Reserved bits read as 0"
            newline
            bitfld.long 0x00 0.--5. "tfl,Transmit FIFO Level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    rgroup.long 0x84++0x03
        line.long 0x00 "RFL,RFL register is valid only when the DW_apb_uart is configured to have additional FIFO status registers implemented (FIFO_STAT = YES)"
            hexmask.long 0x00 6.--31. 1. "RSVD_RFL_31toADDR_WIDTH,RFL 31 to ADDR_WIDTH Reserved bits read as 0"
            newline
            bitfld.long 0x00 0.--5. "rfl,Receive FIFO Level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"

    group.long 0x88++0x03
        line.long 0x00 "SRR,This register is valid only when the DW_apb_uart is configured to have additional shadow registers implemented (SHADOW = YES)"
            hexmask.long 0x00 3.--31. 1. "RSVD_SRR_31to3,SRR 31to3 Reserved bits read as 0"
            newline
            bitfld.long 0x00 2. "XFR,XMIT FIFO Reset" "0,1"
            newline
            bitfld.long 0x00 1. "RFR,RCVR FIFO Reset" "0,1"
            newline
            bitfld.long 0x00 0. "UR,UART Reset" "0: No Uart Reset,1: Uart reset"
    group.long 0x8C++0x03
        line.long 0x00 "SRTS,SRTS register is valid only when the DW_apb_uart is configured to have additional shadow registers implemented (SHADOW = YES)"
            hexmask.long 0x00 1.--31. 1. "RSVD_SRTS_31to1,SRTS 31to1 Reserved bits read as 0"
            newline
            bitfld.long 0x00 0. "SRTS,Shadow Request to Send" "0: Shadow Request to Send uart_rts_n logic1,1: Shadow Request to Send uart_rts_n logic0"
    group.long 0x90++0x03
        line.long 0x00 "SBCR,SBCR register is valid only when the DW_apb_uart is configured to have additional shadow registers implemented (SHADOW = YES)"
            hexmask.long 0x00 1.--31. 1. "RSVD_SBCR_31to1,SBCR 31to1 Reserved bits read as 0"
            newline
            bitfld.long 0x00 0. "SBCB,Shadow Break Control Bit" "0: No spacing on serial output,1: Serial output forced to the spacing"
    group.long 0x94++0x03
        line.long 0x00 "SDMAM,This register is valid only when the DW_apb_uart is configured to have additional FIFO registers implemented (FIFO_MODE != None) and additional shadow registers implemented (SHADOW = YES)"
            hexmask.long 0x00 1.--31. 1. "RSVD_SDMAM_31to1,SDMAM 31to1 Reserved bits read as 0"
            newline
            bitfld.long 0x00 0. "SDMAM,Shadow DMA Mode" "0: MODE_0,1: MODE_1"
    group.long 0x98++0x03
        line.long 0x00 "SFE,SFE register is valid only when the DW_apb_uart is configured to have additional FIFO registers implemented (FIFO_MODE != None) and additional shadow registers implemented (SHADOW = YES)"
            hexmask.long 0x00 1.--31. 1. "RSVD_SFE_31to1,SFE 31to1 Reserved bits read as 0"
            newline
            bitfld.long 0x00 0. "SFE,Shadow FIFO Enable" "0: FIFOs are disabled,1: FIFOs are enabled"
    group.long 0x9C++0x03
        line.long 0x00 "SRT,SRT register is valid only when the DW_apb_uart is configured to have additional FIFO registers implemented (FIFO_MODE != None) and additional shadow registers implemented (SHADOW = YES)"
            hexmask.long 0x00 2.--31. 1. "RSVD_SRT_31to2,SRT 31to2 Reserved bits read as 0"
            newline
            bitfld.long 0x00 0.--1. "SRT,Shadow RCVR Trigger" "0: 1 character in FIFO,1: FIFO_QUARTER_FULL,2: FIFO_HALF_FULL,3: FIFO 2 less than full"
    group.long 0xA0++0x03
        line.long 0x00 "STET,This register is valid only when the DW_apb_uart is configured to have FIFOs implemented (FIFO_MODE != NONE) and THRE interrupt support implemented (THRE_MODE_USER = Enabled) and additional shadow registers implemented (SHADOW = YES)"
            hexmask.long 0x00 2.--31. 1. "RSVD_STET_31to2,STET 31to2 Reserved bits read as 0"
            newline
            bitfld.long 0x00 0.--1. "STET,Shadow TX Empty Trigger" "0: FIFO_EMPTY,1: 2 characters in FIFO,2: FIFO_QUARTER_FULL,3: FIFO_HALF_FULL"
    group.long 0xA4++0x03
        line.long 0x00 "HTX,Halt TX"
            hexmask.long 0x00 1.--31. 1. "RSVD_HTX_31to1,HTX 31to1 Reserved bits read as 0"
            newline
            bitfld.long 0x00 0. "HTX,Halt TX" "0: Halt Transmission disabled,1: Halt Transmission enabled"
    group.long 0xA8++0x03
        line.long 0x00 "DMASA,DMA Software Acknowledge Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_DMASA_31to1,DMASA 31to1 Reserved bits read as 0"
            newline
            bitfld.long 0x00 0. "DMASA,DMA Software Acknowledge" "?,1: DMA software acknowledge"
    group.long 0xC0++0x03
        line.long 0x00 "DLF,This register is only valid when the DW_apb_uart is configured to have Fractional Baud rate Divisor implemented (FRACTIONAL_BAUD_DIVISOR_EN = ENABLED)"
            hexmask.long 0x00 4.--31. 1. "RSVD_DLF,DLF 31 to DLF_SIZE Reserved bits read as 0"
            newline
            bitfld.long 0x00 0.--3. "DLF,Fractional part of divisor" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0xD4++0x03
        line.long 0x00 "REG_TIMEOUT_RST,Name: Register timeout counter reset register This register keeps the reset value of reg_timer counter register"
            hexmask.long 0x00 4.--31. 1. "RSVD_REG_TIMEOUT_RST,Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0.--3. "REG_TIMEOUT_RST,This field holds reset value of REG_TIMEOUT counter register" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0xF4++0x03
        line.long 0x00 "CPR,Component Parameter Register.This register is valid only when UART_ADD_ENCODED_PARAMS = 1"
            hexmask.long.byte 0x00 24.--31. 1. "RSVD_CPR_31to24,CPR 31to24 Reserved bits read as 0"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "FIFO_MODE,Encoding of FIFO_MODE configuration parameter value"
            newline
            bitfld.long 0x00 14.--15. "RSVD_CPR_15to14,CPR 15to14 Reserved bits read as 0" "0,1,2,3"
            newline
            bitfld.long 0x00 13. "DMA_EXTRA,Encoding of DMA_EXTRA configuration parameter value" "0: DMA_EXTRA disabled,1: DMA_EXTRA enabled"
            newline
            bitfld.long 0x00 12. "UART_ADD_ENCODED_PARAMS,Encoding of UART_ADD_ENCODED_PARAMS configuration parameter value" "0: UART_ADD_ENCODED_PARAMS disabled,1: UART_ADD_ENCODED_PARAMS enabled"
            newline
            bitfld.long 0x00 11. "SHADOW,Encoding of SHADOW configuration parameter value" "0: SHADOW disabled,1: SHADOW enabled"
            newline
            bitfld.long 0x00 10. "FIFO_STAT,Encoding of FIFO_STAT configuration parameter value" "0: FIFO_STAT disabled,1: FIFO_STAT enabled"
            newline
            bitfld.long 0x00 9. "FIFO_ACCESS,Encoding of FIFO_ACCESS configuration parameter value" "0: FIFO_ACCESS disabled,1: FIFO ACCESS enabled"
            newline
            bitfld.long 0x00 8. "ADDITIONAL_FEAT,Encoding of ADDITIONAL_FEATURES configuration parameter value" "0: Additional features disabled,1: Additional features enabled"
            newline
            bitfld.long 0x00 7. "SIR_LP_MODE,Encoding of SIR_LP_MODE configuration parameter value" "0: SIR_LP mode disabled,1: SIR_LP mode enabled"
            newline
            bitfld.long 0x00 6. "SIR_MODE,Encoding of SIR_MODE configuration parameter value" "0: SIR mode disabled,1: SIR mode enabled"
            newline
            bitfld.long 0x00 5. "THRE_MODE,Encoding of THRE_MODE configuration parameter value" "0: THRE mode disabled,1: THRE mode enabled"
            newline
            bitfld.long 0x00 4. "AFCE_MODE,Encoding of AFCE_MODE configuration parameter value" "0: AFCE mode disabled,1: AFCE mode enabled"
            newline
            bitfld.long 0x00 2.--3. "RSVD_CPR_3to2,CPR 3to2 Reserved bits read as 0" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--1. "APB_DATA_WIDTH,Encoding of APB_DATA_WIDTH configuration parameter value" "0: APB data width is 8 bits,1: APB data width is 16 bits,2: APB data width is 32 bits,?..."
    rgroup.long 0xF8++0x03
        line.long 0x00 "UCV,UCV register is valid only when the DW_apb_uart is configured to have additional features implemented (ADDITIONAL_FEATURES = YES)"
            hexmask.long 0x00 0.--31. 1. "UART_Component_Version,ASCII value for each number in the version followed by *"
    rgroup.long 0xFC++0x03
        line.long 0x00 "CTR,CTR is register is valid only when the DW_apb_uart is configured to have additional features implemented (ADDITIONAL_FEATURES = YES)"
            hexmask.long 0x00 0.--31. 1. "Peripheral_ID,This register contains the peripherals identification code"
tree.end

tree "WDT (Watchdog Timer Unit)"
    repeat 4. (list 0. 1. 2. 3.) (list ad:0x9192C000 ad:0x9192D000 ad:0x9192E000 ad:0x9192F000)
        tree "WDT$1"
            base $2
            group.long 0x00++0x03
                line.long 0x00 "WDT_CR,Control Register"
                    hexmask.long 0x00 6.--31. 1. "RSVD_WDT_CR,WDT_CR[31:6] Reserved bits and read as zero (0)"
                    newline
                    bitfld.long 0x00 5. "NO_NAME,Redundant R/W bit" "0,1"
                    newline
                    bitfld.long 0x00 2.--4. "RPL,Reset pulse length" "0: PCLK_CYCLES_2,1: PCLK_CYCLES_4,2: PCLK_CYCLES_8,3: PCLK_CYCLES_16,4: PCLK_CYCLES_32,5: PCLK_CYCLES_64,6: PCLK_CYCLES_128,7: PCLK_CYCLES_256"
                    newline
                    bitfld.long 0x00 1. "RMOD,Response mode" "0: Generate a system reset,1: First generate an interrupt and even if it is.."
                    newline
                    bitfld.long 0x00 0. "WDT_EN,WDT enable" "0: Watchdog timer disabled,1: Watchdog timer enabled"
            group.long 0x04++0x03
                line.long 0x00 "WDT_TORR,Timeout Range Register"
                    hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_WDT_TORR,WDT_TORR[31:8] Reserved and read as zero (0)"
                    newline
                    rbitfld.long 0x00 4.--7. "RSVD_TOP_INIT,WDT_TORR[7:4] Reserved field for TOP_INIT" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
                    newline
                    bitfld.long 0x00 0.--3. "TOP,Timeout period" "0: Time out of WDT_USER_TOP_0 or 64K Clocks,1: Time out of WDT_USER_TOP_1 or 128K Clocks,2: Time out of WDT_USER_TOP_2 or 256K Clocks,3: Time out of WDT_USER_TOP_3 or 512K Clocks,4: Time out of WDT_USER_TOP_4 or 1M Clocks,5: Time out of WDT_USER_TOP_5 or 2M Clocks,6: Time out of WDT_USER_TOP_6 or 4M Clocks,7: Time out of WDT_USER_TOP_7 or 8M Clocks,8: Time out of WDT_USER_TOP_8 or 16M Clocks,9: Time out of WDT_USER_TOP_9 or 32M Clocks,10: Time out of WDT_USER_TOP_10 or 64M Clocks,11: Time out of WDT_USER_TOP_11 or 128M Clocks,12: Time out of WDT_USER_TOP_12 or 256M Clocks,13: Time out of WDT_USER_TOP_13 or 512M Clocks,14: Time out of WDT_USER_TOP_14 or 1G Clocks,15: Time out of WDT_USER_TOP_15 or 2G Clocks"

            rgroup.long 0x08++0x03
                line.long 0x00 "WDT_CCVR,Current Counter Value Register"
                    hexmask.long 0x00 0.--31. 1. "WDT_CCVR,WDT Current Counter Value Register"

            wgroup.long 0x0C++0x03
                line.long 0x00 "WDT_CRR,Counter Restart Register"
                    hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_WDT_CRR,WDT_CRR[31:24] Reserved bits - Write Only"
                    newline
                    hexmask.long.byte 0x00 0.--7. 1. "WDT_CRR,Counter Restart Register"

            rgroup.long 0x10++0x03
                line.long 0x00 "WDT_STAT,Interrupt Status Register"
                    hexmask.long 0x00 1.--31. 1. "RSVD_WDT_STAT,WDT_STAT[31:1] Reserved bits - Read Only"
                    newline
                    bitfld.long 0x00 0. "WDT_STAT,Interrupt status register This register shows the interrupt status of the WDT" "0: Interrupt is inactive,1: Interrupt is active regardless of polarity"
            rgroup.long 0x14++0x03
                line.long 0x00 "WDT_EOI,Interrupt Clear Register"
                    hexmask.long 0x00 1.--31. 1. "RSVD_WDT_EOI,RSVD_WDT_EOI[31:1] Reserved bits and read as zero (0)"
                    newline
                    bitfld.long 0x00 0. "WDT_EOI,Interrupt Clear Register" "0,1"
            rgroup.long 0xE4++0x03
                line.long 0x00 "WDT_COMP_PARAM_5,Component Parameters Register 5 Note: This is a constant read-only register that contains encoded information about the component's parameter settings"
                    hexmask.long 0x00 0.--31. 1. "CP_WDT_USER_TOP_MAX,Upper limit of Timeout Period parameters"
            rgroup.long 0xE8++0x03
                line.long 0x00 "WDT_COMP_PARAM_4,Component Parameters Register 4 Note: This is a constant read-only register that contains encoded information about the component's parameter settings"
                    hexmask.long 0x00 0.--31. 1. "CP_WDT_USER_TOP_INIT_MAX,Upper limit of Initial Timeout Period parameters"
            rgroup.long 0xEC++0x03
                line.long 0x00 "WDT_COMP_PARAM_3,Component Parameters Register 3 Note: This is a constant read-only register that contains encoded information about the component's parameter settings"
                    hexmask.long 0x00 0.--31. 1. "CD_WDT_TOP_RST,The value of this register is derived from the WDT_TOP_RST coreConsultant parameter"
            rgroup.long 0xF0++0x03
                line.long 0x00 "WDT_COMP_PARAM_2,Component Parameters Register 2 Note: This is a constant read-only register that contains encoded information about the component's parameter settings"
                    hexmask.long 0x00 0.--31. 1. "CP_WDT_CNT_RST,The value of this register is derived from the WDT_RST_CNT coreConsultant parameter"
            rgroup.long 0xF4++0x03
                line.long 0x00 "WDT_COMP_PARAM_1,Component Parameters Register 1 Note:This is a constant read-only register that contains encoded information about the component's parameter settings"
                    bitfld.long 0x00 29.--31. "RSVD_31_29,WDT_COMP_PARAM_1[31:29]Reserved bits and read as zero (0)" "0,1,2,3,4,5,6,7"
                    newline
                    bitfld.long 0x00 24.--28. "WDT_CNT_WIDTH,The Watchdog Timer counter width" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
                    newline
                    bitfld.long 0x00 20.--23. "WDT_DFLT_TOP_INIT,Describes the initial timeout period that is available directly after reset" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
                    newline
                    bitfld.long 0x00 16.--19. "WDT_DFLT_TOP,Selects the timeout period that is available directly after reset" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
                    newline
                    bitfld.long 0x00 13.--15. "RSVD_15_13,WDT_COMP_PARAM_1[15:13] Reserved bits and read as zero (0)" "0,1,2,3,4,5,6,7"
                    newline
                    bitfld.long 0x00 10.--12. "WDT_DFLT_RPL,The reset pulse length that is available directly after reset" "0,1,2,3,4,5,6,7"
                    newline
                    bitfld.long 0x00 8.--9. "APB_DATA_WIDTH,Width of the APB Data Bus to which this component is attached" "0: APB data width is 8 bits,1: APB data width is 16 bits,2: APB data width is 32 bits,?..."
                    newline
                    bitfld.long 0x00 7. "WDT_PAUSE,Configures the peripheral to have a pause enable signal (pause) on the interface that can be used to freeze the watchdog counter during pause mode" "0: Pause enable signal is non existent,1: Pause enable signal is included"
                    newline
                    bitfld.long 0x00 6. "WDT_USE_FIX_TOP,When this parameter is set to 1 timeout period range is fixed" "0: User must define timeout values,1: Use predefined timeout values"
                    newline
                    bitfld.long 0x00 5. "WDT_HC_TOP,When set to 1 the selected timeout period(s) is set to be hard coded" "0: Timeout period is programmable,1: Timeout period is hard coded"
                    newline
                    bitfld.long 0x00 4. "WDT_HC_RPL,Configures the reset pulse length to be hard coded" "0: Reset pulse length is programmable,1: Reset pulse length is hardcoded"
                    newline
                    bitfld.long 0x00 3. "WDT_HC_RMOD,Configures the output response mode to be hard coded" "0: Output response mode is programmable,1: Output response mode is hard coded"
                    newline
                    bitfld.long 0x00 2. "WDT_DUAL_TOP,When set to 1 includes a second timeout period that is used for initialization prior to the first kick" "0: Second timeout period is not present,1: Second timeout period is present"
                    newline
                    bitfld.long 0x00 1. "WDT_DFLT_RMOD,Describes the output response mode that is available directly after reset" "0: System reset only,1: Interrupt and system reset"
                    newline
                    bitfld.long 0x00 0. "WDT_ALWAYS_EN,Configures the WDT to be enabled from reset" "0: Watchdog timer disabled on reset,1: Watchdog timer enabled on reset"
            rgroup.long 0xF8++0x03
                line.long 0x00 "WDT_COMP_VERSION,Component Version Register"
                    hexmask.long 0x00 0.--31. 1. "WDT_COMP_VERSION,ASCII value for each number in the version followed by *"
            rgroup.long 0xFC++0x03
                line.long 0x00 "WDT_COMP_TYPE,Component Type Register"
                    hexmask.long 0x00 0.--31. 1. "WDT_COMP_TYPE,Designware Component Type number = 0x44_57_01_20"
        tree.end
    repeat.end
tree.end

autoindent.off
newline
