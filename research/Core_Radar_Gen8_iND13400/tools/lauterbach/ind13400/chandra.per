            bitfld.long 0x00 24. "SPH,Split Headers" "0: Split Headers feature is disabled,1: Split Headers feature is enabled"
            newline
            rbitfld.long 0x00 21.--23. "Reserved_23_21,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 18.--20. "DSL,Descriptor Skip Length This bit specifies the Dword (64-bit) number of locations to skip between two descriptors" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 17. "Reserved_17,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "PBLx8,8xPBL mode" "0: 8xPBL mode is disabled,1: 8xPBL mode is enabled"
            newline
            rbitfld.long 0x00 14.--15. "Reserved_15_14,Reserved" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--13. 1. "Reserved_MSS,Reserved"
    group.long 0x1204++0x03
        line.long 0x00 "DMA_CH2_Tx_Control,The DMA Channel2 Transmit Control register controls the Tx features such as PBL TCP segmentation and Tx Channel weights"
            rbitfld.long 0x00 31. "Reserved_31,Reserved" "0,1"
            newline
            bitfld.long 0x00 29.--30. "TFSEL,TBS Fetch Select Select bits for one of the four DMA_TBS_CTRL register fields (FTOS FGSN FTOV) for the channel Values" "0: DMA_TBS_CTRL0,1: DMA_TBS_CTRL1,2: DMA_TBS_CTRL2,3: DMA_TBS_CTRL3 (Reserved if"
            newline
            bitfld.long 0x00 28. "EDSE,Enhanced Descriptor Enable" "0: Enhanced Descriptor is disabled,1: Enhanced Descriptor is enabled"
            newline
            bitfld.long 0x00 24.--27. "TQOS,Transmit QOS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 23. "Reserved_23,Reserved" "0,1"
            newline
            rbitfld.long 0x00 22. "Reserved_ETIC,Reserved" "0,1"
            newline
            bitfld.long 0x00 16.--21. "TxPBL,Transmit Programmable Burst Length These bits indicate the maximum number of beats to be transferred in one DMA block data transfer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 15. "IPBL,Ignore PBL Requirement" "0: Ignore PBL Requirement is disabled,1: Ignore PBL Requirement is enabled"
            newline
            bitfld.long 0x00 13.--14. "TSE_MODE,TSE Mode" "0: TSO_USO,1: UFO with Checksum,2: UFO without Checksum,?..."
            newline
            bitfld.long 0x00 12. "TSE,TCP Segmentation Enabled" "0: TCP Segmentation is disabled,1: TCP Segmentation is enabled"
            newline
            hexmask.long.byte 0x00 5.--11. 1. "Reserved_11_5,Reserved"
            newline
            bitfld.long 0x00 4. "OSF,Operate on Second Packet" "0: Operate on Second Packet disabled,1: Operate on Second Packet enabled"
            newline
            bitfld.long 0x00 1.--3. "TCW,Transmit Channel Weight This field indicates the weight assigned to the corresponding Tx channel" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0. "ST,Start or Stop Transmission Command" "0: Stop Transmission Command,1: Start Transmission Command"
    group.long 0x1214++0x03
        line.long 0x00 "DMA_CH2_TxDesc_List_Address,The Channel2 Tx Descriptor List Address register points the DMA to the start of Transmit descriptor list"
            hexmask.long 0x00 3.--31. 1. "TDESLA,Start of Transmit List This field contains the base address of the first descriptor in the Transmit descriptor list"
            newline
            rbitfld.long 0x00 0.--2. "Reserved_LSb,Reserved" "0,1,2,3,4,5,6,7"
    group.long 0x1220++0x03
        line.long 0x00 "DMA_CH2_TxDesc_Tail_Pointer,The Channel2 Tx Descriptor Tail Pointer register points to an offset from the base and indicates the location of the last valid descriptor"
            hexmask.long 0x00 3.--31. 1. "TDTP,Transmit Descriptor Tail Pointer This field contains the tail pointer for the Tx descriptor ring"
            newline
            rbitfld.long 0x00 0.--2. "Reserved_LSb,Reserved" "0,1,2,3,4,5,6,7"
    group.long 0x122C++0x03
        line.long 0x00 "DMA_CH2_TxDesc_Ring_Length,The Tx Descriptor Ring Length register contains the length of the Transmit descriptor ring"
            hexmask.long.tbyte 0x00 10.--31. 1. "Reserved_31_10,Reserved"
            newline
            hexmask.long.word 0x00 0.--9. 1. "TDRL,Transmit Descriptor Ring Length This field sets the maximum number of Tx descriptors in the circular descriptor ring"
    group.long 0x1234++0x03
        line.long 0x00 "DMA_CH2_Interrupt_Enable,The Channel2 Interrupt Enable register enables the interrupts reported by the Status register"
            hexmask.long.word 0x00 16.--31. 1. "Reserved_31_16,Reserved"
            newline
            bitfld.long 0x00 15. "NIE,Normal Interrupt Summary Enable When this bit is set the normal interrupt summary is enabled" "0: Normal Interrupt Summary is disabled,1: Normal Interrupt Summary is enabled"
            newline
            bitfld.long 0x00 14. "AIE,Abnormal Interrupt Summary Enable When this bit is set the abnormal interrupt summary is enabled" "0: Abnormal Interrupt Summary is disabled,1: Abnormal Interrupt Summary is enabled"
            newline
            bitfld.long 0x00 13. "CDEE,Context Descriptor Error Enable When this bit is set along with the AIE bit the Descriptor error interrupt is enabled" "0: Context Descriptor Error is disabled,1: Context Descriptor Error is enabled"
            newline
            bitfld.long 0x00 12. "FBEE,Fatal Bus Error Enable When this bit is set along with the AIE bit the Fatal Bus error interrupt is enabled" "0: Fatal Bus Error is disabled,1: Fatal Bus Error is enabled"
            newline
            rbitfld.long 0x00 11. "Reserved_ERIE,Reserved" "0,1"
            newline
            bitfld.long 0x00 10. "ETIE,Early Transmit Interrupt Enable When this bit is set along with the AIE bit the Early Transmit interrupt is enabled" "0: Early Transmit Interrupt is disabled,1: Early Transmit Interrupt is enabled"
            newline
            rbitfld.long 0x00 9. "Reserved_RWTE,Reserved" "0,1"
            newline
            rbitfld.long 0x00 8. "Reserved_RSE,Reserved" "0,1"
            newline
            rbitfld.long 0x00 7. "Reserved_RBUE,Reserved" "0,1"
            newline
            rbitfld.long 0x00 6. "Reserved_RIE,Reserved" "0,1"
            newline
            rbitfld.long 0x00 3.--5. "Reserved_5_3,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 2. "TBUE,Transmit Buffer Unavailable Enable When this bit is set along with the NIE bit the Transmit Buffer Unavailable interrupt is enabled" "0: Transmit Buffer Unavailable is disabled,1: Transmit Buffer Unavailable is enabled"
            newline
            bitfld.long 0x00 1. "TXSE,Transmit Stopped Enable When this bit is set along with the AIE bit the Transmission Stopped interrupt is enabled" "0: Transmit Stopped is disabled,1: Transmit Stopped is enabled"
            newline
            bitfld.long 0x00 0. "TIE,Transmit Interrupt Enable When this bit is set along with the NIE bit the Transmit Interrupt is enabled" "0: Transmit Interrupt is disabled,1: Transmit Interrupt is enabled"
    group.long 0x123C++0x03
        line.long 0x00 "DMA_CH2_Slot_Function_Control_Status,The Slot Function Control and Status register contains the control bits for slot function and the status for Transmit path"
            hexmask.long.word 0x00 20.--31. 1. "Reserved_31_20,Reserved"
            newline
            rbitfld.long 0x00 16.--19. "RSN,Reference Slot Number This field gives the current value of the reference slot number in the DMA" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.word 0x00 4.--15. 1. "SIV,Slot Interval Value This field controls the period of the slot interval in which the TxDMA fetches the scheduled packets"
            newline
            rbitfld.long 0x00 2.--3. "Reserved_3_2,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 1. "ASC,Advance Slot Check When set this bit enables the DMA to fetch the data from the buffer when the slot number (SLOTNUM) programmed in the Tx descriptor is - equal to the reference slot number given in the RSN field or - ahead of the reference slot.." "0: Advance Slot Check is disabled,1: Advance Slot Check is enabled"
            newline
            bitfld.long 0x00 0. "ESC,Enable Slot Comparison When set this bit enables the checking of the slot numbers programmed in the Tx descriptor with the current reference given in the RSN field" "0: Slot Comparison is disabled,1: Slot Comparison is enabled"

    rgroup.long 0x1244++0x03
        line.long 0x00 "DMA_CH2_Current_App_TxDesc,The Channel2 Current Application Transmit Descriptor register points to the current Transmit descriptor read by the DMA"
            hexmask.long 0x00 0.--31. 1. "CURTDESAPTR,Application Transmit Descriptor Address Pointer The DMA updates this pointer during Tx operation"
    rgroup.long 0x1254++0x03
        line.long 0x00 "DMA_CH2_Current_App_TxBuffer,The Channel2 Current Application Transmit Buffer Address register points to the current Tx buffer address read by the DMA"
            hexmask.long 0x00 0.--31. 1. "CURTBUFAPTR,Application Transmit Buffer Address Pointer The DMA updates this pointer during Tx operation"

    group.long 0x1260++0x03
        line.long 0x00 "DMA_CH2_Status,The software driver (application) reads the Status register during interrupt service routine or polling to determine the status of the DMA"
            hexmask.long.word 0x00 22.--31. 1. "Reserved_31_22,Reserved"
            newline
            rbitfld.long 0x00 19.--21. "REB,Rx DMA Error Bits This field indicates the type of error that caused a Bus Error" "0: Error during write transfer This field is valid,1: Error during read transfer,?..."
            newline
            rbitfld.long 0x00 16.--18. "TEB,Tx DMA Error Bits This field indicates the type of error that caused a Bus Error" "0: Error during write transfer This field is valid,1: Error during read transfer,?..."
            newline
            bitfld.long 0x00 15. "NIS,Normal Interrupt Summary Normal Interrupt Summary bit value is the logical OR of the following bits when the corresponding interrupt bits are enabled in the DMA_CH2_Interrupt_Enable register: - Bit" "0: Normal Interrupt Summary status not detected,1: Normal Interrupt Summary status detected"
            newline
            bitfld.long 0x00 14. "AIS,Abnormal Interrupt Summary Abnormal Interrupt Summary bit value is the logical OR of the following when the corresponding interrupt bits are enabled in the DMA_CH2_Interrupt_Enable register: - Bit" "0: Abnormal Interrupt Summary status not detected,1: Abnormal Interrupt Summary status detected"
            newline
            bitfld.long 0x00 13. "CDE,Context Descriptor Error This bit indicates that the DMA Tx/Rx engine received a descriptor error which indicates invalid context in the middle of packet flow ( intermediate descriptor) or all one's descriptor in Tx case and on Rx side it indicates.." "0: Context Descriptor Error status not detected,1: Context Descriptor Error status detected"
            newline
            bitfld.long 0x00 12. "FBE,Fatal Bus Error This bit indicates that a bus error occurred (as described in the EB field)" "0: Fatal Bus Error status not detected,1: Fatal Bus Error status detected"
            newline
            bitfld.long 0x00 11. "ERI,Early Receive Interrupt This bit when set indicates that the RxDMA has completed the transfer of packet data to the memory" "0: Early Receive Interrupt status not detected,1: Early Receive Interrupt status detected"
            newline
            bitfld.long 0x00 10. "ETI,Early Transmit Interrupt This bit when set indicates that the TxDMA has completed the transfer of packet data to the MTL TXFIFO memory" "0: Early Transmit Interrupt status not detected,1: Early Transmit Interrupt status detected"
            newline
            bitfld.long 0x00 9. "RWT,Receive Watchdog Timeout This bit is asserted when a packet with length greater than 2 048 bytes (10 240 bytes when Jumbo Packet mode is enabled) is received" "0: Receive Watchdog Timeout status not detected,1: Receive Watchdog Timeout status detected"
            newline
            bitfld.long 0x00 8. "RPS,Receive Process Stopped This bit is asserted when the Rx process enters the Stopped state" "0: Receive Process Stopped status not detected,1: Receive Process Stopped status detected"
            newline
            bitfld.long 0x00 7. "RBU,Receive Buffer Unavailable This bit indicates that the application owns the next descriptor in the Receive list and the DMA cannot acquire it" "0: Receive Buffer Unavailable status not detected,1: Receive Buffer Unavailable status detected"
            newline
            bitfld.long 0x00 6. "RI,Receive Interrupt This bit indicates that the packet reception is complete" "0: Receive Interrupt status not detected,1: Receive Interrupt status detected"
            newline
            rbitfld.long 0x00 3.--5. "Reserved_5_3,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 2. "TBU,Transmit Buffer Unavailable This bit indicates that the application owns the next descriptor in the Transmit list and the DMA cannot acquire it" "0: Transmit Buffer Unavailable status not detected,1: Transmit Buffer Unavailable status detected"
            newline
            bitfld.long 0x00 1. "TPS,Transmit Process Stopped This bit is set when the transmission is stopped" "0: Transmit Process Stopped status not detected,1: Transmit Process Stopped status detected"
            newline
            bitfld.long 0x00 0. "TI,Transmit Interrupt This bit indicates that the packet transmission is complete" "0: Transmit Interrupt status not detected,1: Transmit Interrupt status detected"
tree.end

tree "ETHER_MAC ()"
    base ad:0x8A002000
    rgroup.long 0x20++0x03
        line.long 0x00 "LATENCY_CTRL,LATENCY_CTRL"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x100++0x03
        line.long 0x00 "RX_ETH_FILT_msb,To program rules into the EtherType rules table the RX_ETH_FILT register is written by the host processor"
            hexmask.long 0x00 4.--31. 1. "reserved,Reserved bits"
            bitfld.long 0x00 1.--3. "RULE_NUM,Entry Number in the EtherType filtering table" "0: RULE_NUM,?..."
            newline
            bitfld.long 0x00 0. "OUTCOME,Indicates the outcome when a rule is matched" "0: OUTCOME,?..."
    group.long 0x104++0x03
        line.long 0x00 "RX_ETH_FILT_lsb,To program rules into the EtherType rules table the RX_ETH_FILT register is written by the host processor"
            hexmask.long.word 0x00 16.--31. 1. "HI_ETHERTYPE,Upper bound value of EtherType filter for RULE_NUM in the RX Lookup block"
            hexmask.long.word 0x00 0.--15. 1. "LO_ETHERTYPE,Lower bound value of EtherType filter for RULE_NUM in the RX Lookup block"
    group.long 0x140++0x03
        line.long 0x00 "RX_LKUP_SWAP,Writing this register causes the active and in-active pages of the lookup database to swap"
            hexmask.long 0x00 1.--31. 1. "reserved,Reserved bits"
            bitfld.long 0x00 0. "SWAP,Writing this register causes the active and in-active pages of the lookup database to swap" "0: SWAP,?..."

    rgroup.long 0x148++0x03
        line.long 0x00 "RX_LKUP_STAT,Indicates the current active/inactive page index of the lookup database"
            hexmask.long 0x00 2.--31. 1. "reserved,Reserved bits"
            bitfld.long 0x00 1. "PAGE,Indicates the current active page index of the lookup database" "0: PAGE,?..."
            newline
            bitfld.long 0x00 0. "RDY,Indicates that the inactive page is ready to be written to by the host" "0: RDY,?..."

    group.long 0x200++0x03
        line.long 0x00 "TX_SRC_FILT_1,Filter for the source MAC address used for the TX Lookup"
            hexmask.long.word 0x00 16.--31. 1. "reserved,Reserved bits"
            hexmask.long.word 0x00 0.--15. 1. "ADR,Filter for the source MAC address used for the TX Lookup"
    group.long 0x204++0x03
        line.long 0x00 "TX_SRC_FILT_0,Filter for the source MAC address used for the TX Lookup"
            hexmask.long 0x00 0.--31. 1. "ADR,Filter for the source MAC address used for the TX Lookup"
    group.long 0x208++0x03
        line.long 0x00 "TX_DST_FILT_1,Filter for the destination MAC address used for the TX lookup"
            hexmask.long.word 0x00 17.--31. 1. "reserved,Reserved bits"
            bitfld.long 0x00 16. "WILD,Write this bit to indicate that the dst_addr is a wildcard and all values are matched" "0: WILD,?..."
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADR,Filter for the source MAC address used for the TX Lookup"
    group.long 0x20C++0x03
        line.long 0x00 "TX_DST_FILT_0,Filter for the destination MAC address used for the TX lookup"
            hexmask.long 0x00 0.--31. 1. "ADR,Filter for the source MAC address used for the TX Lookup"
    group.long 0x210++0x03
        line.long 0x00 "TX_PRG_LUT,Writing to this register causes the information contained in TX_SRC_FILT TX_DST_FILT and TX_PRG_LUT to be loaded into the entry of the Lookup Table corresponding to PHY_PORT and ENTRY being programmed"
            hexmask.long.word 0x00 16.--31. 1. "ETH_TYPE,Filter for the EtherType"
            bitfld.long 0x00 12.--15. "CA,CA value associated with the search parameters programmed" "0: CA,?..."
            newline
            rbitfld.long 0x00 10.--11. "reserved,Reserved bits" "0,1,2,3"
            bitfld.long 0x00 8.--9. "OUTCOME,Indicates the outcome when a match occurs for this SC" "0: OUTCOME,?..."
            newline
            bitfld.long 0x00 4.--7. "ENTRY,ENTRY in the Lookup Table of the PHY_PORT being programmed" "0: ENTRY,?..."
            rbitfld.long 0x00 1.--3. "reserved_1,Reserved bits" "0: Reserved_1,?..."
            newline
            bitfld.long 0x00 0. "PHY_PORT,Writing to this register causes the information contained in TX_SRC_FILT TX_DST_FILT and TX_PRG_LUT to be loaded into the entry of the Lookup Table corresponding to PHY_PORT and ENTRY being programmed" "0: PHY_PORT,?..."

    rgroup.long 0x218++0x03
        line.long 0x00 "TX_PG,When high indicates that an entry is either being inserted or deleted into the TX Lookup Table"
            hexmask.long 0x00 1.--31. 1. "reserved,Reserved bits"
            bitfld.long 0x00 0. "BUSY,When high indicates that an entry is either being inserted or deleted into the TX Lookup Table" "0: BUSY,?..."

    group.long 0x240++0x03
        line.long 0x00 "TX_ACTIVE_AN,Each bit of this register corresponds to the active SA for the corresponding CA to indicate which SA is currently active"
            hexmask.long.word 0x00 16.--31. 1. "reserved,Reserved bits"
            hexmask.long.word 0x00 0.--15. 1. "ACT_SA,When high indicates that an entry is either being inserted or deleted into the TX Lookup Table"
    group.long 0x800++0x03
        line.long 0x00 "MIB_CMD,The MIB_CMD register allows a user to indirectly access the MIB counters"
            hexmask.long.word 0x00 20.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 16.--19. "OBJ_ID,Index of the counter's SA or SC to be read/written that counter can be either on a global SA or SC basis" "0: OBJ_ID,?..."
            newline
            rbitfld.long 0x00 15. "reserved_1,Reserved bit" "0,1"
            hexmask.long.byte 0x00 8.--14. 1. "CTR_ID,ID of the counter to access"
            newline
            rbitfld.long 0x00 6.--7. "reserved_2,Reserved bit" "0,1,2,3"
            bitfld.long 0x00 5. "CLR,If this bit is set the corresponding registers are cleared atomically with the read transaction" "0: CLR,?..."
            newline
            bitfld.long 0x00 4. "DIR,Specify the direction" "0: DIR,?..."
            rbitfld.long 0x00 3. "reserved_3,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 0.--2. "CMD,The MIB_CMD register allows a user to indirectly access the MIB counters" "0: CMD,?..."

    rgroup.long 0x808++0x03
        line.long 0x00 "MIB_CMD_STAT,When high indicates that a MIB_CMD operation is underway"
            hexmask.long 0x00 1.--31. 1. "reserved,Reserved bits"
            bitfld.long 0x00 0. "BUSY,When high indicates that a MIB_CMD operation is underway" "0: BUSY,?..."

    group.long 0x810++0x03
        line.long 0x00 "MIB_VALIDATE,Each bit in this register indicates the default VALIDATE_FRAMES setting for each physical port"
            hexmask.long 0x00 1.--31. 1. "reserved,Reserved bits"
            bitfld.long 0x00 0. "PHY_MAP,Each bit in this register indicates the default VALIDATE_FRAMES setting for each physical port (as passed in the Pre-Control command)" "0: PHY_MAP,?..."
    group.long 0x820++0x03
        line.long 0x00 "MIB_WR_DATA_HIGH,Counter MSB value to be loaded when executing a write command (not applicable in a SA counter)"
            hexmask.long 0x00 0.--31. 1. "DATA,Counter MSB value to be loaded when executing a write command (not applicable in a SA counter"
    group.long 0x824++0x03
        line.long 0x00 "MIB_WR_DATA_LOW,Counter LSB value to be loaded when executing a write command"
            hexmask.long 0x00 0.--31. 1. "DATA,Counter LSB value to be loaded when executing a write command"

    rgroup.long 0xA00++0x03
        line.long 0x00 "MIB_CMD_D_BUF_HIGH_0,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
            hexmask.long 0x00 0.--31. 1. "DATA_HIGH,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
    rgroup.long 0xA04++0x03
        line.long 0x00 "MIB_CMD_D_BUF_LOW_0,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
            hexmask.long 0x00 0.--31. 1. "DATA_LOW,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
    rgroup.long 0xA08++0x03
        line.long 0x00 "MIB_CMD_D_BUF_HIGH_1,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
            hexmask.long 0x00 0.--31. 1. "DATA_HIGH,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
    rgroup.long 0xA0C++0x03
        line.long 0x00 "MIB_CMD_D_BUF_LOW_1,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
            hexmask.long 0x00 0.--31. 1. "DATA_LOW,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
    rgroup.long 0xA10++0x03
        line.long 0x00 "MIB_CMD_D_BUF_HIGH_2,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
            hexmask.long 0x00 0.--31. 1. "DATA_HIGH,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
    rgroup.long 0xA14++0x03
        line.long 0x00 "MIB_CMD_D_BUF_LOW_2,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
            hexmask.long 0x00 0.--31. 1. "DATA_LOW,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
    rgroup.long 0xA18++0x03
        line.long 0x00 "MIB_CMD_D_BUF_HIGH_3,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
            hexmask.long 0x00 0.--31. 1. "DATA_HIGH,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
    rgroup.long 0xA1C++0x03
        line.long 0x00 "MIB_CMD_D_BUF_LOW_3,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
            hexmask.long 0x00 0.--31. 1. "DATA_LOW,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
    rgroup.long 0xA20++0x03
        line.long 0x00 "MIB_CMD_D_BUF_HIGH_4,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
            hexmask.long 0x00 0.--31. 1. "DATA_HIGH,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
    rgroup.long 0xA24++0x03
        line.long 0x00 "MIB_CMD_D_BUF_LOW_4,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
            hexmask.long 0x00 0.--31. 1. "DATA_LOW,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
    rgroup.long 0xA28++0x03
        line.long 0x00 "MIB_CMD_D_BUF_HIGH_5,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
            hexmask.long 0x00 0.--31. 1. "DATA_HIGH,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
    rgroup.long 0xA2C++0x03
        line.long 0x00 "MIB_CMD_D_BUF_LOW_5,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
            hexmask.long 0x00 0.--31. 1. "DATA_LOW,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
    rgroup.long 0xA30++0x03
        line.long 0x00 "MIB_CMD_D_BUF_HIGH_6,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
            hexmask.long 0x00 0.--31. 1. "DATA_HIGH,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
    rgroup.long 0xA34++0x03
        line.long 0x00 "MIB_CMD_D_BUF_LOW_6,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
            hexmask.long 0x00 0.--31. 1. "DATA_LOW,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
    rgroup.long 0xA38++0x03
        line.long 0x00 "MIB_CMD_D_BUF_HIGH_7,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
            hexmask.long 0x00 0.--31. 1. "DATA_HIGH,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
    rgroup.long 0xA3C++0x03
        line.long 0x00 "MIB_CMD_D_BUF_LOW_7,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
            hexmask.long 0x00 0.--31. 1. "DATA_LOW,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
    rgroup.long 0xA40++0x03
        line.long 0x00 "MIB_CMD_D_BUF_HIGH_8,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
            hexmask.long 0x00 0.--31. 1. "DATA_HIGH,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
    rgroup.long 0xA44++0x03
        line.long 0x00 "MIB_CMD_D_BUF_LOW_8,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
            hexmask.long 0x00 0.--31. 1. "DATA_LOW,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
    rgroup.long 0xA48++0x03
        line.long 0x00 "MIB_CMD_D_BUF_HIGH_9,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
            hexmask.long 0x00 0.--31. 1. "DATA_HIGH,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
    rgroup.long 0xA4C++0x03
        line.long 0x00 "MIB_CMD_D_BUF_LOW_9,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
            hexmask.long 0x00 0.--31. 1. "DATA_LOW,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
    rgroup.long 0xA50++0x03
        line.long 0x00 "MIB_CMD_D_BUF_HIGH_10,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
            hexmask.long 0x00 0.--31. 1. "DATA_HIGH,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
    rgroup.long 0xA54++0x03
        line.long 0x00 "MIB_CMD_D_BUF_LOW_10,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
            hexmask.long 0x00 0.--31. 1. "DATA_LOW,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
    rgroup.long 0xA58++0x03
        line.long 0x00 "MIB_CMD_D_BUF_HIGH_11,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
            hexmask.long 0x00 0.--31. 1. "DATA_HIGH,Contains the return MSB value of the 64 bit MIB Counter (Not applicable for SA counters as they are 32 bit values)"
    rgroup.long 0xA5C++0x03
        line.long 0x00 "MIB_CMD_D_BUF_LOW_11,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"
            hexmask.long 0x00 0.--31. 1. "DATA_LOW,Contains the return LSB value of the 64 bit MIB Counter (32 bit in a SA counter)"

    group.long 0xB00++0x03
        line.long 0x00 "SAI_SC_CORR_0,Correlates a specific RX SA with an RX SC for the purpose of the RX SC MIB Counters"
            rbitfld.long 0x00 27.--31. "reserved_0,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 24.--26. "SAI_SC_0,Secure chanel associated with SAI_0" "0: SAI_SC_0,?..."
            newline
            rbitfld.long 0x00 19.--23. "reserved_1,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 16.--18. "SAI_SC_1,Secure chanel associated with SAI_1" "0: SAI_SC_1,?..."
            newline
            rbitfld.long 0x00 11.--15. "reserved_2,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 8.--10. "SAI_SC_2,Secure chanel associated with SAI_2" "0: SAI_SC_2,?..."
            newline
            rbitfld.long 0x00 3.--7. "reserved_3,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 0.--2. "SAI_SC_3,Secure chanel associated with SAI_3" "0: SAI_SC_3,?..."
    group.long 0xB04++0x03
        line.long 0x00 "SAI_SC_CORR_1,Correlates a specific RX SA with an RX SC for the purpose of the RX SC MIB Counters"
            rbitfld.long 0x00 27.--31. "reserved_0,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 24.--26. "SAI_SC_4,Secure chanel associated with SAI_4" "0: SAI_SC_4,?..."
            newline
            rbitfld.long 0x00 19.--23. "reserved_1,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 16.--18. "SAI_SC_5,Secure chanel associated with SAI_5" "0: SAI_SC_5,?..."
            newline
            rbitfld.long 0x00 11.--15. "reserved_2,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 8.--10. "SAI_SC_6,Secure chanel associated with SAI_6" "0: SAI_SC_6,?..."
            newline
            rbitfld.long 0x00 3.--7. "reserved_3,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 0.--2. "SAI_SC_7,Secure chanel associated with SAI_7" "0: SAI_SC_7,?..."
    group.long 0xB08++0x03
        line.long 0x00 "SAI_SC_CORR_2,Correlates a specific RX SA with an RX SC for the purpose of the RX SC MIB Counters"
            rbitfld.long 0x00 27.--31. "reserved_0,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 24.--26. "SAI_SC_8,Secure chanel associated with SAI_8" "0: SAI_SC_8,?..."
            newline
            rbitfld.long 0x00 19.--23. "reserved_1,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 16.--18. "SAI_SC_9,Secure chanel associated with SAI_9" "0: SAI_SC_9,?..."
            newline
            rbitfld.long 0x00 11.--15. "reserved_2,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 8.--10. "SAI_SC_10,Secure chanel associated with SAI_10" "0: SAI_SC_10,?..."
            newline
            rbitfld.long 0x00 3.--7. "reserved_3,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 0.--2. "SAI_SC_11,Secure chanel associated with SAI_11" "0: SAI_SC_11,?..."
    group.long 0xB0C++0x03
        line.long 0x00 "SAI_SC_CORR_3,Correlates a specific RX SA with an RX SC for the purpose of the RX SC MIB Counters"
            rbitfld.long 0x00 27.--31. "reserved_0,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 24.--26. "SAI_SC_12,Secure chanel associated with SAI_12" "0: SAI_SC_12,?..."
            newline
            rbitfld.long 0x00 19.--23. "reserved_1,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 16.--18. "SAI_SC_13,Secure chanel associated with SAI_13" "0: SAI_SC_13,?..."
            newline
            rbitfld.long 0x00 11.--15. "reserved_2,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 8.--10. "SAI_SC_14,Secure chanel associated with SAI_14" "0: SAI_SC_14,?..."
            newline
            rbitfld.long 0x00 3.--7. "reserved_3,Reserved bits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            bitfld.long 0x00 0.--2. "SAI_SC_15,Secure chanel associated with SAI_15" "0: SAI_SC_15,?..."

    rgroup.long 0x2000++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_0,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x2004++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_0,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x2008++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_0,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x200C++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_0,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x2010++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_1,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x2014++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_1,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x2018++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_1,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x201C++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_1,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x2020++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_2,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x2024++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_2,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x2028++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_2,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x202C++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_2,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x2030++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_3,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x2034++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_3,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x2038++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_3,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x203C++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_3,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x2040++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_4,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x2044++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_4,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x2048++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_4,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x204C++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_4,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x2050++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_5,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x2054++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_5,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x2058++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_5,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x205C++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_5,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x2060++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_6,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x2064++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_6,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x2068++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_6,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x206C++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_6,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x2070++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_7,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x2074++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_7,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x2078++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_7,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x207C++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_7,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x2080++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_8,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x2084++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_8,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x2088++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_8,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x208C++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_8,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x2090++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_9,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x2094++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_9,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x2098++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_9,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x209C++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_9,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x20A0++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_10,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x20A4++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_10,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x20A8++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_10,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x20AC++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_10,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x20B0++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_11,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x20B4++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_11,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x20B8++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_11,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x20BC++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_11,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x20C0++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_12,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x20C4++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_12,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x20C8++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_12,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x20CC++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_12,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x20D0++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_13,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x20D4++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_13,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x20D8++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_13,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x20DC++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_13,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x20E0++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_14,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x20E4++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_14,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x20E8++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_14,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x20EC++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_14,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x20F0++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_RESERVED_15,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x20F4++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_INFO_15,This table contains one entry SA"
            bitfld.long 0x00 4.--5. "AN,AN value used in the lookup to determine the SAI" "0: AN,?..."
            bitfld.long 0x00 0.--3. "CA,CA index associated with the SCI value" "0: CA,?..."
    group.long 0x20F8++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_HIGH_15,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_HIGH,SCI portion of the RX Lookup Table entry"
    group.long 0x20FC++0x03
        line.long 0x00 "RX_LOOKUP_TABLE_SCI_LOW_15,This table contains one entry SA"
            hexmask.long 0x00 0.--31. 1. "SCI_LOW,SCI portion of the RX Lookup Table entry"

    rgroup.long 0x4000++0x03
        line.long 0x00 "CORE_VER_NUM,IP Version Number"
            hexmask.long.word 0x00 16.--31. 1. "RESERVED_31_16,Reserved and read as zero"
            hexmask.long.word 0x00 0.--15. 1. "VERSION_NUM,Indicates the coreKit release version number in BCD format"
    rgroup.long 0x4004++0x03
        line.long 0x00 "CORE_VER_TYPE,IP Version Type Register"
            hexmask.long.word 0x00 16.--31. 1. "RESERVED_31_24,Reserved and read as zero"
            bitfld.long 0x00 12.--15. "TYPE_ENUM,Indicates the coreKit release type" "?,1: TYPE_ENUM_REG,?..."
            newline
            bitfld.long 0x00 8.--11. "PKG_NUM,Indicates the alphabetical packaging number of coreKit ID" "?,?,?,?,?,?,?,?,?,?,10: PKG_NUM_REG,?..."
            hexmask.long.byte 0x00 0.--7. 1. "TYPE_NUM,Indicates the coreKit release version type number in BCD format"

    group.long 0x4008++0x03
        line.long 0x00 "MACsec_IP_Control,MACsec IP Control"
            bitfld.long 0x00 30.--31. "txvlanmode,Tx VLAN mode mode is encoded as below: 2'd0 : NOP" "0: txvlanmode,?..."
            hexmask.long.word 0x00 21.--29. 1. "Reserved_0,Reserved and read-only as zero"
            newline
            hexmask.long.word 0x00 12.--20. 1. "sbfifofullthresh,Defines the full threshold value of Tx and Rx side-band FIFOs normally be set to a value that is close to the depth of the side-band FIFOs (see pSBFIFO_DEPTH) but may be lowered for debug/diagnostic purposes"
            rbitfld.long 0x00 9.--11. "Reserved_1,Reserved" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 6.--7. "Reserved_2,Reserved bits" "0,1,2,3"
            bitfld.long 0x00 2. "rx_padding_en,Enables the padding of MACSec frames smaller than 64 bytes (after removing the SECTag and ICV) in the direction MAC to phy to avoid them to be considered as runt frames" "?,1: rx_padding_en"
            newline
            bitfld.long 0x00 1. "tx_padding_en,Enables padded frames to be encrypted without encrypting the padding bytes" "?,1: tx_padding_en"
            bitfld.long 0x00 0. "xpnsel," "0: xpnsel,?..."
    group.long 0x4010++0x03
        line.long 0x00 "MACSec_CFG_MIN_IPG,MACsec Minimum Inter-Packet Gap (IPG) configuration register"
            hexmask.long.word 0x00 16.--31. 1. "Reserved,Reserved bits"
            hexmask.long.byte 0x00 8.--15. 1. "min_ipg_tx,Configuration of Minimum Inter-Packet Gap (IPG) for the Tx path"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "min_ipg_rx,Configuration of Minimum Inter-Packet Gap (IPG) for the Rx path"
    group.long 0x4014++0x03
        line.long 0x00 "MACsec_IP_VLAN,VLAN Configuration register 1 and 2"
            hexmask.long.word 0x00 16.--31. 1. "vlantpid2,VLAN TPID 2 value IP recognizes the 4-byte field right after MAC SA as VLAN if the TPID value matches any of the values programed in vlantpid1 OR vlantpid2"
            hexmask.long.word 0x00 0.--15. 1. "vlantpid1,VLAN TPID 1 value IP recognizes the 4-byte field right after MAC SA as VLAN if the TPID value matches any of the values programed in vlantpid1 OR vlantpid2"

    wgroup.long 0x4040++0x03
        line.long 0x00 "rls_cnt_setup_value,Register is required to configure the fixed latencies for Tx and Rx"
            hexmask.long.word 0x00 16.--31. 1. "Tx_cnt_setup_value,Value to configure the Tx fixed latency (excluding the GMII interface latency)"
            hexmask.long.word 0x00 0.--15. 1. "Rx_cnt_setup_value,Value to configure the Rx fixed latency (excluding the GMII interface latency)"

    group.long 0x5000++0x03
        line.long 0x00 "IRQ_GLBL_EN,System global interrupt register enable"
            bitfld.long 0x00 31. "GLBL_EN,Global enable control for interrupt sources" "?,1: GLBL_EN"
            hexmask.long.tbyte 0x00 11.--29. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 10. "RX_PREAMBLE_ERROR_EN,Enables the GMII preamble error interrupt (RX Side)" "?,1: RX_PREAMBLE_ERROR_EN"
            bitfld.long 0x00 9. "TX_PREAMBLE_ERROR_EN,Enables the GMII preamble error interrupt (TX Side)" "?,1: TX_PREAMBLE_ERROR_EN"
            newline
            bitfld.long 0x00 8. "RX_GMII_ERROR_EN,Enables the GMII error interrupt (RX Side)" "?,1: RX_GMII_ERROR_EN"
            bitfld.long 0x00 7. "TX_GMII_ERROR_EN,Enables the GMII error interrupt (TX Side)" "?,1: TX_GMII_ERROR_EN"
            newline
            bitfld.long 0x00 6. "RX_ILLEGAL_IPG_EN,Enables the Illegal IPG interrupt (RX Side)" "?,1: RX_ILLEGAL_IPG_EN"
            bitfld.long 0x00 5. "TX_ILLEGAL_IPG_EN,Enables the Illegal IPG interrupt (TX Side)" "?,1: TX_ILLEGAL_IPG_EN"
            newline
            bitfld.long 0x00 4. "RX_FRAME_TOO_SHORT_EN,Enables the Frame too short contribution to IRQ signal" "?,1: RX_FRAME_TOO_SHORT_EN"
            bitfld.long 0x00 3. "TX_FRAME_TOO_SHORT_EN,Enables the Frame too short contribution to IRQ signal" "?,1: TX_FRAME_TOO_SHORT_EN"
            newline
            bitfld.long 0x00 2. "RX_FRAME_CRC_ERROR_EN,Enables the CRC error contribution to IRQ signal (RX Side)" "?,1: RX_FRAME_CRC_ERROR_EN"
            bitfld.long 0x00 1. "TX_FRAME_CRC_ERROR_EN,Enables the CRC error contribution to IRQ signal (TX Side)" "?,1: TX_FRAME_CRC_ERROR_EN"
            newline
            bitfld.long 0x00 0. "UNKNOWN_SC_EN,Enables the Global Unknown SC contribution to the IRQ signal" "?,1: UNKNOWN_SC_EN"
    group.long 0x5004++0x03
        line.long 0x00 "IRQ_GLBL_STAT,System global interrupt register status"
            hexmask.long.tbyte 0x00 11.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 10. "RX_PREAMBLE_ERROR_STAT,Preamble with fewer than 7 bytes is seen" "0: RX_PREAMBLE_ERROR_STAT,?..."
            newline
            bitfld.long 0x00 9. "TX_PREAMBLE_ERROR_STAT,Preamble with fewer than 7 bytes is seen" "0: TX_PREAMBLE_ERROR_STAT,?..."
            bitfld.long 0x00 8. "RX_GMII_ERROR_STAT,Current status of RX GMII error interrupt" "0: RX_GMII_ERROR_STAT,?..."
            newline
            bitfld.long 0x00 7. "TX_GMII_ERROR_STAT,Current status of TX GMII error interrupt" "0: TX_GMII_ERROR_STAT,?..."
            bitfld.long 0x00 6. "RX_ILLEGAL_IPG_STAT,Current status of Illegal IPG interrupt" "0: RX_ILLEGAL_IPG_STAT,?..."
            newline
            bitfld.long 0x00 5. "TX_ILLEGAL_IPG_STAT,Current status of Illegal IPG interrupt" "0: TX_ILLEGAL_IPG_STAT,?..."
            bitfld.long 0x00 4. "RX_FRAME_TOO_SHORT_STAT,Current status of Frame too short interrupt" "0: RX_FRAME_TOO_SHORT_STAT,?..."
            newline
            bitfld.long 0x00 3. "TX_FRAME_TOO_SHORT_STAT,Current status of Frame too short interrupt" "0: TX_FRAME_TOO_SHORT_STAT,?..."
            bitfld.long 0x00 2. "RX_FRAME_CRC_ERROR_STAT,Current status of CRC error on frame interrupt (RX side)" "0: RX_FRAME_CRC_ERROR_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_CRC_ERROR_STAT,Current status of CRC error on frame interrupt (TX side)" "0: TX_FRAME_CRC_ERROR_STAT,?..."
            bitfld.long 0x00 0. "UNKNOWN_SC_STAT,Current status of Global Unknown SC contribution to the IRQ signal" "0: UNKNOWN_SC_STAT,?..."
    group.long 0x5008++0x03
        line.long 0x00 "IRQ_PENDING_SA_STAT,System global interrupt register enable"
            bitfld.long 0x00 31. "RX_SA_15_STAT,Status of RX SA 15" "0: RX_SA_15_STAT,?..."
            bitfld.long 0x00 30. "RX_SA_14_STAT,Status of RX SA 14" "0: RX_SA_14_STAT,?..."
            newline
            bitfld.long 0x00 29. "RX_SA_13_STAT,Status of RX SA 13" "0: RX_SA_13_STAT,?..."
            bitfld.long 0x00 28. "RX_SA_12_STAT,Status of RX SA 12" "0: RX_SA_12_STAT,?..."
            newline
            bitfld.long 0x00 27. "RX_SA_11_STAT,Status of RX SA 11" "0: RX_SA_11_STAT,?..."
            bitfld.long 0x00 26. "RX_SA_10_STAT,Status of RX SA 10" "0: RX_SA_10_STAT,?..."
            newline
            bitfld.long 0x00 25. "RX_SA_9_STAT,Status of RX SA 9" "0: RX_SA_9_STAT,?..."
            bitfld.long 0x00 24. "RX_SA_8_STAT,Status of RX SA 8" "0: RX_SA_8_STAT,?..."
            newline
            bitfld.long 0x00 23. "RX_SA_7_STAT,Status of RX SA 7" "0: RX_SA_7_STAT,?..."
            bitfld.long 0x00 22. "RX_SA_6_STAT,Status of RX SA 6" "0: RX_SA_6_STAT,?..."
            newline
            bitfld.long 0x00 21. "RX_SA_5_STAT,Status of RX SA 5" "0: RX_SA_5_STAT,?..."
            bitfld.long 0x00 20. "RX_SA_4_STAT,Status of RX SA 4" "0: RX_SA_4_STAT,?..."
            newline
            bitfld.long 0x00 19. "RX_SA_3_STAT,Status of RX SA 3" "0: RX_SA_3_STAT,?..."
            bitfld.long 0x00 18. "RX_SA_2_STAT,Status of RX SA 2" "0: RX_SA_2_STAT,?..."
            newline
            bitfld.long 0x00 17. "RX_SA_1_STAT,Status of RX SA 1" "0: RX_SA_1_STAT,?..."
            bitfld.long 0x00 16. "RX_SA_0_STAT,Status of RX SA 0" "0: RX_SA_0_STAT,?..."
            newline
            bitfld.long 0x00 15. "TX_SA_15_STAT,Status of TX SA 15" "0: TX_SA_15_STAT,?..."
            bitfld.long 0x00 14. "TX_SA_14_STAT,Status of TX SA 14" "0: TX_SA_14_STAT,?..."
            newline
            bitfld.long 0x00 13. "TX_SA_13_STAT,Status of TX SA 13" "0: TX_SA_13_STAT,?..."
            bitfld.long 0x00 12. "TX_SA_12_STAT,Status of TX SA 12" "0: TX_SA_12_STAT,?..."
            newline
            bitfld.long 0x00 11. "TX_SA_11_STAT,Status of TX SA 11" "0: TX_SA_11_STAT,?..."
            bitfld.long 0x00 10. "TX_SA_10_STAT,Status of TX SA 10" "0: TX_SA_10_STAT,?..."
            newline
            bitfld.long 0x00 9. "TX_SA_9_STAT,Status of TX SA 9" "0: TX_SA_9_STAT,?..."
            bitfld.long 0x00 8. "TX_SA_8_STAT,Status of TX SA 8" "0: TX_SA_8_STAT,?..."
            newline
            bitfld.long 0x00 7. "TX_SA_7_STAT,Status of TX SA 7" "0: TX_SA_7_STAT,?..."
            bitfld.long 0x00 6. "TX_SA_6_STAT,Status of TX SA 6" "0: TX_SA_6_STAT,?..."
            newline
            bitfld.long 0x00 5. "TX_SA_5_STAT,Status of TX SA 5" "0: TX_SA_5_STAT,?..."
            bitfld.long 0x00 4. "TX_SA_4_STAT,Status of TX SA 4" "0: TX_SA_4_STAT,?..."
            newline
            bitfld.long 0x00 3. "TX_SA_3_STAT,Status of TX SA 3" "0: TX_SA_3_STAT,?..."
            bitfld.long 0x00 2. "TX_SA_2_STAT,Status of TX SA 2" "0: TX_SA_2_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_SA_1_STAT,Status of TX SA 1" "0: TX_SA_1_STAT,?..."
            bitfld.long 0x00 0. "TX_SA_0_STAT,Status of TX SA 0" "0: TX_SA_0_STAT,?..."
    group.long 0x500C++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_0,Interrupt Enable for each IRQ type of Tx SA 0"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5010++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_0,Interrupt Status for each IRQ type of Tx SA 0"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x5014++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_1,Interrupt Enable for each IRQ type of Tx SA 1"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5018++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_1,Interrupt Status for each IRQ type of Tx SA 1"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x501C++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_2,Interrupt Enable for each IRQ type of Tx SA 2"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5020++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_2,Interrupt Status for each IRQ type of Tx SA 2"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x5024++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_3,Interrupt Enable for each IRQ type of Tx SA 3"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5028++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_3,Interrupt Status for each IRQ type of Tx SA 3"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x502C++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_4,Interrupt Enable for each IRQ type of Tx SA 4"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5030++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_4,Interrupt Status for each IRQ type of Tx SA 4"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x5034++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_5,Interrupt Enable for each IRQ type of Tx SA 5"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5038++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_5,Interrupt Status for each IRQ type of Tx SA 5"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x503C++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_6,Interrupt Enable for each IRQ type of Tx SA 6"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5040++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_6,Interrupt Status for each IRQ type of Tx SA 6"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x5044++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_7,Interrupt Enable for each IRQ type of Tx SA 7"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5048++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_7,Interrupt Status for each IRQ type of Tx SA 7"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x504C++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_8,Interrupt Enable for each IRQ type of Tx SA 8"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5050++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_8,Interrupt Status for each IRQ type of Tx SA 8"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x5054++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_9,Interrupt Enable for each IRQ type of Tx SA 9"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5058++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_9,Interrupt Status for each IRQ type of Tx SA 9"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x505C++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_10,Interrupt Enable for each IRQ type of Tx SA 10"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5060++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_10,Interrupt Status for each IRQ type of Tx SA 10"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x5064++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_11,Interrupt Enable for each IRQ type of Tx SA 11"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5068++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_11,Interrupt Status for each IRQ type of Tx SA 11"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x506C++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_12,Interrupt Enable for each IRQ type of Tx SA 12"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5070++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_12,Interrupt Status for each IRQ type of Tx SA 12"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x5074++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_13,Interrupt Enable for each IRQ type of Tx SA 13"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5078++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_13,Interrupt Status for each IRQ type of Tx SA 13"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x507C++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_14,Interrupt Enable for each IRQ type of Tx SA 14"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5080++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_14,Interrupt Status for each IRQ type of Tx SA 14"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x5084++0x03
        line.long 0x00 "IRQ_TYPE_EN_TX_SA_15,Interrupt Enable for each IRQ type of Tx SA 15"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "?,1: SA_GLBL_EN"
            hexmask.long 0x00 5.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 4. "TX_INACTIVE_SA_EN,Enables the Tx Inactive SA interrupt" "?,1: TX_INACTIVE_SA_EN"
            bitfld.long 0x00 3. "SOFT_TTL_EN,Enables the Soft TTL interrupt" "?,1: SOFT_TTL_EN"
            newline
            bitfld.long 0x00 2. "HARD_TTL_EN,Enables the Hard TTL interrupt" "?,1: HARD_TTL_EN"
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_EN,Enables the Tx Frame too long interrupt" "?,1: TX_FRAME_TOO_LONG_EN"
            newline
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_EN,Enables the Tx Lookup frame discarded interrupt" "?,1: TX_LOOKUP_DSC_EN"
    group.long 0x5088++0x03
        line.long 0x00 "IRQ_TYPE_STAT_TX_SA_15,Interrupt Status for each IRQ type of Tx SA 15"
            hexmask.long 0x00 5.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 4. "TX_INACTIVE_SA_STAT,Current status of Tx Inactive SA interrupt" "0: TX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 3. "SOFT_TTL_STAT,Current status of Soft TTL interrupt" "0: SOFT_TTL_STAT,?..."
            bitfld.long 0x00 2. "HARD_TTL_STAT,Current status of Hard TTL interrupt" "0: HARD_TTL_STAT,?..."
            newline
            bitfld.long 0x00 1. "TX_FRAME_TOO_LONG_STAT,Current status of Tx Frame too long interrupt" "0: TX_FRAME_TOO_LONG_STAT,?..."
            bitfld.long 0x00 0. "TX_LOOKUP_DSC_STAT,Current status of Tx Lookup frame discarded interrupt" "0: TX_LOOKUP_DSC_STAT,?..."
    group.long 0x508C++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_0,Interrupt Enable for each IRQ type of Rx SA 0"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x5090++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_0,Interrupt Status for each IRQ type of Rx SA 0"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x5094++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_1,Interrupt Enable for each IRQ type of Rx SA 1"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x5098++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_1,Interrupt Status for each IRQ type of Rx SA 1"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x509C++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_2,Interrupt Enable for each IRQ type of Rx SA 2"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x50A0++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_2,Interrupt Status for each IRQ type of Rx SA 2"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x50A4++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_3,Interrupt Enable for each IRQ type of Rx SA 3"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x50A8++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_3,Interrupt Status for each IRQ type of Rx SA 3"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x50AC++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_4,Interrupt Enable for each IRQ type of Rx SA 4"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x50B0++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_4,Interrupt Status for each IRQ type of Rx SA 4"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x50B4++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_5,Interrupt Enable for each IRQ type of Rx SA 5"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x50B8++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_5,Interrupt Status for each IRQ type of Rx SA 5"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x50BC++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_6,Interrupt Enable for each IRQ type of Rx SA 6"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x50C0++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_6,Interrupt Status for each IRQ type of Rx SA 6"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x50C4++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_7,Interrupt Enable for each IRQ type of Rx SA 7"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x50C8++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_7,Interrupt Status for each IRQ type of Rx SA 7"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x50CC++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_8,Interrupt Enable for each IRQ type of Rx SA 8"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x50D0++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_8,Interrupt Status for each IRQ type of Rx SA 8"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x50D4++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_9,Interrupt Enable for each IRQ type of Rx SA 9"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x50D8++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_9,Interrupt Status for each IRQ type of Rx SA 9"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x50DC++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_10,Interrupt Enable for each IRQ type of Rx SA 10"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x50E0++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_10,Interrupt Status for each IRQ type of Rx SA 10"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x50E4++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_11,Interrupt Enable for each IRQ type of Rx SA 11"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x50E8++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_11,Interrupt Status for each IRQ type of Rx SA 11"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x50EC++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_12,Interrupt Enable for each IRQ type of Rx SA 12"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x50F0++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_12,Interrupt Status for each IRQ type of Rx SA 12"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x50F4++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_13,Interrupt Enable for each IRQ type of Rx SA 13"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x50F8++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_13,Interrupt Status for each IRQ type of Rx SA 13"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x50FC++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_14,Interrupt Enable for each IRQ type of Rx SA 14"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x5100++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_14,Interrupt Status for each IRQ type of Rx SA 14"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."
    group.long 0x5104++0x03
        line.long 0x00 "IRQ_TYPE_EN_RX_SA_15,Interrupt Enable for each IRQ type of Rx SA 15"
            bitfld.long 0x00 31. "SA_GLBL_EN,Global SA enable control for interrupt sources" "0: SA_GLBL_EN,?..."
            hexmask.long.tbyte 0x00 7.--30. 1. "reserved_0,Reserved bits"
            newline
            bitfld.long 0x00 6. "RX_INACTIVE_SA_EN,Enables the RX Inactive SA" "?,1: RX_INACTIVE_SA_EN"
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_EN,Enables the RX Unknown Cipher interrupt" "?,1: RX_UNKNOWN_CIPH_EN"
            newline
            bitfld.long 0x00 4. "RX_PRE_REPLAY_EN,Enables the RX Pre Replay interrupt" "?,1: RX_PRE_REPLAY_EN"
            bitfld.long 0x00 3. "RX_POST_REPLAY_EN,Enables the RX Post Replay interrupt" "?,1: RX_POST_REPLAY_EN"
            newline
            bitfld.long 0x00 2. "RX_BAD_SECTAG_EN,Enables the RX Bad Sectag interrupt" "?,1: RX_BAD_SECTAG_EN"
            bitfld.long 0x00 1. "RX_CHECK_FAIL_EN,Enables the RX Check Fail interrupt meaning that an Rx frame failed the integrity check" "?,1: RX_CHECK_FAIL_EN"
            newline
            bitfld.long 0x00 0. "RX_NEW_SA_EN,Enables the New SA detected interrupt i.e An Rx frame was received on an SA for the first time" "?,1: RX_NEW_SA_EN"
    group.long 0x5108++0x03
        line.long 0x00 "IRQ_TYPE_STAT_RX_SA_15,Interrupt Status for each IRQ type of Rx SA 15"
            hexmask.long 0x00 7.--31. 1. "reserved_0,Reserved bits"
            bitfld.long 0x00 6. "RX_INACTIVE_SA_STAT,Current status of RX Inactive SA" "0: RX_INACTIVE_SA_STAT,?..."
            newline
            bitfld.long 0x00 5. "RX_UNKNOWN_CIPH_STAT,Current status of RX Unknown Cipher interrupt" "0: RX_UNKNOWN_CIPH_STAT,?..."
            bitfld.long 0x00 4. "RX_PRE_REPLAY_STAT,Current status of RX Pre Replay interrupt" "0: RX_PRE_REPLAY_STAT,?..."
            newline
            bitfld.long 0x00 3. "RX_POST_REPLAY_STAT,Current status of RX Post Replay interrupt" "0: RX_POST_REPLAY_STAT,?..."
            bitfld.long 0x00 2. "RX_BAD_SECTAG_STAT,Current status of RX Bad Sectag interrupt" "0: RX_BAD_SECTAG_STAT,?..."
            newline
            bitfld.long 0x00 1. "RX_CHECK_FAIL_STAT,Current status of RX Check Fail interrupt" "0: RX_CHECK_FAIL_STAT,?..."
            bitfld.long 0x00 0. "RX_NEW_SA_STAT,Current status of New SA detected interrupt" "0: RX_NEW_SA_STAT,?..."

    rgroup.long 0x6000++0x03
        line.long 0x00 "SALT_TABLE_3_0,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x6004++0x03
        line.long 0x00 "SALT_TABLE_2_0,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x6008++0x03
        line.long 0x00 "SALT_TABLE_1_0,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x600C++0x03
        line.long 0x00 "SALT_TABLE_0_0,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x6010++0x03
        line.long 0x00 "SALT_TABLE_3_1,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x6014++0x03
        line.long 0x00 "SALT_TABLE_2_1,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x6018++0x03
        line.long 0x00 "SALT_TABLE_1_1,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x601C++0x03
        line.long 0x00 "SALT_TABLE_0_1,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x6020++0x03
        line.long 0x00 "SALT_TABLE_3_2,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x6024++0x03
        line.long 0x00 "SALT_TABLE_2_2,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x6028++0x03
        line.long 0x00 "SALT_TABLE_1_2,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x602C++0x03
        line.long 0x00 "SALT_TABLE_0_2,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x6030++0x03
        line.long 0x00 "SALT_TABLE_3_3,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x6034++0x03
        line.long 0x00 "SALT_TABLE_2_3,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x6038++0x03
        line.long 0x00 "SALT_TABLE_1_3,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x603C++0x03
        line.long 0x00 "SALT_TABLE_0_3,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x6040++0x03
        line.long 0x00 "SALT_TABLE_3_4,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x6044++0x03
        line.long 0x00 "SALT_TABLE_2_4,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x6048++0x03
        line.long 0x00 "SALT_TABLE_1_4,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x604C++0x03
        line.long 0x00 "SALT_TABLE_0_4,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x6050++0x03
        line.long 0x00 "SALT_TABLE_3_5,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x6054++0x03
        line.long 0x00 "SALT_TABLE_2_5,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x6058++0x03
        line.long 0x00 "SALT_TABLE_1_5,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x605C++0x03
        line.long 0x00 "SALT_TABLE_0_5,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x6060++0x03
        line.long 0x00 "SALT_TABLE_3_6,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x6064++0x03
        line.long 0x00 "SALT_TABLE_2_6,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x6068++0x03
        line.long 0x00 "SALT_TABLE_1_6,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x606C++0x03
        line.long 0x00 "SALT_TABLE_0_6,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x6070++0x03
        line.long 0x00 "SALT_TABLE_3_7,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x6074++0x03
        line.long 0x00 "SALT_TABLE_2_7,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x6078++0x03
        line.long 0x00 "SALT_TABLE_1_7,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x607C++0x03
        line.long 0x00 "SALT_TABLE_0_7,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x6080++0x03
        line.long 0x00 "SALT_TABLE_3_8,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x6084++0x03
        line.long 0x00 "SALT_TABLE_2_8,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x6088++0x03
        line.long 0x00 "SALT_TABLE_1_8,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x608C++0x03
        line.long 0x00 "SALT_TABLE_0_8,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x6090++0x03
        line.long 0x00 "SALT_TABLE_3_9,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x6094++0x03
        line.long 0x00 "SALT_TABLE_2_9,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x6098++0x03
        line.long 0x00 "SALT_TABLE_1_9,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x609C++0x03
        line.long 0x00 "SALT_TABLE_0_9,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x60A0++0x03
        line.long 0x00 "SALT_TABLE_3_10,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x60A4++0x03
        line.long 0x00 "SALT_TABLE_2_10,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x60A8++0x03
        line.long 0x00 "SALT_TABLE_1_10,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x60AC++0x03
        line.long 0x00 "SALT_TABLE_0_10,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x60B0++0x03
        line.long 0x00 "SALT_TABLE_3_11,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x60B4++0x03
        line.long 0x00 "SALT_TABLE_2_11,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x60B8++0x03
        line.long 0x00 "SALT_TABLE_1_11,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x60BC++0x03
        line.long 0x00 "SALT_TABLE_0_11,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x60C0++0x03
        line.long 0x00 "SALT_TABLE_3_12,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x60C4++0x03
        line.long 0x00 "SALT_TABLE_2_12,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x60C8++0x03
        line.long 0x00 "SALT_TABLE_1_12,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x60CC++0x03
        line.long 0x00 "SALT_TABLE_0_12,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x60D0++0x03
        line.long 0x00 "SALT_TABLE_3_13,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x60D4++0x03
        line.long 0x00 "SALT_TABLE_2_13,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x60D8++0x03
        line.long 0x00 "SALT_TABLE_1_13,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x60DC++0x03
        line.long 0x00 "SALT_TABLE_0_13,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x60E0++0x03
        line.long 0x00 "SALT_TABLE_3_14,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x60E4++0x03
        line.long 0x00 "SALT_TABLE_2_14,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x60E8++0x03
        line.long 0x00 "SALT_TABLE_1_14,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x60EC++0x03
        line.long 0x00 "SALT_TABLE_0_14,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"

    rgroup.long 0x60F0++0x03
        line.long 0x00 "SALT_TABLE_3_15,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "reserved,Reserved bits"

    group.long 0x60F4++0x03
        line.long 0x00 "SALT_TABLE_2_15,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x60F8++0x03
        line.long 0x00 "SALT_TABLE_1_15,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x60FC++0x03
        line.long 0x00 "SALT_TABLE_0_15,16-entry Salt table with 96-bit Salt value per CA"
            hexmask.long 0x00 0.--31. 1. "Salt_value,16-entry Salt table with 96-bit Salt value per CA"
    group.long 0x8040++0x03
        line.long 0x00 "AR_UPDATE_CTRL_PN,Anti rplay control register msb"
            hexmask.long 0x00 0.--31. 1. "PN,New minPN value to set in SA"
    group.long 0x8044++0x03
        line.long 0x00 "AR_UPDATE_CTRL_SAI,Anti rplay control register"
            hexmask.long 0x00 4.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--3. "SAI,SA Index to update" "0: SAI,?..."

    rgroup.long 0x8048++0x03
        line.long 0x00 "AR_UPDATE_STAT,Anti rplay control register msb"
            hexmask.long 0x00 1.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0. "BUSY,Indicates that a PN update is in progress" "0: BUSY,?..."

    group.long 0x8050++0x03
        line.long 0x00 "AR_UPDATE_XPN_CTRL_HIGH,Anti rplay control register"
            hexmask.long 0x00 0.--31. 1. "XPN,New minXPN value to set in SA"
    group.long 0x8054++0x03
        line.long 0x00 "AR_UPDATE_XPN_CTRL_LOW,Anti rplay control register"
            hexmask.long 0x00 0.--31. 1. "XPN,New minXPN value to set in SA"

    rgroup.long 0x8080++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_0,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x8084++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_0,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_0,AR_PN_WIN_SIZE_0" "0: AR_PN_WIN_SIZE_0,?..."

    rgroup.long 0x8088++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_1,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x808C++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_1,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_1,AR_PN_WIN_SIZE_1" "0: AR_PN_WIN_SIZE_1,?..."

    rgroup.long 0x8090++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_2,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x8094++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_2,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_2,AR_PN_WIN_SIZE_2" "0: AR_PN_WIN_SIZE_2,?..."

    rgroup.long 0x8098++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_3,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x809C++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_3,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_3,AR_PN_WIN_SIZE_3" "0: AR_PN_WIN_SIZE_3,?..."

    rgroup.long 0x80A0++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_4,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x80A4++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_4,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_4,AR_PN_WIN_SIZE_4" "0: AR_PN_WIN_SIZE_4,?..."

    rgroup.long 0x80A8++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_5,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x80AC++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_5,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_5,AR_PN_WIN_SIZE_5" "0: AR_PN_WIN_SIZE_5,?..."

    rgroup.long 0x80B0++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_6,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x80B4++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_6,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_6,AR_PN_WIN_SIZE_6" "0: AR_PN_WIN_SIZE_6,?..."

    rgroup.long 0x80B8++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_7,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x80BC++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_7,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_7,AR_PN_WIN_SIZE_7" "0: AR_PN_WIN_SIZE_7,?..."

    rgroup.long 0x80C0++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_8,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x80C4++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_8,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_8,AR_PN_WIN_SIZE_8" "0: AR_PN_WIN_SIZE_8,?..."

    rgroup.long 0x80C8++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_9,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x80CC++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_9,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_9,AR_PN_WIN_SIZE_9" "0: AR_PN_WIN_SIZE_9,?..."

    rgroup.long 0x80D0++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_10,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x80D4++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_10,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_10,AR_PN_WIN_SIZE_10" "0: AR_PN_WIN_SIZE_10,?..."

    rgroup.long 0x80D8++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_11,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x80DC++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_11,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_11,AR_PN_WIN_SIZE_11" "0: AR_PN_WIN_SIZE_11,?..."

    rgroup.long 0x80E0++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_12,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x80E4++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_12,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_12,AR_PN_WIN_SIZE_12" "0: AR_PN_WIN_SIZE_12,?..."

    rgroup.long 0x80E8++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_13,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x80EC++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_13,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_13,AR_PN_WIN_SIZE_13" "0: AR_PN_WIN_SIZE_13,?..."

    rgroup.long 0x80F0++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_14,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x80F4++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_14,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_14,AR_PN_WIN_SIZE_14" "0: AR_PN_WIN_SIZE_14,?..."

    rgroup.long 0x80F8++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_HIGH_15,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved_1,Reserved bits"
            bitfld.long 0x00 0.--4. "Reserved_0,Reserved bits" "0: Reserved_0,?..."

    group.long 0x80FC++0x03
        line.long 0x00 "AR_PN_WIN_SIZE_LOW_15,Anti-replay window size configuration registers"
            hexmask.long 0x00 5.--31. 1. "Reserved,Reserved bits"
            bitfld.long 0x00 0.--4. "AR_PN_WIN_SIZE_15,AR_PN_WIN_SIZE_15" "0: AR_PN_WIN_SIZE_15,?..."
    group.long 0x9000++0x03
        line.long 0x00 "Tx_SAD_0_0_HIGH,Tx SAD entry 0 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x9004++0x03
        line.long 0x00 "Tx_SAD_0_0_LOW,Tx SAD entry 0 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x9008++0x03
        line.long 0x00 "Tx_SAD_0_1_HIGH,Tx SAD entry 0 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x900C++0x03
        line.long 0x00 "Tx_SAD_0_1_LOW,Tx SAD entry 0 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x9010++0x03
        line.long 0x00 "Tx_SAD_0_2_HIGH,Tx SAD entry 0 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9014++0x03
        line.long 0x00 "Tx_SAD_0_2_LOW,Tx SAD entry 0 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9020++0x03
        line.long 0x00 "Tx_SAD_1_0_HIGH,Tx SAD entry 1 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x9024++0x03
        line.long 0x00 "Tx_SAD_1_0_LOW,Tx SAD entry 1 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x9028++0x03
        line.long 0x00 "Tx_SAD_1_1_HIGH,Tx SAD entry 1 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x902C++0x03
        line.long 0x00 "Tx_SAD_1_1_LOW,Tx SAD entry 1 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x9030++0x03
        line.long 0x00 "Tx_SAD_1_2_HIGH,Tx SAD entry 1 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9034++0x03
        line.long 0x00 "Tx_SAD_1_2_LOW,Tx SAD entry 1 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9040++0x03
        line.long 0x00 "Tx_SAD_2_0_HIGH,Tx SAD entry 2 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x9044++0x03
        line.long 0x00 "Tx_SAD_2_0_LOW,Tx SAD entry 2 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x9048++0x03
        line.long 0x00 "Tx_SAD_2_1_HIGH,Tx SAD entry 2 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x904C++0x03
        line.long 0x00 "Tx_SAD_2_1_LOW,Tx SAD entry 2 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x9050++0x03
        line.long 0x00 "Tx_SAD_2_2_HIGH,Tx SAD entry 2 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9054++0x03
        line.long 0x00 "Tx_SAD_2_2_LOW,Tx SAD entry 2 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9060++0x03
        line.long 0x00 "Tx_SAD_3_0_HIGH,Tx SAD entry 3 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x9064++0x03
        line.long 0x00 "Tx_SAD_3_0_LOW,Tx SAD entry 3 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x9068++0x03
        line.long 0x00 "Tx_SAD_3_1_HIGH,Tx SAD entry 3 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x906C++0x03
        line.long 0x00 "Tx_SAD_3_1_LOW,Tx SAD entry 3 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x9070++0x03
        line.long 0x00 "Tx_SAD_3_2_HIGH,Tx SAD entry 3 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9074++0x03
        line.long 0x00 "Tx_SAD_3_2_LOW,Tx SAD entry 3 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9080++0x03
        line.long 0x00 "Tx_SAD_4_0_HIGH,Tx SAD entry 4 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x9084++0x03
        line.long 0x00 "Tx_SAD_4_0_LOW,Tx SAD entry 4 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x9088++0x03
        line.long 0x00 "Tx_SAD_4_1_HIGH,Tx SAD entry 4 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x908C++0x03
        line.long 0x00 "Tx_SAD_4_1_LOW,Tx SAD entry 4 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x9090++0x03
        line.long 0x00 "Tx_SAD_4_2_HIGH,Tx SAD entry 4 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9094++0x03
        line.long 0x00 "Tx_SAD_4_2_LOW,Tx SAD entry 4 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x90A0++0x03
        line.long 0x00 "Tx_SAD_5_0_HIGH,Tx SAD entry 5 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x90A4++0x03
        line.long 0x00 "Tx_SAD_5_0_LOW,Tx SAD entry 5 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x90A8++0x03
        line.long 0x00 "Tx_SAD_5_1_HIGH,Tx SAD entry 5 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x90AC++0x03
        line.long 0x00 "Tx_SAD_5_1_LOW,Tx SAD entry 5 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x90B0++0x03
        line.long 0x00 "Tx_SAD_5_2_HIGH,Tx SAD entry 5 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x90B4++0x03
        line.long 0x00 "Tx_SAD_5_2_LOW,Tx SAD entry 5 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x90C0++0x03
        line.long 0x00 "Tx_SAD_6_0_HIGH,Tx SAD entry 6 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x90C4++0x03
        line.long 0x00 "Tx_SAD_6_0_LOW,Tx SAD entry 6 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x90C8++0x03
        line.long 0x00 "Tx_SAD_6_1_HIGH,Tx SAD entry 6 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x90CC++0x03
        line.long 0x00 "Tx_SAD_6_1_LOW,Tx SAD entry 6 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x90D0++0x03
        line.long 0x00 "Tx_SAD_6_2_HIGH,Tx SAD entry 6 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x90D4++0x03
        line.long 0x00 "Tx_SAD_6_2_LOW,Tx SAD entry 6 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x90E0++0x03
        line.long 0x00 "Tx_SAD_7_0_HIGH,Tx SAD entry 7 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x90E4++0x03
        line.long 0x00 "Tx_SAD_7_0_LOW,Tx SAD entry 7 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x90E8++0x03
        line.long 0x00 "Tx_SAD_7_1_HIGH,Tx SAD entry 7 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x90EC++0x03
        line.long 0x00 "Tx_SAD_7_1_LOW,Tx SAD entry 7 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x90F0++0x03
        line.long 0x00 "Tx_SAD_7_2_HIGH,Tx SAD entry 7 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x90F4++0x03
        line.long 0x00 "Tx_SAD_7_2_LOW,Tx SAD entry 7 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9100++0x03
        line.long 0x00 "Tx_SAD_8_0_HIGH,Tx SAD entry 8 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x9104++0x03
        line.long 0x00 "Tx_SAD_8_0_LOW,Tx SAD entry 8 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x9108++0x03
        line.long 0x00 "Tx_SAD_8_1_HIGH,Tx SAD entry 8 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x910C++0x03
        line.long 0x00 "Tx_SAD_8_1_LOW,Tx SAD entry 8 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x9110++0x03
        line.long 0x00 "Tx_SAD_8_2_HIGH,Tx SAD entry 8 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9114++0x03
        line.long 0x00 "Tx_SAD_8_2_LOW,Tx SAD entry 8 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9120++0x03
        line.long 0x00 "Tx_SAD_9_0_HIGH,Tx SAD entry 9 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x9124++0x03
        line.long 0x00 "Tx_SAD_9_0_LOW,Tx SAD entry 9 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x9128++0x03
        line.long 0x00 "Tx_SAD_9_1_HIGH,Tx SAD entry 9 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x912C++0x03
        line.long 0x00 "Tx_SAD_9_1_LOW,Tx SAD entry 9 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x9130++0x03
        line.long 0x00 "Tx_SAD_9_2_HIGH,Tx SAD entry 9 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9134++0x03
        line.long 0x00 "Tx_SAD_9_2_LOW,Tx SAD entry 9 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9140++0x03
        line.long 0x00 "Tx_SAD_10_0_HIGH,Tx SAD entry 10 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x9144++0x03
        line.long 0x00 "Tx_SAD_10_0_LOW,Tx SAD entry 10 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x9148++0x03
        line.long 0x00 "Tx_SAD_10_1_HIGH,Tx SAD entry 10 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x914C++0x03
        line.long 0x00 "Tx_SAD_10_1_LOW,Tx SAD entry 10 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x9150++0x03
        line.long 0x00 "Tx_SAD_10_2_HIGH,Tx SAD entry 10 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9154++0x03
        line.long 0x00 "Tx_SAD_10_2_LOW,Tx SAD entry 10 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9160++0x03
        line.long 0x00 "Tx_SAD_11_0_HIGH,Tx SAD entry 11 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x9164++0x03
        line.long 0x00 "Tx_SAD_11_0_LOW,Tx SAD entry 11 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x9168++0x03
        line.long 0x00 "Tx_SAD_11_1_HIGH,Tx SAD entry 11 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x916C++0x03
        line.long 0x00 "Tx_SAD_11_1_LOW,Tx SAD entry 11 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x9170++0x03
        line.long 0x00 "Tx_SAD_11_2_HIGH,Tx SAD entry 11 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9174++0x03
        line.long 0x00 "Tx_SAD_11_2_LOW,Tx SAD entry 11 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9180++0x03
        line.long 0x00 "Tx_SAD_12_0_HIGH,Tx SAD entry 12 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x9184++0x03
        line.long 0x00 "Tx_SAD_12_0_LOW,Tx SAD entry 12 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x9188++0x03
        line.long 0x00 "Tx_SAD_12_1_HIGH,Tx SAD entry 12 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x918C++0x03
        line.long 0x00 "Tx_SAD_12_1_LOW,Tx SAD entry 12 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x9190++0x03
        line.long 0x00 "Tx_SAD_12_2_HIGH,Tx SAD entry 12 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x9194++0x03
        line.long 0x00 "Tx_SAD_12_2_LOW,Tx SAD entry 12 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x91A0++0x03
        line.long 0x00 "Tx_SAD_13_0_HIGH,Tx SAD entry 13 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x91A4++0x03
        line.long 0x00 "Tx_SAD_13_0_LOW,Tx SAD entry 13 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x91A8++0x03
        line.long 0x00 "Tx_SAD_13_1_HIGH,Tx SAD entry 13 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x91AC++0x03
        line.long 0x00 "Tx_SAD_13_1_LOW,Tx SAD entry 13 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x91B0++0x03
        line.long 0x00 "Tx_SAD_13_2_HIGH,Tx SAD entry 13 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x91B4++0x03
        line.long 0x00 "Tx_SAD_13_2_LOW,Tx SAD entry 13 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x91C0++0x03
        line.long 0x00 "Tx_SAD_14_0_HIGH,Tx SAD entry 14 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x91C4++0x03
        line.long 0x00 "Tx_SAD_14_0_LOW,Tx SAD entry 14 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x91C8++0x03
        line.long 0x00 "Tx_SAD_14_1_HIGH,Tx SAD entry 14 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x91CC++0x03
        line.long 0x00 "Tx_SAD_14_1_LOW,Tx SAD entry 14 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x91D0++0x03
        line.long 0x00 "Tx_SAD_14_2_HIGH,Tx SAD entry 14 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x91D4++0x03
        line.long 0x00 "Tx_SAD_14_2_LOW,Tx SAD entry 14 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x91E0++0x03
        line.long 0x00 "Tx_SAD_15_0_HIGH,Tx SAD entry 15 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET,Length in bytes of conditionally offset to apply (59:53 in the 64-bit word)"
            newline
            bitfld.long 0x00 2.--6. "TCI,The following bits to put in the TCI field in concatenated order {ES SC SCB E C}" "0: TCI,?..."
            bitfld.long 0x00 1. "AN_HI,The upper bit of the Association Number for this frame (bit 33 in the 64-bit word)" "0: AN_HI,?..."
    group.long 0x91E4++0x03
        line.long 0x00 "Tx_SAD_15_0_LOW,Tx SAD entry 15 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Next packet number"
    group.long 0x91E8++0x03
        line.long 0x00 "Tx_SAD_15_1_HIGH,Tx SAD entry 15 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 16.--31. 1. "PORT,Port value to use when creating the SCI (63:48 in the 64-bit word)"
            hexmask.long.word 0x00 0.--13. 1. "MTU,Maximum Transmission Unit size of the media that this SA controls"
    group.long 0x91EC++0x03
        line.long 0x00 "Tx_SAD_15_1_LOW,Tx SAD entry 15 Second 64-bit word lower bits"
            hexmask.long.word 0x00 16.--31. 1. "SOFT_TTL,Most significant 16 bits only the lower 16 bits are implied as zero"
            hexmask.long.word 0x00 0.--15. 1. "HARD_TTL,Most significant 16 bits only"
    group.long 0x91F0++0x03
        line.long 0x00 "Tx_SAD_15_2_HIGH,Tx SAD entry 15 Third 64-bit word higher bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0x91F4++0x03
        line.long 0x00 "Tx_SAD_15_2_LOW,Tx SAD entry 15 Third 64-bit word lower bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used where the ES bit is clear in the TCI"
    group.long 0xC000++0x03
        line.long 0x00 "Rx_SAD_0_0_HIGH,Rx SAD entry 0 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC004++0x03
        line.long 0x00 "Rx_SAD_0_0_LOW,Rx SAD entry 0 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC008++0x03
        line.long 0x00 "Rx_SAD_0_1_HIGH,Rx SAD entry 0 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC00C++0x03
        line.long 0x00 "Rx_SAD_0_1_LOW,Rx SAD entry 0 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC010++0x03
        line.long 0x00 "Rx_SAD_1_0_HIGH,Rx SAD entry 1 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC014++0x03
        line.long 0x00 "Rx_SAD_1_0_LOW,Rx SAD entry 1 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC018++0x03
        line.long 0x00 "Rx_SAD_1_1_HIGH,Rx SAD entry 1 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC01C++0x03
        line.long 0x00 "Rx_SAD_1_1_LOW,Rx SAD entry 1 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC020++0x03
        line.long 0x00 "Rx_SAD_2_0_HIGH,Rx SAD entry 2 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC024++0x03
        line.long 0x00 "Rx_SAD_2_0_LOW,Rx SAD entry 2 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC028++0x03
        line.long 0x00 "Rx_SAD_2_1_HIGH,Rx SAD entry 2 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC02C++0x03
        line.long 0x00 "Rx_SAD_2_1_LOW,Rx SAD entry 2 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC030++0x03
        line.long 0x00 "Rx_SAD_3_0_HIGH,Rx SAD entry 3 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC034++0x03
        line.long 0x00 "Rx_SAD_3_0_LOW,Rx SAD entry 3 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC038++0x03
        line.long 0x00 "Rx_SAD_3_1_HIGH,Rx SAD entry 3 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC03C++0x03
        line.long 0x00 "Rx_SAD_3_1_LOW,Rx SAD entry 3 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC040++0x03
        line.long 0x00 "Rx_SAD_4_0_HIGH,Rx SAD entry 4 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC044++0x03
        line.long 0x00 "Rx_SAD_4_0_LOW,Rx SAD entry 4 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC048++0x03
        line.long 0x00 "Rx_SAD_4_1_HIGH,Rx SAD entry 4 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC04C++0x03
        line.long 0x00 "Rx_SAD_4_1_LOW,Rx SAD entry 4 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC050++0x03
        line.long 0x00 "Rx_SAD_5_0_HIGH,Rx SAD entry 5 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC054++0x03
        line.long 0x00 "Rx_SAD_5_0_LOW,Rx SAD entry 5 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC058++0x03
        line.long 0x00 "Rx_SAD_5_1_HIGH,Rx SAD entry 5 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC05C++0x03
        line.long 0x00 "Rx_SAD_5_1_LOW,Rx SAD entry 5 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC060++0x03
        line.long 0x00 "Rx_SAD_6_0_HIGH,Rx SAD entry 6 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC064++0x03
        line.long 0x00 "Rx_SAD_6_0_LOW,Rx SAD entry 6 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC068++0x03
        line.long 0x00 "Rx_SAD_6_1_HIGH,Rx SAD entry 6 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC06C++0x03
        line.long 0x00 "Rx_SAD_6_1_LOW,Rx SAD entry 6 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC070++0x03
        line.long 0x00 "Rx_SAD_7_0_HIGH,Rx SAD entry 7 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC074++0x03
        line.long 0x00 "Rx_SAD_7_0_LOW,Rx SAD entry 7 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC078++0x03
        line.long 0x00 "Rx_SAD_7_1_HIGH,Rx SAD entry 7 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC07C++0x03
        line.long 0x00 "Rx_SAD_7_1_LOW,Rx SAD entry 7 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC080++0x03
        line.long 0x00 "Rx_SAD_8_0_HIGH,Rx SAD entry 8 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC084++0x03
        line.long 0x00 "Rx_SAD_8_0_LOW,Rx SAD entry 8 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC088++0x03
        line.long 0x00 "Rx_SAD_8_1_HIGH,Rx SAD entry 8 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC08C++0x03
        line.long 0x00 "Rx_SAD_8_1_LOW,Rx SAD entry 8 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC090++0x03
        line.long 0x00 "Rx_SAD_9_0_HIGH,Rx SAD entry 9 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC094++0x03
        line.long 0x00 "Rx_SAD_9_0_LOW,Rx SAD entry 9 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC098++0x03
        line.long 0x00 "Rx_SAD_9_1_HIGH,Rx SAD entry 9 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC09C++0x03
        line.long 0x00 "Rx_SAD_9_1_LOW,Rx SAD entry 9 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC0A0++0x03
        line.long 0x00 "Rx_SAD_10_0_HIGH,Rx SAD entry 10 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC0A4++0x03
        line.long 0x00 "Rx_SAD_10_0_LOW,Rx SAD entry 10 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC0A8++0x03
        line.long 0x00 "Rx_SAD_10_1_HIGH,Rx SAD entry 10 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC0AC++0x03
        line.long 0x00 "Rx_SAD_10_1_LOW,Rx SAD entry 10 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC0B0++0x03
        line.long 0x00 "Rx_SAD_11_0_HIGH,Rx SAD entry 11 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC0B4++0x03
        line.long 0x00 "Rx_SAD_11_0_LOW,Rx SAD entry 11 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC0B8++0x03
        line.long 0x00 "Rx_SAD_11_1_HIGH,Rx SAD entry 11 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC0BC++0x03
        line.long 0x00 "Rx_SAD_11_1_LOW,Rx SAD entry 11 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC0C0++0x03
        line.long 0x00 "Rx_SAD_12_0_HIGH,Rx SAD entry 12 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC0C4++0x03
        line.long 0x00 "Rx_SAD_12_0_LOW,Rx SAD entry 12 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC0C8++0x03
        line.long 0x00 "Rx_SAD_12_1_HIGH,Rx SAD entry 12 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC0CC++0x03
        line.long 0x00 "Rx_SAD_12_1_LOW,Rx SAD entry 12 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC0D0++0x03
        line.long 0x00 "Rx_SAD_13_0_HIGH,Rx SAD entry 13 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC0D4++0x03
        line.long 0x00 "Rx_SAD_13_0_LOW,Rx SAD entry 13 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC0D8++0x03
        line.long 0x00 "Rx_SAD_13_1_HIGH,Rx SAD entry 13 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC0DC++0x03
        line.long 0x00 "Rx_SAD_13_1_LOW,Rx SAD entry 13 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC0E0++0x03
        line.long 0x00 "Rx_SAD_14_0_HIGH,Rx SAD entry 14 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC0E4++0x03
        line.long 0x00 "Rx_SAD_14_0_LOW,Rx SAD entry 14 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC0E8++0x03
        line.long 0x00 "Rx_SAD_14_1_HIGH,Rx SAD entry 14 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC0EC++0x03
        line.long 0x00 "Rx_SAD_14_1_LOW,Rx SAD entry 14 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC0F0++0x03
        line.long 0x00 "Rx_SAD_15_0_HIGH,Rx SAD entry 15 First 64-bit word higher 32 bits"
            bitfld.long 0x00 31. "ACTIVE,Indicates if the SA is activated (bit 63 in the 64-bit word)" "0: ACTIVE,?..."
            bitfld.long 0x00 30. "REPLAY,If set replay check is enabled" "0: REPLAY,?..."
            newline
            bitfld.long 0x00 29. "USED,This flag must be clear upon creation of the SA" "0: USED,?..."
            bitfld.long 0x00 27.--28. "VALIDATE,Validate field" "0: VALIDATE,?..."
            newline
            hexmask.long.byte 0x00 20.--26. 1. "OFFSET,Length in bytes of confidentiality offset to apply (58:52 in the 64-bit word)"
            hexmask.long.word 0x00 0.--15. 1. "PORT,Port value to use when processing frames with implicit SCI (SC=0)"
    group.long 0xC0F4++0x03
        line.long 0x00 "Rx_SAD_15_0_LOW,Rx SAD entry 15 First 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "PN,- In non-XPN mode: Minimum acceptable packet number"
    group.long 0xC0F8++0x03
        line.long 0x00 "Rx_SAD_15_1_HIGH,Rx SAD entry 15 Second 64-bit word higher 32 bits"
            hexmask.long.word 0x00 0.--15. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
    group.long 0xC0FC++0x03
        line.long 0x00 "Rx_SAD_15_1_LOW,Rx SAD entry 15 Second 64-bit word lower 32 bits"
            hexmask.long 0x00 0.--31. 1. "SYSTEM_IDENTIFIER,System Identifier to be used for receipt of frames with ES=0 and SC=0"
tree.end

tree "ETHER_SEC ()"
    base ad:0x91934000
    rgroup.long 0x00++0x03
        line.long 0x00 "CORE_VER_NUM,IP Version Number"
            hexmask.long.word 0x00 16.--31. 1. "RESERVED_31_16,Reserved and read as zero"
            hexmask.long.word 0x00 0.--15. 1. "VERSION_NUM,Indicates the coreKit release version number in BCD format"
    rgroup.long 0x04++0x03
        line.long 0x00 "CORE_VER_TYPE,IP Version Type Register"
            hexmask.long.word 0x00 16.--31. 1. "RESERVED_31_16,Reserved and read as zero"
            bitfld.long 0x00 12.--15. "TYPE_ENUM,Indicates the coreKit release type" "0: TYPE_ENUM_REG,?..."
            bitfld.long 0x00 8.--11. "PKG_NUM,Indicates the alphabetical packaging number of coreKit ID" "0: PKG_NUM_REG,?..."
            hexmask.long.byte 0x00 0.--7. 1. "TYPE_NUM,Indicates the coreKit release version type number in BCD format"

    group.long 0x08++0x03
        line.long 0x00 "IRQ_EN,Interrupt Enable Register"
            bitfld.long 0x00 31. "OUTPUT,Enables O_cfg_irq output" "0: UNKN_DESC,?..."
            hexmask.long.word 0x00 18.--30. 1. "RESERVED_31_18,Reserved and read as zero"
            bitfld.long 0x00 17. "FSM_PAR_ERR,Enables interrupt indicating that an FSM parity error has been detected" "0: FSM_PAR_ERR_REG,?..."
            bitfld.long 0x00 16. "REG_PAR_ERR,Enables interrupt indicating that a register parity error has been detected" "0: REG_PAR_ERR_REG,?..."
            newline
            hexmask.long.word 0x00 5.--15. 1. "RESERVED_15_5,Reserved and read as zero"
            bitfld.long 0x00 4. "CTX_IDX_ERR,Enables interrupt indicating that a context index error has been detected" "0: CTX_IDX_ERR_REG,?..."
            rbitfld.long 0x00 2.--3. "RESERVED_3_2,Reserved and read as zero" "0,1,2,3"
            bitfld.long 0x00 0. "KEY_DONE,Enables interrupt indicating that a key load has completed" "0: KEY_DONE_REG,?..."
    group.long 0x0C++0x03
        line.long 0x00 "IRQ_STAT,Interrupt Status Register"
            bitfld.long 0x00 17. "FSM_PAR_ERR,Status of interrupt indicating that an FSM parity error has been detected" "0: FSM_PAR_ERR_REG,?..."
            bitfld.long 0x00 16. "REG_PAR_ERR,Status of interrupt indicating that a register parity error has been detected" "0: REG_PAR_ERR_REG,?..."
            bitfld.long 0x00 4. "CTX_IDX_ERR,Status of interrupt indicating that a context index error has been detected" "0: CTX_IDX_ERR_REG,?..."
            bitfld.long 0x00 0. "KEY_DONE,Status of interrupt indicating that a key load has completed" "0: KEY_DONE_REG,?..."
    group.long 0x14++0x03
        line.long 0x00 "CTRL,Control Register"
            hexmask.long.word 0x00 20.--31. 1. "RESERVED_31_20,Reserved and read as zero"
            bitfld.long 0x00 18. "ENCRYPT,Encrypt/Decrypt selector for the key" "0: ENCRYPT_REG,?..."
            bitfld.long 0x00 16. "KEY_SZ,Size of the key: - 0:128-bit" "?,1: KEY_SZ_REG"
            bitfld.long 0x00 0.--4. "CTX_IDX,Key context index to load the key into" "0: CTX_IDX_REG,?..."

    rgroup.long 0x18++0x03
        line.long 0x00 "STAT,Status Register"
            hexmask.long 0x00 2.--31. 1. "RESERVED_31_2,Reserved and read as zero"
            bitfld.long 0x00 0. "BUSY,Indicates that the core is busy installing a key" "0: UNKN_DESC,?..."

    wgroup.long 0x20++0x03
        line.long 0x00 "KEY_0,Key 0 Register"
            hexmask.long 0x00 0.--31. 1. "KEY,Key bytes: {00 01 02 03}"
    wgroup.long 0x24++0x03
        line.long 0x00 "KEY_1,Key 1 Register"
            hexmask.long 0x00 0.--31. 1. "KEY,Key bytes: {04 05 06 07}"
    wgroup.long 0x28++0x03
        line.long 0x00 "KEY_2,Key 2 Register"
            hexmask.long 0x00 0.--31. 1. "KEY,Key bytes: {08 09 10 11}"
    wgroup.long 0x2C++0x03
        line.long 0x00 "KEY_3,Key 3 Register"
            hexmask.long 0x00 0.--31. 1. "KEY,Key bytes: {12 13 14 15}"
    wgroup.long 0x30++0x03
        line.long 0x00 "KEY_4,Key 4 Register"
            hexmask.long 0x00 0.--31. 1. "KEY,Key bytes: {16 17 18 19} (256-bit key only)"
    wgroup.long 0x34++0x03
        line.long 0x00 "KEY_5,Key 5 Register"
            hexmask.long 0x00 0.--31. 1. "KEY,Key bytes: {20 21 22 23} (256-bit key only)"
    wgroup.long 0x38++0x03
        line.long 0x00 "KEY_6,Key 6 Register"
            hexmask.long 0x00 0.--31. 1. "KEY,Key bytes: {24 25 26 27} (256-bit key only)"
    wgroup.long 0x3C++0x03
        line.long 0x00 "KEY_7,Key 7 Register"
            hexmask.long 0x00 0.--31. 1. "KEY,Key bytes: {28 29 30 31} (256-bit key only)"
tree.end

tree "FUSA_CTRL ()"
    base ad:0x89004000
    group.long 0x00++0x03
        line.long 0x00 "CTRL0,IO Control bank FuSa Test Mode Control Register"
            bitfld.long 0x00 16. "IOCTRL_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "IOCTRL_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "IOCTRL_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "IOCTRL_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "IOCTRL_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "IOCTRL_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "IOCTRL_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0x04++0x03
        line.long 0x00 "STAT0,IO Control bank FuSa Error Status"
            bitfld.long 0x00 4. "IOCTRL_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "IOCTRL_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "IOCTRL_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "IOCTRL_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "IOCTRL_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0x08++0x03
        line.long 0x00 "CTRL1,System Control bank FuSa Test Mode Control Register"
            bitfld.long 0x00 16. "SYSCTRL_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "SYSCTRL_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "SYSCTRL_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "SYSCTRL_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "SYSCTRL_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "SYSCTRL_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "SYSCTRL_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0x0C++0x03
        line.long 0x00 "STAT1,System Control bank FuSa Error Status"
            bitfld.long 0x00 4. "SYSCTRL_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "SYSCTRL_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "SYSCTRL_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "SYSCTRL_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "SYSCTRL_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0x10++0x03
        line.long 0x00 "CTRL2,Aux Accelerator Reg bank FuSa Test Mode Control Register"
            bitfld.long 0x00 20.--22. "AUX_ACC_DP_SW_IF,Test Mode for Software Interface Check for primary data interface" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 16. "AUX_ACC_RB_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "AUX_ACC_RB_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "AUX_ACC_RB_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "AUX_ACC_RB_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "AUX_ACC_RB_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "AUX_ACC_RB_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "AUX_ACC_RB_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0x14++0x03
        line.long 0x00 "STAT2,Aux Accelerator Reg bank FuSa Error Status"
            bitfld.long 0x00 4. "AUX_ACC_RB_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "AUX_ACC_RB_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "AUX_ACC_RB_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "AUX_ACC_RB_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "AUX_ACC_RB_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0x18++0x03
        line.long 0x00 "CTRL3,SysMem Reg bank FuSa Test Mode Control Register"
            bitfld.long 0x00 24.--26. "SYSMEM_P1_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 20.--22. "SYSMEM_P0_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 16. "SYSMEM_RB_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "SYSMEM_RB_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "SYSMEM_RB_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "SYSMEM_RB_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "SYSMEM_RB_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "SYSMEM_RB_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "SYSMEM_RB_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0x1C++0x03
        line.long 0x00 "STAT3,SysMem Reg bank FuSa Error Status"
            bitfld.long 0x00 4. "SYSMEM_RB_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "SYSMEM_RB_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "SYSMEM_RB_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "SYSMEM_RB_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "SYSMEM_RB_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0x20++0x03
        line.long 0x00 "CTRL4,Mipi Wrapper bank FuSa Test Mode Control Register"
            bitfld.long 0x00 16. "MIPI_WRAPPER_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "MIPI_WRAPPER_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "MIPI_WRAPPER_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "MIPI_WRAPPER_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "MIPI_WRAPPER_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "MIPI_WRAPPER_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "MIPI_WRAPPER_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0x24++0x03
        line.long 0x00 "STAT4,Mipi Wrapper bank FuSa Error Status"
            bitfld.long 0x00 4. "MIPI_WRAPPER_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "MIPI_WRAPPER_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "MIPI_WRAPPER_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "MIPI_WRAPPER_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "MIPI_WRAPPER_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0x28++0x03
        line.long 0x00 "CTRL5,DSP BBE32 bank FuSa Test Mode Control Register"
            bitfld.long 0x00 16. "DSP_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "DSP_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "DSP_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "DSP_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "DSP_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "DSP_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "DSP_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0x2C++0x03
        line.long 0x00 "STAT5,DSP BBE32 bank FuSa Error Status"
            bitfld.long 0x00 4. "DSP_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "DSP_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "DSP_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "DSP_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "DSP_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0x30++0x03
        line.long 0x00 "CTRL6,RA bank FuSa Test Mode Control Register"
            bitfld.long 0x00 16. "RA_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "RA_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "RA_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "RA_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "RA_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "RA_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "RA_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0x34++0x03
        line.long 0x00 "STAT6,RA bank FuSa Error Status"
            bitfld.long 0x00 4. "RA_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "RA_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "RA_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "RA_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "RA_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0x38++0x03
        line.long 0x00 "CTRL7,Artie Control bank FuSa Test Mode Control Register"
            bitfld.long 0x00 16. "ARTIE_CTRL_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "ARTIE_CTRL_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "ARTIE_CTRL_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "ARTIE_CTRL_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "ARTIE_CTRL_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "ARTIE_CTRL_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "ARTIE_CTRL_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0x3C++0x03
        line.long 0x00 "STAT7,Artie Control bank FuSa Error Status"
            bitfld.long 0x00 4. "ARTIE_CTRL_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "ARTIE_CTRL_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "ARTIE_CTRL_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "ARTIE_CTRL_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "ARTIE_CTRL_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0x40++0x03
        line.long 0x00 "CTRL8,Clocks and Resets Generator Control bank FuSa Test Mode Control Register"
            bitfld.long 0x00 16. "CRG_CTRL_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "CRG_CTRL_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "CRG_CTRL_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "CRG_CTRL_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "CRG_CTRL_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "CRG_CTRL_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "CRG_CTRL_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0x44++0x03
        line.long 0x00 "STAT8,Clocks and Resets Generator Control bank FuSa Error Status"
            bitfld.long 0x00 4. "CRG_CTRL_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "CRG_CTRL_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "CRG_CTRL_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "CRG_CTRL_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "CRG_CTRL_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0x48++0x03
        line.long 0x00 "CTRL9,GP ADC Control bank FuSa Test Mode Control Register"
            bitfld.long 0x00 16. "GP_ADC_CTRL_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "GP_ADC_CTRL_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "GP_ADC_CTRL_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "GP_ADC_CTRL_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "GP_ADC_CTRL_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "GP_ADC_CTRL_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "GP_ADC_CTRL_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0x4C++0x03
        line.long 0x00 "STAT9,GP ADC Control bank and Ethernet DMA Interface FuSa Error Status"
            bitfld.long 0x00 8. "ETH_DATA_WDATAERR,FuSa Error on Write Data for Ethernet MAC DMA interface" "0,1"
            newline
            bitfld.long 0x00 4. "GP_ADC_CTRL_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "GP_ADC_CTRL_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "GP_ADC_CTRL_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "GP_ADC_CTRL_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "GP_ADC_CTRL_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0x50++0x03
        line.long 0x00 "FCRU_CTRL00,Fault Collection and Recovery Unit Control Register 0"
            hexmask.long 0x00 0.--31. 1. "FAULT_PIN_ENA0,First set of 32 Critical Fault Enables to route to PMU_FAULTB output pin/ball (0 to 31)"
    group.long 0x54++0x03
        line.long 0x00 "FCRU_CTRL01,Fault Collection and Recovery Unit Control Register 1"
            hexmask.long 0x00 0.--31. 1. "FAULT_PIN_ENA1,Second set of 32 Critical Fault Enables to route to PMU_FAULTB output pin/ball (32 to 63)"
    group.long 0x58++0x03
        line.long 0x00 "FCRU_CTRL02,Fault Collection and Recovery Unit Control Register 2"
            hexmask.long 0x00 0.--31. 1. "FAULT_RST_ENA0,First set of 32 Critical Fault Enables to route to Chandra internal self-reset (0 to 31)"
    group.long 0x5C++0x03
        line.long 0x00 "FCRU_CTRL03,Fault Collection and Recovery Unit Control Register 3"
            hexmask.long 0x00 0.--31. 1. "FAULT_RST_ENA1,Second set of 32 Critical Fault Enables to route to Chandra internal self-reset (32 to 63)"
    group.long 0x60++0x03
        line.long 0x00 "FCRU_CTRL04,Fault Collection and Recovery Unit Control Register 4"
            hexmask.long 0x00 0.--31. 1. "FAULT_PIN_DBG_CLR0,First set of 32 Sticky Diagnostic/Debug register clear for Faults routed to PMU_FAULTB output pin/ball (0 to 31)"
    group.long 0x64++0x03
        line.long 0x00 "FCRU_CTRL05,Fault Collection and Recovery Unit Control Register 5"
            hexmask.long 0x00 0.--31. 1. "FAULT_PIN_DBG_CLR1,Second set of 32 Sticky Diagnostic/Debug register clear for Faults routed to PMU_FAULTB output pin/ball (32 to 63)"
    group.long 0x68++0x03
        line.long 0x00 "FCRU_CTRL06,Fault Collection and Recovery Unit Control Register 6"
            hexmask.long 0x00 0.--31. 1. "FAULT_RST_DBG_CLR0,First set of 32 Sticky Diagnostic/Debug register clear for Faults routed to Chandra internal self-reset (0 to 31)"
    group.long 0x6C++0x03
        line.long 0x00 "FCRU_CTRL07,Fault Collection and Recovery Unit Control Register 7"
            hexmask.long 0x00 0.--31. 1. "FAULT_RST_DBG_CLR1,Second set of 32 Sticky Diagnostic/Debug register clear for Faults routed to Chandra internal self-reset (32 to 63)"
    group.long 0x70++0x03
        line.long 0x00 "FCRU_CTRL08,Fault Collection and Recovery Unit Control Register 8"
            hexmask.long 0x00 0.--31. 1. "FAULT_CAP_BYP0,First set of 32 Capture bypass bits"
    group.long 0x74++0x03
        line.long 0x00 "FCRU_CTRL09,Fault Collection and Recovery Unit Control Register 9"
            hexmask.long 0x00 0.--31. 1. "FAULT_CAP_BYP1,Second set of 32 Capture bypass bits"
    group.long 0x78++0x03
        line.long 0x00 "FCRU_CTRL10,Fault Collection and Recovery Unit Control Register 10"
            bitfld.long 0x00 4. "PIN_ATIVE_STATE_CTRL,Active State PMU_FAULTB pin/ball control or in other words Polarity control" "0: Active low (0),1: Active high (1)"
            newline
            bitfld.long 0x00 0.--1. "PIN_INATIVE_STATE_CTRL,Inactive State PMU_FAULTB pin/ball control" "?,1: Driven to logic low (0),2: Driven to logic high (1),?..."
    group.long 0x7C++0x03
        line.long 0x00 "FCRU_CTRL11,Fault Collection and Recovery Unit Control Register 11"
            hexmask.long 0x00 0.--31. 1. "FORCE_FAULT0,Force a fault on the 32 first LSB Fault lines"
    group.long 0x80++0x03
        line.long 0x00 "FCRU_CTRL12,Fault Collection and Recovery Unit Control Register 12"
            hexmask.long 0x00 0.--31. 1. "FORCE_FAULT1,Force a fault on the 32 first MSB Fault lines"
    group.long 0x84++0x03
        line.long 0x00 "FCRU_KEY,Fault Collection and Recovery Unit Key Register 12"
            hexmask.long 0x00 0.--31. 1. "FCRU_KEY,This key needs to be set to 0xCAB005E5 to enable the Force Fault registers to be enabled"

    rgroup.long 0x88++0x03
        line.long 0x00 "FCRU_DIAG0,Fault Collection and Recovery Unit Diagnostic Register 0"
            hexmask.long 0x00 0.--31. 1. "FAULT_PIN_DBG0,First set of 32 Sticky Diagnostic/Debug registers for Faults routed to PMU_FAULTB output pin/ball (0 to 31)"
    rgroup.long 0x8C++0x03
        line.long 0x00 "FCRU_DIAG1,Fault Collection and Recovery Unit Diagnostic Register 1"
            hexmask.long 0x00 0.--31. 1. "FAULT_PIN_DBG1,Second set of 32 Sticky Diagnostic/Debug registers for Faults routed to PMU_FAULTB output pin/ball (32 to 64)"
    rgroup.long 0x90++0x03
        line.long 0x00 "FCRU_DIAG2,Fault Collection and Recovery Unit Diagnostic Register 2"
            hexmask.long 0x00 0.--31. 1. "FAULT_RST_DBG0,First set of 32 Sticky Diagnostic/Debug registers for Faults routed to Chandra internal self-reset (0 to 31)"
    rgroup.long 0x94++0x03
        line.long 0x00 "FCRU_DIAG3,Fault Collection and Recovery Unit Diagnostic Register 3"
            hexmask.long 0x00 0.--31. 1. "FAULT_RST_DBG1,Second set of 32 Sticky Diagnostic/Debug registers for Faults routed to Chandra internal self-reset (32 to 64)"
    rgroup.long 0x98++0x03
        line.long 0x00 "NOC_DIAG0,Network On Chip (Chandra NOC) Diagnostic Register 0"
            hexmask.long 0x00 0.--25. 1. "FAULT_CNOC_DBG,Chandra NOC Fault debug: [00] aacc_t_data_fault"
    rgroup.long 0x9C++0x03
        line.long 0x00 "NOC_DIAG1,Network On Chip (Small NOC) Diagnostic Register 1"
            hexmask.long.word 0x00 0.--12. 1. "FAULT_SNOC_DBG,Small NOC Fault debug: [00] adc_i_data_fault"
    rgroup.long 0xA0++0x03
        line.long 0x00 "NOC_DIAG2,Network On Chip (Artie NOC) Diagnostic Register 2"
            hexmask.long 0x00 0.--26. 1. "FAULT_ANOC_DBG,Artie NOC Fault debug: [ 0] artieserv_t_data_fault"

    group.long 0xA4++0x03
        line.long 0x00 "CTRL10,CRC SFR bank FuSa Test Mode Control Register"
            bitfld.long 0x00 16. "CRCE_CTRL_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8. "CRCE_CTRL_SW_IF,Test Mode for Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 0. "CRCE_CTRL_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Intentionally corrupt byte parity upon register"

    rgroup.long 0xA8++0x03
        line.long 0x00 "STAT10,CRC SFR bank FuSa Error Status"
            bitfld.long 0x00 0.--1. "CRCE_CTRL_ERR,Bit[0]: FuSa Error on Storage Check Bit[1]: FuSa Error on interface" "0,1,2,3"

    group.long 0xAC++0x03
        line.long 0x00 "RMON_CTRL0,Reset monitor non-software serviceable resets control"
            bitfld.long 0x00 4.--5. "CTL_RMON_R52_FRC,Set respective bit to '1' to force reset monitoring of R52 resets to trigger" "0,1,2,3"
            newline
            bitfld.long 0x00 0. "CTL_RMON_SYS_FRC,Set to '1' to force reset monitoring of rst_sys_n to trigger" "0,1"

    rgroup.long 0xB0++0x03
        line.long 0x00 "STICKY_DIAG_STAT0,Additional Sticky Diagnosis Bits Status 0"
            abitfld.long 0x00 0.--31. "STS_ADD_STICKY0," "0x00000001=1: Artie-to-Top bridge initiator data..,0x00000002=2: Artie-to-Top bridge initiator..,0x00000003=3: Debug AP initiator data fault,0x00000004=4: Debug AP initiator timeout fault,0x00000005=5: Debug STM target data fault,0x00000006=6: Debug TMC initiator data fault,0x00000007=7: Debug TMC initiator timeout fault,0x00000008=8: DSP SFR target data fault,0x00000009=9: DSP iDMA initiator data fault,0x0000000A=10: DSP iDMA initiator timeout fault,0x0000000B=11: DSP IPIF target data fault,0x0000000C=12: SysMem data Port 0 target data..,0x0000000D=13: SysMem data Port 1 target data..,0x0000000E=14: MIPI target data fault,0x0000000F=15: DSP OPIF initiator data fault,0x00000010=16: DSP OPIF initiator timeout fault,0x00000011=17: Top Peripheral AHB target timeout..,0x00000012=18: Top Peripheral APB0 target..,0x00000013=19: RA input initiator data fault,0x00000014=20: RA input initiator timeout fault,0x00000015=21: RA output initiator data fault,0x00000016=22: RA output initiator timeout fault,0x00000017=23: Top-to-Artie bridge target data..,0x00000018=24: Chandra NOC internal SFR target..,0x00000019=25: Top Peripheral APB1 target..,0x0000001A=26: Artie Core NoC internal SFR..,0x0000001B=27: CRC Engine target data fault,0x0000001C=28: reserved,0x0000001D=29: reserved,0x0000001E=30: GPIO controller target data fault,0x0000001F=31: HSM initiator data fault"
    rgroup.long 0xB4++0x03
        line.long 0x00 "STICKY_DIAG_STAT1,Additional Sticky Diagnosis Bits Status 1"
            abitfld.long 0x00 0.--31. "STS_ADD_STICKY1," "0x00000001=1: HSM target data fault,0x00000002=2: MCDMA initiator data fault,0x00000003=3: MCDMA initiator timeout fault,0x00000004=4: MCDMA AHB target data fault,0x00000005=5: Multi-Target APB target data fault,0x00000006=6: Multi-Target AHB target data fault,0x00000007=7: FLASH QSPI DMA initiator data fault,0x00000008=8: FLASH QSPI DMA initiator timeout..,0x00000009=9: FLASH QSPI AHB target data fault,0x0000000A=10: R52 M0 initiator data fault,0x0000000B=11: R52 M0 initiator timeout fault,0x0000000C=12: R52 target data fault,0x0000000D=13: General Purpose QSPI AHB target..,0x0000000E=14: Artie Mem target data fault,0x0000000F=15: Top-to-Artie bridge initiator..,0x00000010=16: Top-to-Artie bridge initiator..,0x00000011=17: Artie-to-Top bridge target data..,0x00000012=18: Wrapper-to-Artie bridge initiator..,0x00000013=19: Wrapper-to-Artie bridge initiator..,0x00000014=20: Artie-to-Wrapper bridge target..,0x00000015=21: GPADC DMA initiator data fault,0x00000016=22: GPADC DMA initiator timeout fault,0x00000017=23: Artie-to-Wrapper bridge initiator..,0x00000018=24: Artie-to-Wrapper bridge initiator..,0x00000019=25: Ethernet MAC DMA initiator data..,0x0000001A=26: Ethernet MAC DMA initiator..,0x0000001B=27: OTP target data fault,0x0000001C=28: Wrapper Peripheral AHB target..,0x0000001D=29: Wrapper Peripheral APB target..,0x0000001E=30: MMIC QSPI DMA initiator data fault,0x0000001F=31: MMIC QSPI DMA initiator timeout.."
    rgroup.long 0xB8++0x03
        line.long 0x00 "STICKY_DIAG_STAT2,Additional Sticky Diagnosis Bits Status 2"
            bitfld.long 0x00 0.--1. "STS_ADD_STICKY2," "0,1,2,3"

    group.long 0xBC++0x03
        line.long 0x00 "STICKY_DIAG_CTRL0,Additional Sticky Diagnosis Bits Control 0"
            hexmask.long 0x00 0.--31. 1. "CLR_ADD_STICKY0,Write a '1' to individual bits to clear that respective sticky status bit"
    group.long 0xC0++0x03
        line.long 0x00 "STICKY_DIAG_CTRL1,Additional Sticky Diagnosis Bits Control 1"
            hexmask.long 0x00 0.--31. 1. "CLR_ADD_STICKY1,Write a '1' to individual bits to clear that respective sticky status bit"
    group.long 0xC4++0x03
        line.long 0x00 "STICKY_DIAG_CTRL2,Additional Sticky Diagnosis Bits Control 2"
            bitfld.long 0x00 0.--1. "CLR_ADD_STICKY2,Write a '1' to individual bits to clear that respective sticky status bit" "0,1,2,3"
    group.long 0xC8++0x03
        line.long 0x00 "CTRL11,PWM0 bank FuSa Test Mode Control Register"
            bitfld.long 0x00 16. "PWM0_CTRL_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "PWM0_CTRL_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "PWM0_CTRL_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "PWM0_CTRL_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "PWM0_CTRL_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "PWM0_CTRL_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "PWM0_CTRL_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0xCC++0x03
        line.long 0x00 "STAT11,PWM0 bank FuSa Error Status"
            bitfld.long 0x00 4. "PWM0_CTRL_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "PWM0_CTRL_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "PWM0_CTRL_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "PWM0_CTRL_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "PWM0_CTRL_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0xD0++0x03
        line.long 0x00 "CTRL12,PWM1 bank FuSa Test Mode Control Register"
            bitfld.long 0x00 16. "PWM1_CTRL_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "PWM1_CTRL_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "PWM1_CTRL_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "PWM1_CTRL_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "PWM1_CTRL_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "PWM1_CTRL_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "PWM1_CTRL_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0xD4++0x03
        line.long 0x00 "STAT12,PWM1 bank FuSa Error Status"
            bitfld.long 0x00 4. "PWM1_CTRL_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "PWM1_CTRL_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "PWM1_CTRL_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "PWM1_CTRL_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "PWM1_CTRL_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0xD8++0x03
        line.long 0x00 "CTRL13,PWM2 bank FuSa Test Mode Control Register"
            bitfld.long 0x00 16. "PWM2_CTRL_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "PWM2_CTRL_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "PWM2_CTRL_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "PWM2_CTRL_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "PWM2_CTRL_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "PWM2_CTRL_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "PWM2_CTRL_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0xDC++0x03
        line.long 0x00 "STAT13,PWM2 bank FuSa Error Status"
            bitfld.long 0x00 4. "PWM2_CTRL_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "PWM2_CTRL_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "PWM2_CTRL_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "PWM2_CTRL_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "PWM2_CTRL_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0xE0++0x03
        line.long 0x00 "CTRL14,PWM3 bank FuSa Test Mode Control Register"
            bitfld.long 0x00 16. "PWM3_CTRL_INIT,Initialize the FuSa state machine back to IDLE" "0,1"
            newline
            bitfld.long 0x00 8.--10. "PWM3_CTRL_SW_IF,Test Mode for Software Interface Check" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "PWM3_CTRL_ACCESS_PR2,Test Mode for PRDATA Register Check" "0,1"
            newline
            bitfld.long 0x00 5. "PWM3_CTRL_ACCESS_PR1,Test Mode for PSLVERR Register Check" "0,1"
            newline
            bitfld.long 0x00 4. "PWM3_CTRL_ACCESS_PR0,Test Mode for PREADY Register Check" "0,1"
            newline
            bitfld.long 0x00 2. "PWM3_CTRL_ACCESS_SR,Test Mode for Protocol State Registers Check" "0: Normal operation,1: Main FSM registers are updated but Redundant"
            newline
            bitfld.long 0x00 0.--1. "PWM3_CTRL_STORAGE,Test Mode for Storage Check" "0: Normal operation,1: Write data are NOT updated but the parity bit..,2: Write data are updated but the parity bit is..,3: Normal operation"

    rgroup.long 0xE4++0x03
        line.long 0x00 "STAT14,PWM3 bank FuSa Error Status"
            bitfld.long 0x00 4. "PWM3_CTRL_ERR_CTRL,FuSa Error on Control logic Check" "0,1"
            newline
            bitfld.long 0x00 3. "PWM3_CTRL_ERR_HWIF,FuSa Error on Hardware Interface Check" "0,1"
            newline
            bitfld.long 0x00 2. "PWM3_CTRL_ERR_SWIF,FuSa Error on Software Interface Check" "0,1"
            newline
            bitfld.long 0x00 1. "PWM3_CTRL_ERR_ACCESS,FuSa Error on Access Check" "0,1"
            newline
            bitfld.long 0x00 0. "PWM3_CTRL_ERR_STORAGE,FuSa Error on Storage Check" "0,1"

    group.long 0xE8++0x03
        line.long 0x00 "SPARE,Spare Register"
            hexmask.long 0x00 0.--31. 1. "SPARE,Spare registers"
    group.long 0xEC++0x03
        line.long 0x00 "CTL_LOCK,Lock control"
            hexmask.long 0x00 0.--31. 1. "CTL_FUSA_LOCK_KEY,Write 0xc1916d09 to allow write access to this SFR bank"

    rgroup.long 0xF0++0x03
        line.long 0x00 "STS_LOCK,Lock status"
            bitfld.long 0x00 0. "STS_FUSA_LOCK_N,Lock status for this SFR bank" "0,1"
tree.end

tree "GP_ADC ()"
    base ad:0x88001000
    group.long 0x00++0x03
        line.long 0x00 "ADC_CTRL,GP-ADC Control register"
            hexmask.long.word 0x00 16.--31. 1. "ADC_MUX_SEL,Select analog input"
            newline
            bitfld.long 0x00 12.--14. "ADC_CLK_DIV_SEL,GPADC Clock Division" "0: CLK_GPADC = 250MHz (No Division ) 3.906 MSPS,1: CLK_GPADC = 125MHz (Divide by 2 ) 1.953 MSPS,2: CLK_GPADC = 62.5MHz (Divide by 4 ) 0.976 MSPS,3: CLK_GPADC = 31.25MHz (Divide by 8 ) 0.488 MSPS,4: CLK_GPADC = 15.625MHz (Divide by 16) 0.244 MSPS,?..."
            newline
            bitfld.long 0x00 6.--11. "ADC_CAP_TRIM,SAR cap trim bits (debug only)" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 5. "ADC_COMP_BIAS_BST,Increase comparator bias current by around 33% (debug only)" "0,1"
            newline
            bitfld.long 0x00 4. "ADC_TEST_PAT_INV,Invert static digital test pattern: 12'hFFE" "0,1"
            newline
            bitfld.long 0x00 3. "ADC_TEST_PAT_ENA,Enable static digital test pattern: 12'h001" "0,1"
            newline
            bitfld.long 0x00 2. "ADC_DATA_CLK_INV,val =" "0: Data toggles on falling edge of the clk_data,1: Data toggles on rising edge of the clk_data"
            newline
            bitfld.long 0x00 1. "ADC_DIV_RST_N,When low resets clock divider which creates samples and data clock timing" "0,1"
            newline
            bitfld.long 0x00 0. "ADC_PD,Power down entire ADC" "0,1"
    group.long 0x04++0x03
        line.long 0x00 "OFFSET_CTRL,GP-ADC Offset Control register"
            rbitfld.long 0x00 16.--21. "ADC_OFFSET_VAL,Corrected ADC offset value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 8.--13. "ADC_OFFSET_TRIM,Offset trim bits during manual override of the ADC offset correction scheme (debug only)" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 3. "ADC_OFFSET_CTRL,When high do manual override of the ADC offset correction scheme (debug only)" "0,1"
            newline
            bitfld.long 0x00 2. "ADC_OFFSET_AVG,When high use averaging mechanism in the ADC offset correction scheme" "0,1"
            newline
            bitfld.long 0x00 1. "ADC_OFFSET_BST,When high increase the offset correction range to 2x the original" "0,1"
            newline
            bitfld.long 0x00 0. "ADC_OFFSET_ENA,When high enable the ADC offset correction" "0,1"
    group.long 0x08++0x03
        line.long 0x00 "GEN_CONFIG,GP-ADC General Control register"
            bitfld.long 0x00 4.--5. "TESTMUX_SEL,Selects test mux output" "0: Test Mux selects debug information from..,1: Test Mux selects debug information from..,2: Test Mux selects debug information from..,3: Test Mux selects all zeros"
            newline
            bitfld.long 0x00 3. "AHB_PARITY_ERROR_IENA,Enable AHB parity error generated interrupt" "0,1"
            newline
            bitfld.long 0x00 2. "AHB_ERROR_IENA,Enable AHB error generated interrupt" "0,1"
            newline
            bitfld.long 0x00 1. "GENERAL_ENABLE,General channel enable" "0,1"
            newline
            bitfld.long 0x00 0. "OVERRIDE_CTRL,Overrides hardware controller allowing direct selection of channels" "0,1"

    rgroup.long 0x0C++0x03
        line.long 0x00 "ADC_DATA,GP-ADC data register"
            hexmask.long.word 0x00 0.--11. 1. "ADC_DATA,Samples will be stored here when in override mode"

    group.long 0x10++0x03
        line.long 0x00 "ADC_AHB_ERROR,GP-ADC AHB error flag and type"
            bitfld.long 0x00 3. "AHB_PARITY_ERROR_FLAG,Flag is set if an error is detected in parity bits of data AHB bus" "0,1"
            newline
            bitfld.long 0x00 1.--2. "AHB_ERROR_TYPE,Stores the last received AHB error or unsuported slave response" "0,1,2,3"
            newline
            bitfld.long 0x00 0. "AHB_ERROR_FLAG,Flag is set if an ERROR RETRY or SPLIT response is received from the AHB slave" "0,1"
    group.long 0x14++0x03
        line.long 0x00 "CH0_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH0_START_ADDR_A,Starting address for buffer A"
    group.long 0x18++0x03
        line.long 0x00 "CH0_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH0_START_ADDR_B,Starting address for buffer B"
    group.long 0x1C++0x03
        line.long 0x00 "CH0_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CH0_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CH0_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CH0_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CH0_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CH0_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CH0_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CH0_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CH0_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH0_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0x20++0x03
        line.long 0x00 "CH0_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CH0_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CH0_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0x24++0x03
        line.long 0x00 "CH0_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CH0_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CH0_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0x28++0x03
        line.long 0x00 "CH0_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CH0_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CH0_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0x2C++0x03
        line.long 0x00 "CH0_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CH0_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH0_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0x30++0x03
        line.long 0x00 "CH0_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CH0_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CH0_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0x34++0x03
        line.long 0x00 "CH1_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH1_START_ADDR_A,Starting address for buffer A"
    group.long 0x38++0x03
        line.long 0x00 "CH1_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH1_START_ADDR_B,Starting address for buffer B"
    group.long 0x3C++0x03
        line.long 0x00 "CH1_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CH1_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CH1_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CH1_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CH1_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CH1_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CH1_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CH1_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CH1_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH1_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0x40++0x03
        line.long 0x00 "CH1_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CH1_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CH1_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0x44++0x03
        line.long 0x00 "CH1_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CH1_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CH1_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0x48++0x03
        line.long 0x00 "CH1_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CH1_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CH1_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0x4C++0x03
        line.long 0x00 "CH1_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CH1_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH1_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0x50++0x03
        line.long 0x00 "CH1_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CH1_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CH1_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0x54++0x03
        line.long 0x00 "CH2_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH2_START_ADDR_A,Starting address for buffer A"
    group.long 0x58++0x03
        line.long 0x00 "CH2_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH2_START_ADDR_B,Starting address for buffer B"
    group.long 0x5C++0x03
        line.long 0x00 "CH2_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CH2_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CH2_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CH2_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CH2_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CH2_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CH2_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CH2_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CH2_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH2_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0x60++0x03
        line.long 0x00 "CH2_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CH2_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CH2_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0x64++0x03
        line.long 0x00 "CH2_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CH2_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CH2_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0x68++0x03
        line.long 0x00 "CH2_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CH2_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CH2_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0x6C++0x03
        line.long 0x00 "CH2_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CH2_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH2_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0x70++0x03
        line.long 0x00 "CH2_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CH2_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CH2_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0x74++0x03
        line.long 0x00 "CH3_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH3_START_ADDR_A,Starting address for buffer A"
    group.long 0x78++0x03
        line.long 0x00 "CH3_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH3_START_ADDR_B,Starting address for buffer B"
    group.long 0x7C++0x03
        line.long 0x00 "CH3_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CH3_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CH3_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CH3_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CH3_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CH3_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CH3_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CH3_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CH3_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH3_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0x80++0x03
        line.long 0x00 "CH3_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CH3_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CH3_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0x84++0x03
        line.long 0x00 "CH3_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CH3_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CH3_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0x88++0x03
        line.long 0x00 "CH3_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CH3_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CH3_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0x8C++0x03
        line.long 0x00 "CH3_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CH3_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH3_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0x90++0x03
        line.long 0x00 "CH3_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CH3_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CH3_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0x94++0x03
        line.long 0x00 "CH4_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH4_START_ADDR_A,Starting address for buffer A"
    group.long 0x98++0x03
        line.long 0x00 "CH4_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH4_START_ADDR_B,Starting address for buffer B"
    group.long 0x9C++0x03
        line.long 0x00 "CH4_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CH4_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CH4_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CH4_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CH4_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CH4_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CH4_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CH4_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CH4_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH4_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0xA0++0x03
        line.long 0x00 "CH4_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CH4_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CH4_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0xA4++0x03
        line.long 0x00 "CH4_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CH4_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CH4_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0xA8++0x03
        line.long 0x00 "CH4_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CH4_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CH4_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0xAC++0x03
        line.long 0x00 "CH4_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CH4_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH4_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0xB0++0x03
        line.long 0x00 "CH4_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CH4_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CH4_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0xB4++0x03
        line.long 0x00 "CH5_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH5_START_ADDR_A,Starting address for buffer A"
    group.long 0xB8++0x03
        line.long 0x00 "CH5_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH5_START_ADDR_B,Starting address for buffer B"
    group.long 0xBC++0x03
        line.long 0x00 "CH5_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CH5_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CH5_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CH5_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CH5_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CH5_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CH5_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CH5_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CH5_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH5_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0xC0++0x03
        line.long 0x00 "CH5_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CH5_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CH5_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0xC4++0x03
        line.long 0x00 "CH5_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CH5_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CH5_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0xC8++0x03
        line.long 0x00 "CH5_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CH5_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CH5_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0xCC++0x03
        line.long 0x00 "CH5_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CH5_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH5_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0xD0++0x03
        line.long 0x00 "CH5_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CH5_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CH5_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0xD4++0x03
        line.long 0x00 "CH6_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH6_START_ADDR_A,Starting address for buffer A"
    group.long 0xD8++0x03
        line.long 0x00 "CH6_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH6_START_ADDR_B,Starting address for buffer B"
    group.long 0xDC++0x03
        line.long 0x00 "CH6_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CH6_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CH6_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CH6_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CH6_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CH6_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CH6_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CH6_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CH6_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH6_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0xE0++0x03
        line.long 0x00 "CH6_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CH6_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CH6_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0xE4++0x03
        line.long 0x00 "CH6_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CH6_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CH6_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0xE8++0x03
        line.long 0x00 "CH6_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CH6_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CH6_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0xEC++0x03
        line.long 0x00 "CH6_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CH6_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH6_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0xF0++0x03
        line.long 0x00 "CH6_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CH6_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CH6_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0xF4++0x03
        line.long 0x00 "CH7_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH7_START_ADDR_A,Starting address for buffer A"
    group.long 0xF8++0x03
        line.long 0x00 "CH7_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH7_START_ADDR_B,Starting address for buffer B"
    group.long 0xFC++0x03
        line.long 0x00 "CH7_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CH7_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CH7_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CH7_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CH7_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CH7_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CH7_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CH7_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CH7_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH7_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0x100++0x03
        line.long 0x00 "CH7_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CH7_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CH7_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0x104++0x03
        line.long 0x00 "CH7_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CH7_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CH7_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0x108++0x03
        line.long 0x00 "CH7_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CH7_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CH7_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0x10C++0x03
        line.long 0x00 "CH7_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CH7_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH7_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0x110++0x03
        line.long 0x00 "CH7_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CH7_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CH7_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0x114++0x03
        line.long 0x00 "CH8_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH8_START_ADDR_A,Starting address for buffer A"
    group.long 0x118++0x03
        line.long 0x00 "CH8_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH8_START_ADDR_B,Starting address for buffer B"
    group.long 0x11C++0x03
        line.long 0x00 "CH8_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CH8_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CH8_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CH8_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CH8_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CH8_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CH8_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CH8_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CH8_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH8_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0x120++0x03
        line.long 0x00 "CH8_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CH8_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CH8_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0x124++0x03
        line.long 0x00 "CH8_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CH8_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CH8_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0x128++0x03
        line.long 0x00 "CH8_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CH8_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CH8_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0x12C++0x03
        line.long 0x00 "CH8_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CH8_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH8_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0x130++0x03
        line.long 0x00 "CH8_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CH8_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CH8_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0x134++0x03
        line.long 0x00 "CH9_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH9_START_ADDR_A,Starting address for buffer A"
    group.long 0x138++0x03
        line.long 0x00 "CH9_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CH9_START_ADDR_B,Starting address for buffer B"
    group.long 0x13C++0x03
        line.long 0x00 "CH9_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CH9_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CH9_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CH9_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CH9_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CH9_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CH9_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CH9_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CH9_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH9_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0x140++0x03
        line.long 0x00 "CH9_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CH9_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CH9_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0x144++0x03
        line.long 0x00 "CH9_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CH9_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CH9_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0x148++0x03
        line.long 0x00 "CH9_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CH9_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CH9_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0x14C++0x03
        line.long 0x00 "CH9_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CH9_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CH9_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0x150++0x03
        line.long 0x00 "CH9_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CH9_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CH9_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0x154++0x03
        line.long 0x00 "CHA_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CHA_START_ADDR_A,Starting address for buffer A"
    group.long 0x158++0x03
        line.long 0x00 "CHA_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CHA_START_ADDR_B,Starting address for buffer B"
    group.long 0x15C++0x03
        line.long 0x00 "CHA_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CHA_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CHA_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CHA_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CHA_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CHA_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CHA_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CHA_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CHA_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CHA_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0x160++0x03
        line.long 0x00 "CHA_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CHA_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CHA_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0x164++0x03
        line.long 0x00 "CHA_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CHA_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CHA_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0x168++0x03
        line.long 0x00 "CHA_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CHA_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CHA_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0x16C++0x03
        line.long 0x00 "CHA_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CHA_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CHA_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0x170++0x03
        line.long 0x00 "CHA_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CHA_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CHA_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0x174++0x03
        line.long 0x00 "CHB_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CHB_START_ADDR_A,Starting address for buffer A"
    group.long 0x178++0x03
        line.long 0x00 "CHB_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CHB_START_ADDR_B,Starting address for buffer B"
    group.long 0x17C++0x03
        line.long 0x00 "CHB_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CHB_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CHB_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CHB_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CHB_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CHB_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CHB_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CHB_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CHB_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CHB_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0x180++0x03
        line.long 0x00 "CHB_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CHB_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CHB_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0x184++0x03
        line.long 0x00 "CHB_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CHB_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CHB_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0x188++0x03
        line.long 0x00 "CHB_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CHB_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CHB_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0x18C++0x03
        line.long 0x00 "CHB_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CHB_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CHB_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0x190++0x03
        line.long 0x00 "CHB_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CHB_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CHB_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0x194++0x03
        line.long 0x00 "CHC_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CHC_START_ADDR_A,Starting address for buffer A"
    group.long 0x198++0x03
        line.long 0x00 "CHC_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CHC_START_ADDR_B,Starting address for buffer B"
    group.long 0x19C++0x03
        line.long 0x00 "CHC_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CHC_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CHC_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CHC_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CHC_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CHC_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CHC_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CHC_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CHC_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CHC_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0x1A0++0x03
        line.long 0x00 "CHC_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CHC_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CHC_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0x1A4++0x03
        line.long 0x00 "CHC_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CHC_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CHC_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0x1A8++0x03
        line.long 0x00 "CHC_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CHC_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CHC_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0x1AC++0x03
        line.long 0x00 "CHC_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CHC_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CHC_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0x1B0++0x03
        line.long 0x00 "CHC_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CHC_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CHC_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0x1B4++0x03
        line.long 0x00 "CHD_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CHD_START_ADDR_A,Starting address for buffer A"
    group.long 0x1B8++0x03
        line.long 0x00 "CHD_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CHD_START_ADDR_B,Starting address for buffer B"
    group.long 0x1BC++0x03
        line.long 0x00 "CHD_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CHD_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CHD_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CHD_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CHD_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CHD_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CHD_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CHD_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CHD_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CHD_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0x1C0++0x03
        line.long 0x00 "CHD_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CHD_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CHD_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0x1C4++0x03
        line.long 0x00 "CHD_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CHD_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CHD_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0x1C8++0x03
        line.long 0x00 "CHD_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CHD_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CHD_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0x1CC++0x03
        line.long 0x00 "CHD_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CHD_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CHD_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0x1D0++0x03
        line.long 0x00 "CHD_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CHD_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CHD_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0x1D4++0x03
        line.long 0x00 "CHE_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CHE_START_ADDR_A,Starting address for buffer A"
    group.long 0x1D8++0x03
        line.long 0x00 "CHE_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CHE_START_ADDR_B,Starting address for buffer B"
    group.long 0x1DC++0x03
        line.long 0x00 "CHE_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CHE_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CHE_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CHE_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CHE_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CHE_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CHE_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CHE_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CHE_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CHE_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0x1E0++0x03
        line.long 0x00 "CHE_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CHE_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CHE_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0x1E4++0x03
        line.long 0x00 "CHE_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CHE_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CHE_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0x1E8++0x03
        line.long 0x00 "CHE_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CHE_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CHE_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0x1EC++0x03
        line.long 0x00 "CHE_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CHE_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CHE_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0x1F0++0x03
        line.long 0x00 "CHE_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CHE_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CHE_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0x1F4++0x03
        line.long 0x00 "CHF_CONFIG1,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CHF_START_ADDR_A,Starting address for buffer A"
    group.long 0x1F8++0x03
        line.long 0x00 "CHF_CONFIG2,GP-ADC Controller configuration register 1"
            hexmask.long 0x00 0.--31. 1. "CHF_START_ADDR_B,Starting address for buffer B"
    group.long 0x1FC++0x03
        line.long 0x00 "CHF_CONFIG3,GP-ADC Controller configuration register 2"
            bitfld.long 0x00 29. "CHF_FIFO_OVERFLOW_IE,FIFO overflow interrupt enable" "0,1"
            newline
            bitfld.long 0x00 28. "CHF_CAPTURE_DONE_IE,Capture done interrupt enable" "0,1"
            newline
            bitfld.long 0x00 27. "CHF_PINGPONG_MODE,val =" "0: In this mode a single buffer is used specified,1: In this mode two buffers used alternatively"
            newline
            bitfld.long 0x00 26. "CHF_CAPTURE_MODE,val=0x0: One-shot mode capture will end after completing CHF_BUFFER_LENGTH samples" "0,1"
            newline
            bitfld.long 0x00 25. "CHF_CHANNEL_ENABLE,Channel enable" "0,1"
            newline
            bitfld.long 0x00 24. "CHF_PACK_TRANSFERS,Packet mode enable" "0,1"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CHF_ACQ_WAIT,Wait time for settling the input after a mux conversion"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CHF_BUFFER_LENGTH,Circular buffer size in samples"
    group.long 0x200++0x03
        line.long 0x00 "CHF_THRESHOLD_VALUE,GP-ADC Controller threshold values"
            hexmask.long.word 0x00 16.--27. 1. "CHF_THRESHOLD_HIGH,12-bit data higher threshold"
            newline
            hexmask.long.word 0x00 0.--11. 1. "CHF_THRESHOLD_LOW,12-bit data lower threshold"
    group.long 0x204++0x03
        line.long 0x00 "CHF_THRESHOLD_IE,GP-ADC Controller threshold IE"
            bitfld.long 0x00 1. "CHF_THRESHOLD_HIGH_IENA,Threshold High interrupt enable" "0,1"
            newline
            bitfld.long 0x00 0. "CHF_THRESHOLD_LOW_IENA,Threshold Low interrupt enable" "0,1"
    group.long 0x208++0x03
        line.long 0x00 "CHF_THRESHOLD_FLAGS,GP-ADC Controller threshold flags"
            bitfld.long 0x00 1. "CHF_THRESHOLD_HIGH_FLAG,Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 0. "CHF_THRESHOLD_LOW_FLAG,Can be read for status write a '1 to clear the flag" "0,1"

    rgroup.long 0x20C++0x03
        line.long 0x00 "CHF_STATUS,GP-ADC Controller channel status"
            bitfld.long 0x00 17. "CHF_CURRENT_BUFFER,If 0 current target is buffer A if 1 current target is buffer B" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CHF_CURRENT_POINTER,Current pointer of the circular buffer"

    group.long 0x210++0x03
        line.long 0x00 "CHF_STATUS_FLAGS,GP-ADC Controller channel status flags"
            bitfld.long 0x00 1. "CHF_FIFO_OVERFLOW_FLAG,Indicates if the channel FIFO has overflowed" "0,1"
            newline
            bitfld.long 0x00 0. "CHF_CAPTURE_DONE,When set at 1 indicates a capture has been completed" "0,1"
    group.long 0x214++0x03
        line.long 0x00 "CTL_LOCK,Lock control"
            hexmask.long 0x00 0.--31. 1. "CTL_GP_ADC_LOCK_KEY,Write 0x0D1E607E to allow write access to this SFR bank"

    rgroup.long 0x218++0x03
        line.long 0x00 "STS_LOCK,Lock status"
            bitfld.long 0x00 0. "STS_GP_ADC_LOCK_N,Lock status for this SFR bank" "0,1"

    group.long 0x21C++0x03
        line.long 0x00 "SPARE,Spare Register"
            hexmask.long 0x00 0.--31. 1. "SPARE,Spare registers"
tree.end

tree "GPIO (General Purpose I/O Ports And Peripheral I/O Lines)"
    base ad:0x91925000
    group.long 0x00++0x03
        line.long 0x00 "GPIO_SWPORTA_DR,Port A data register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_SWPORTA_DR,RSVD_GPIO_SWPORTA_DR Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_SWPORTA_DR,Values written to this register are output on the I/O signals for Port A if the corresponding data direction bits for Port A are set to Output mode and the corresponding control bit for Port A is set to Software mode"
    group.long 0x04++0x03
        line.long 0x00 "GPIO_SWPORTA_DDR,Port A Data Direction Register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_SWPORTA_DDR,RSVD_GPIO_SWPORTA_DDR Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_SWPORTA_DDR,Values written to this register independently control the direction of the corresponding data bit in Port A"
    group.long 0x0C++0x03
        line.long 0x00 "GPIO_SWPORTB_DR,Port B data register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_SWPORTB_DR,RSVD_GPIO_SWPORTB_DR Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_SWPORTB_DR,Values written to this register are output on the I/O signals for Port B if the corresponding data direction bits for Port B are set to Output mode and the corresponding control bit for Port B is set to Software mode"
    group.long 0x10++0x03
        line.long 0x00 "GPIO_SWPORTB_DDR,Port B Data Direction Register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_SWPORTB_DDR,RSVD_GPIO_SWPORTB_DDR Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_SWPORTB_DDR,Values written to this register independently control the direction of the corresponding data bit in Port B"
    group.long 0x18++0x03
        line.long 0x00 "GPIO_SWPORTC_DR,Port C data register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_SWPORTC_DR,RSVD_GPIO_SWPORTC_DR Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_SWPORTC_DR,Values written to this register are output on the I/O signals for Port C if the corresponding data direction bits for Port C are set to Output mode and the corresponding control bit for Port C is set to Software mode"
    group.long 0x1C++0x03
        line.long 0x00 "GPIO_SWPORTC_DDR,Port C Data Direction Register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_SWPORTC_DDR,RSVD_GPIO_SWPORTC_DDR Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_SWPORTC_DDR,Values written to this register independently control the direction of the corresponding data bit in Port C"
    group.long 0x24++0x03
        line.long 0x00 "GPIO_SWPORTD_DR,Port D data register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_SWPORTD_DR,RSVD_GPIO_SWPORTD_DR Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_SWPORTD_DR,Values written to this register are output on the I/O signals for Port D if the corresponding data direction bits for Port D are set to Output mode and the corresponding control bit for Port D is set to Software mode"
    group.long 0x28++0x03
        line.long 0x00 "GPIO_SWPORTD_DDR,Port D Data Direction Register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_SWPORTD_DDR,RSVD_GPIO_SWPORTD_DDR Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_SWPORTD_DDR,Values written to this register independently control the direction of the corresponding data bit in Port D"
    group.long 0x30++0x03
        line.long 0x00 "GPIO_INTEN,Interrupt enable register Note: This register is available only if Port A is configured to generate interrupts (GPIO_PORTA_INTR = Include (1))"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_INTEN,RSVD_GPIO_INTEN Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_INTEN,Allows each bit of Port A to be configured for interrupts"
    group.long 0x34++0x03
        line.long 0x00 "GPIO_INTMASK,Interrupt mask register Note: This register is available only if Port A is configured to generate interrupts (GPIO_PORTA_INTR = Include (1))"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_INTMASK,RSVD_GPIO_INTMASK Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_INTMASK,Controls whether an interrupt on Port A can create an interrupt for the interrupt controller by not masking it"
    group.long 0x38++0x03
        line.long 0x00 "GPIO_INTTYPE_LEVEL,Interrupt level Note: This register is available only if Port A is configured to generate interrupts (GPIO_PORTA_INTR = Include (1))"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_INTTYPE_LEVEL,RSVD_GPIO_INTTYPE_LEVEL Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_INTTYPE_LEVEL,Controls the type of interrupt that can occur on Port A"
    group.long 0x3C++0x03
        line.long 0x00 "GPIO_INT_POLARITY,Interrupt polarity Note: This register is available only if Port A is configured to generate interrupts (GPIO_PORTA_INTR = Include (1))"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_INT_POLARITY,RSVD_GPIO_INT_POLARITY Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_INT_POLARITY,Controls the polarity of edge or level sensitivity that can occur on input of Port A"

    rgroup.long 0x40++0x03
        line.long 0x00 "GPIO_INTSTATUS,Interrupt status Note: This register is available only if Port A is configured to generate interrupts (GPIO_PORTA_INTR = Include (1))"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_INTSTATUS,RSVD_GPIO_INTSTATUS Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_INTSTATUS,Interrupt status of Port A"
    rgroup.long 0x44++0x03
        line.long 0x00 "GPIO_RAW_INTSTATUS,Raw interrupt status Note: This register is available only if Port A is configured to generate interrupts (GPIO_PORTA_INTR = Include (1))"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_RAW_INTMASK,RSVD_GPIO_RAW_INTMASK Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_RAW_INTSTATUS,Raw interrupt of status of Port A (premasking bits)"

    wgroup.long 0x4C++0x03
        line.long 0x00 "GPIO_PORTA_EOI,Port A clear interrupt register Note: This register is available only if Port A is configured to generate interrupts (GPIO_PORTA_INTR = Include (1)) and when the debounce logic is included (GPIO_DEBOUNCE = Include (1))"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_PORTA_EOI,RSVD_GPIO_PORTA_EOI Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_PORTA_EOI,Controls the clearing of edge type interrupts from Port A"

    rgroup.long 0x50++0x03
        line.long 0x00 "GPIO_EXT_PORTA,External port A register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_EXT_PORTA,RSVD_GPIO_EXT_PORTA Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_EXT_PORTA,This register always reflects the signals value on the External Port A"
    rgroup.long 0x54++0x03
        line.long 0x00 "GPIO_EXT_PORTB,Port B external port register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_EXT_PORTB,RSVD_GPIO_EXT_PORTB Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_EXT_PORTB,This register always reflects the signals value on the External Port B"
    rgroup.long 0x58++0x03
        line.long 0x00 "GPIO_EXT_PORTC,External port C register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_EXT_PORTC,RSVD_GPIO_EXT_PORTC Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_EXT_PORTC,This register always reflects the signals value on the External Port C"
    rgroup.long 0x5C++0x03
        line.long 0x00 "GPIO_EXT_PORTD,Port D external port register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_EXT_PORTD,RSVD_GPIO_EXT_PORTD Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_EXT_PORTD,This register always reflects the signals value on the External Port D"

    group.long 0x60++0x03
        line.long 0x00 "GPIO_LS_SYNC,Synchronization level"
            hexmask.long 0x00 1.--31. 1. "RSVD_GPIO_LS_SYNC,RSVD_GPIO_LS_SYNC Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "GPIO_LS_SYNC,Writing a 1 to this register results in all level-sensitive interrupts being synchronized to pclk_intr" "0: No synchronization to pclk_int (default),1: Synchronize to pclk_intr"

    rgroup.long 0x64++0x03
        line.long 0x00 "GPIO_ID_CODE,GPIO ID code"
            hexmask.long 0x00 0.--31. 1. "GPIO_ID_CODE,This is a user-specified code that a system can"

    group.long 0x68++0x03
        line.long 0x00 "GPIO_INT_BOTHEDGE,Interrupt Both Edge type Note: This register is available only if PORT A is configured to generate interrupts (GPIO_PORTA_INTR = Include(1)) and interrupt detection is configured to generate on both rising and falling edges of external.."
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_GPIO_INT_BOTHEDGE,RSVD_GPIO_INT_BOTHEDGE Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "GPIO_INT_BOTHEDGE,Controls the edge type of interrupt that can occur on Port A"

    rgroup.long 0x6C++0x03
        line.long 0x00 "GPIO_VER_ID_CODE,GPIO Component Version"
            hexmask.long 0x00 0.--31. 1. "GPIO_VER_ID_CODE,ASCII value for each number in the version followed by *"
    rgroup.long 0x70++0x03
        line.long 0x00 "GPIO_CONFIG_REG2,GPIO Configuration Register 2 This register is a read-only register that is present when the configuration parameter GPIO_ADD_ENCODED_PARAMS is set to True"
            hexmask.long.word 0x00 20.--31. 1. "RSVD_GPIO_CONFIG_REG2,RSVD_GPIO_CONFIG_REG2 Reserved bits - read as zero"
            newline
            bitfld.long 0x00 15.--19. "ENCODED_ID_PWIDTH_D,The value of this register is equal to GPIO_PWIDTH_D-1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 10.--14. "ENCODED_ID_PWIDTH_C,The value of this register is equal to GPIO_PWIDTH_C-1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 5.--9. "ENCODED_ID_PWIDTH_B,The value of this register is equal to GPIO_PWIDTH_B-1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 0.--4. "ENCODED_ID_PWIDTH_A,The value of this register is equal to GPIO_PWIDTH_A-1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    rgroup.long 0x74++0x03
        line.long 0x00 "GPIO_CONFIG_REG1,GPIO Configuration Register 1 This register is present when the configuration parameter GPIO_ADD_ENCODED_PARAMS is set to True"
            hexmask.long.word 0x00 22.--31. 1. "RSVD_GPIO_CONFIG_REG1,RSVD_GPIO_CONFIG_REG1 Reserved bits - read as zero"
            newline
            bitfld.long 0x00 21. "INTERRUPT_BOTH_EDGE_TYPE,The value of this register is derived from the GPIO_INT_BOTH_EDGE configuration parameter" "0: Interrupt generation on rising or falling edge,1: Interrupt generation on both rising and.."
            newline
            bitfld.long 0x00 16.--20. "ENCODED_ID_WIDTH,The value of this register is derived from the GPIO_ID_WIDTH configuration parameter" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 15. "GPIO_ID,The value of this register is derived from the GPIO_ID configuration parameter" "0: GPIO_ID not included,1: GPIO_ID is included"
            newline
            bitfld.long 0x00 14. "ADD_ENCODED_PARAMS,The value of this register is derived from the GPIO_ADD_ENCODED_PARAMS configuration parameter" "0: Encoded parameters not added,1: Encoded parameters added"
            newline
            bitfld.long 0x00 13. "DEBOUNCE,The value of this register is derived from the GPIO_DEBOUNCE configuration parameter" "0: Exclude debounce capability,1: Include debounce capability"
            newline
            bitfld.long 0x00 12. "PORTA_INTR,The value of this register is derived from the GPIO_PORTA_INTR configuration parameter" "0: PORT A is not used as an interrupt source,1: PORT A is required to be used as an interrupt.."
            newline
            bitfld.long 0x00 11. "HW_PORTD,The value of this register is derived from the GPIO_HW_PORTD configuration parameter" "0: Port D has external auxiliary hardware..,1: Port D has external auxiliary hardware.."
            newline
            bitfld.long 0x00 10. "HW_PORTC,The value of this register is derived from the GPIO_HW_PORTC configuration parameter" "0: Port C has external auxiliary hardware..,1: Port C has external auxiliary hardware.."
            newline
            bitfld.long 0x00 9. "HW_PORTB,The value of this register is derived from the GPIO_HW_PORTB configuration parameter" "0: Port B has external auxiliary hardware..,1: Port B has external auxiliary hardware.."
            newline
            bitfld.long 0x00 8. "HW_PORTA,The value of this register is derived from the GPIO_HW_PORTA configuration parameter" "0: Port A has external auxiliary hardware..,1: Port A has external auxiliary hardware.."
            newline
            bitfld.long 0x00 7. "PORTD_SINGLE_CTL,The value of this register is derived from the GPIO_PORTD_SINGLE_CTL configuration parameter" "0: PORTD is not controlled from a single source,1: PORTD is controlled from a single source"
            newline
            bitfld.long 0x00 6. "PORTC_SINGLE_CTL,The value of this register is derived from the GPIO_PORTC_SINGLE_CTL configuration parameter" "0: PORTC is not controlled from a single source,1: PORTC is controlled from a single source"
            newline
            bitfld.long 0x00 5. "PORTB_SINGLE_CTL,The value of this register is derived from the GPIO_PORTB_SINGLE_CTL configuration parameter" "0: PORTB is not controlled from a single source,1: PORTB is controlled from a single source"
            newline
            bitfld.long 0x00 4. "PORTA_SINGLE_CTL,The value of this register is derived from the GPIO_PORTA_SINGLE_CTL configuration parameter" "0: PORTA is not controlled from a single source,1: PORTA is controlled from a single source"
            newline
            bitfld.long 0x00 2.--3. "NUM_PORTS,The value of this register is derived from the GPIO_NUM_PORT configuration parameter" "0: Number of ports is 1,1: Number of ports is 2,2: Number of ports is 3,3: Number of ports is 4"
            newline
            bitfld.long 0x00 0.--1. "APB_DATA_WIDTH,The value of this register is derived from the GPIO_APB_DATA_WIDTH configuration parameter" "0: APB DATA WIDTH is 8 bits,1: APB DATA WIDTH is 16 bits,2: APB DATA WIDTH is 32 bits,?..."
tree.end

tree "I2C_MS ()"
    base ad:0x91920000
    group.long 0x00++0x03
        line.long 0x00 "IC_CON,I2C Control Register"
            rbitfld.long 0x00 26.--31. "RSVD_IC_CON_2,IC_CON_2 Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            rbitfld.long 0x00 25. "RSVD_IC_SAR4_SMBUS_ARP_EN,IC_SAR4_SMBUS_ARP_EN Reserved bits - Read Only" "0,1"
            newline
            rbitfld.long 0x00 24. "RSVD_IC_SAR3_SMBUS_ARP_EN,IC_SAR3_SMBUS_ARP_EN Reserved bits - Read Only" "0,1"
            newline
            rbitfld.long 0x00 23. "RSVD_IC_SAR2_SMBUS_ARP_EN,IC_SAR2_SMBUS_ARP_EN Reserved bits - Read Only" "0,1"
            newline
            rbitfld.long 0x00 19. "RSVD_SMBUS_PERSISTENT_SLV_ADDR_EN,SMBUS_PERSISTENT_SLV_ADDR_EN Reserved bits - Read Only" "0,1"
            newline
            rbitfld.long 0x00 18. "RSVD_SMBUS_ARP_EN,SMBUS_ARP_EN Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 17. "SMBUS_SLAVE_QUICK_EN,If this bit is set to 1 DW_apb_i2c slave only receives Quick commands in SMBus Mode" "0: SMBus Slave is disabled to receive Quick..,1: SMBus Slave is enabled to receive Quick command"
            newline
            rbitfld.long 0x00 16. "RSVD_OPTIONAL_SAR_CTRL,OPTIONAL_SAR_CTRL Reserved bits - Read Only" "0,1"
            newline
            rbitfld.long 0x00 12.--15. "RSVD_IC_CON_1,IC_CON_1 Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 11. "BUS_CLEAR_FEATURE_CTRL,This bit controls whether the DW_apb_i2c enables the bus clear feature" "0: Bus Clear Feature is disabled,1: Bus Clear Feature is enabled"
            newline
            rbitfld.long 0x00 10. "STOP_DET_IF_MASTER_ACTIVE,In Master mode" "0: Master issues the STOP_DET interrupt..,1: Master issues the STOP_DET interrupt only.."
            newline
            bitfld.long 0x00 9. "RX_FIFO_FULL_HLD_CTRL,This bit controls whether DW_apb_i2c should hold the bus when the Rx FIFO is physically full to its RX_BUFFER_DEPTH as described in the IC_RX_FULL_HLD_BUS_EN parameter" "0: Overflow when RX_FIFO is full,1: Hold bus when RX_FIFO is full"
            newline
            bitfld.long 0x00 8. "TX_EMPTY_CTRL,This bit controls the generation of the TX_EMPTY interrupt as described in the IC_RAW_INTR_STAT register" "0: Default behaviour of TX_EMPTY interrupt,1: Controlled generation of TX_EMPTY interrupt"
            newline
            bitfld.long 0x00 7. "STOP_DET_IFADDRESSED,In slave mode" "0: slave issues STOP_DET intr always,1: slave issues STOP_DET intr only if addressed"
            newline
            bitfld.long 0x00 6. "IC_SLAVE_DISABLE,This bit controls whether I2C has its slave disabled which means once the presetn signal is applied then this bit takes on the value of the configuration parameter IC_SLAVE_DISABLE" "0: Slave mode is enabled,1: Slave mode is disabled"
            newline
            bitfld.long 0x00 5. "IC_RESTART_EN,Determines whether RESTART conditions may be sent when acting as a master" "0: Master restart disabled,1: Master restart enabled"
            newline
            rbitfld.long 0x00 4. "IC_10BITADDR_MASTER_rd_only,If the I2C_DYNAMIC_TAR_UPDATE configuration parameter is set to 'No' (0) this bit is named IC_10BITADDR_MASTER and controls whether the DW_apb_i2c starts its transfers in 7 or 10-bit addressing mode when acting as a master" "0: Master 7Bit addressing mode,1: Master 10Bit addressing mode"
            newline
            bitfld.long 0x00 3. "IC_10BITADDR_SLAVE,When acting as a slave this bit controls whether the DW_apb_i2c responds to 7- or 10-bit addresses" "0: Slave 7Bit addressing,1: Slave 10Bit addressing"
            newline
            bitfld.long 0x00 1.--2. "SPEED,These bits control at which speed the DW_apb_i2c operates its setting is relevant only if one is operating the DW_apb_i2c in master mode" "?,1: Standard Speed mode of operation,2: Fast or Fast Plus mode of operation,3: High Speed mode of operation"
            newline
            bitfld.long 0x00 0. "MASTER_MODE,This bit controls whether the DW_apb_i2c master is enabled" "0: Master mode is disabled,1: Master mode is enabled"
    group.long 0x04++0x03
        line.long 0x00 "IC_TAR,I2C Target Address Register If the configuration parameter I2C_DYNAMIC_TAR_UPDATE is set to 'No' (0) this register is 12 bits wide and bits 31:12 are reserved"
            hexmask.long.word 0x00 17.--31. 1. "RSVD_IC_TAR_2,IC_TAR_2 Reserved bits - Read Only"
            newline
            bitfld.long 0x00 16. "SMBUS_QUICK_CMD,If bit 11 (SPECIAL) is set to 1 then this bit indicates whether a Quick command is to be performed by the DW_apb_i2c" "0: Disables programming of QUICK-CMD transmission,1: Enables programming of QUICK-CMD transmission"
            newline
            rbitfld.long 0x00 14.--15. "RSVD_IC_TAR_1,IC_TAR_1 Reserved bits - Read Only" "0,1,2,3"
            newline
            rbitfld.long 0x00 13. "RSVD_DEVICE_ID,DEVICE_ID Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 12. "IC_10BITADDR_MASTER,This bit controls whether the DW_apb_i2c starts its transfers in 7- or 10-bit addressing mode when acting as a master" "0: Address 7Bit transmission format,1: Address 10Bit transmission format"
            newline
            bitfld.long 0x00 11. "SPECIAL,This bit indicates whether software performs a Device-ID or General Call or START BYTE command" "0: Disables programming of GENERAL_CALL or..,1: Enables programming of GENERAL_CALL or.."
            newline
            bitfld.long 0x00 10. "GC_OR_START,If bit 11 (SPECIAL) is set to 1 and bit 13(Device-ID) is set to 0 then this bit indicates whether a General Call or START byte command is to be performed by the DW_apb_i2c" "0: GENERAL_CALL byte transmission,1: START byte transmission"
            newline
            hexmask.long.word 0x00 0.--9. 1. "IC_TAR,This is the target address for any master transaction"
    group.long 0x08++0x03
        line.long 0x00 "IC_SAR,I2C Slave Address Register"
            hexmask.long.tbyte 0x00 10.--31. 1. "RSVD_IC_SAR,IC_SAR Reserved bits - Read Only"
            newline
            hexmask.long.word 0x00 0.--9. 1. "IC_SAR,The IC_SAR holds the slave address when the I2C is operating as a slave"
    group.long 0x10++0x03
        line.long 0x00 "IC_DATA_CMD,I2C Rx/Tx Data Buffer and Command Register this is the register the CPU writes to when filling the TX FIFO and the CPU reads from when retrieving bytes from RX FIFO"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_IC_DATA_CMD,IC_DATA_CMD Reserved bits - Read Only"
            newline
            rbitfld.long 0x00 11. "FIRST_DATA_BYTE,Indicates the first data byte received after the address phase for receive transfer in Master receiver or Slave receiver mode" "0: Sequential data byte received,1: Non sequential data byte received"
            newline
            bitfld.long 0x00 10. "RESTART,This bit controls whether a RESTART is issued before the byte is sent or received" "0: Do not Issue RESTART before this command,1: Issue RESTART before this command"
            newline
            bitfld.long 0x00 9. "STOP,This bit controls whether a STOP is issued after the byte is sent or received" "0: Do not Issue STOP after this command,1: Issue STOP after this command"
            newline
            bitfld.long 0x00 8. "CMD,This bit controls whether a read or a write is performed" "0: Master Write Command,1: Master Read Command"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "DAT,This register contains the data to be transmitted or received on the I2C bus"
    group.long 0x14++0x03
        line.long 0x00 "IC_SS_SCL_HCNT,Standard Speed I2C Clock SCL High Count Register"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_IC_SS_SCL_HIGH_COUNT,IC_SS_SCL_HCNT Reserved bits - Read Only"
            newline
            abitfld.long 0x00 0.--15. "IC_SS_SCL_HCNT,This register must be set before any I2C bus transaction can take place to ensure proper I/O timing" "0x0001=1: 6)) Hardware prevents values less than..,0x0003=3: ((IC_CLK_FREQ_OPTIMIZATION==1) ?"
    group.long 0x18++0x03
        line.long 0x00 "IC_SS_SCL_LCNT,Standard Speed I2C Clock SCL Low Count Register"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_IC_SS_SCL_LOW_COUNT,RSVD_IC_SS_SCL_LOW_COUNT Reserved bits - Read Only"
            newline
            abitfld.long 0x00 0.--15. "IC_SS_SCL_LCNT,This register must be set before any I2C bus transaction can take place to ensure proper I/O timing" "0x0005=5: ((IC_CLK_FREQ_OPTIMIZATION==1) ?,0x0006=6: 8)) Hardware prevents values less than.."
    group.long 0x1C++0x03
        line.long 0x00 "IC_FS_SCL_HCNT,Fast Mode or Fast Mode Plus I2C Clock SCL High Count Register"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_IC_FS_SCL_HCNT,IC_FS_SCL_HCNT Reserved bits - Read Only"
            newline
            abitfld.long 0x00 0.--15. "IC_FS_SCL_HCNT,This register must be set before any I2C bus transaction can take place to ensure proper I/O timing" "0x0001=1: 6)) Hardware prevents values less than..,0x0003=3: ((IC_CLK_FREQ_OPTIMIZATION==1) ?"
    group.long 0x20++0x03
        line.long 0x00 "IC_FS_SCL_LCNT,Fast Mode or Fast Mode Plus I2C Clock SCL Low Count Register"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_IC_FS_SCL_LCNT,IC_FS_SCL_LCNT Reserved bits - Read Only"
            newline
            abitfld.long 0x00 0.--15. "IC_FS_SCL_LCNT,This register must be set before any I2C bus transaction can take place to ensure proper I/O timing" "0x0005=5: ((IC_CLK_FREQ_OPTIMIZATION==1) ?,0x0006=6: 8)) Hardware prevents values less than.."

    rgroup.long 0x2C++0x03
        line.long 0x00 "IC_INTR_STAT,I2C Interrupt Status Register"
            hexmask.long.word 0x00 20.--31. 1. "RSVD_IC_INTR_STAT,IC_INTR_STAT Reserved bits - Read Only"
            newline
            bitfld.long 0x00 17. "R_SLV_ADDR2_TAG,See IC_RAW_INTR_STAT for a detailed description of R_SLV_ADDR2_TAG bit" "0: SLV_ADDR2_TAG interrupt is inactive,1: SLV_ADDR2_TAG interrupt is active"
            newline
            bitfld.long 0x00 16. "R_SLV_ADDR1_TAG,See IC_RAW_INTR_STAT for a detailed description of R_SLV_ADDR1_TAG bit" "0: SLV_ADDR1_TAG interrupt is inactive,1: SLV_ADDR1_TAG interrupt is active"
            newline
            bitfld.long 0x00 15. "R_WR_REQ,See IC_RAW_INTR_STAT for a detailed description of R_WR_REQ bit" "0: WR_REQ interrupt is inactive,1: WR_REQ interrupt is active"
            newline
            bitfld.long 0x00 14. "R_SCL_STUCK_AT_LOW,See IC_RAW_INTR_STAT for a detailed description of R_SCL_STUCK_AT_LOW bit" "0: R_SCL_STUCK_AT_LOW interrupt is inactive,1: R_SCL_STUCK_AT_LOW interrupt is active"
            newline
            bitfld.long 0x00 13. "R_MASTER_ON_HOLD,See IC_RAW_INTR_STAT for a detailed description of R_MASTER_ON_HOLD bit" "0: R_MASTER_ON_HOLD interrupt is inactive,1: R_MASTER_ON_HOLD interrupt is active"
            newline
            bitfld.long 0x00 12. "R_RESTART_DET,See IC_RAW_INTR_STAT for a detailed description of R_RESTART_DET bit" "0: R_RESTART_DET interrupt is inactive,1: R_RESTART_DET interrupt is active"
            newline
            bitfld.long 0x00 11. "R_GEN_CALL,See IC_RAW_INTR_STAT for a detailed description of R_GEN_CALL bit" "0: R_GEN_CALL interrupt is inactive,1: R_GEN_CALL interrupt is active"
            newline
            bitfld.long 0x00 10. "R_START_DET,See IC_RAW_INTR_STAT for a detailed description of R_START_DET bit" "0: R_START_DET interrupt is inactive,1: R_START_DET interrupt is active"
            newline
            bitfld.long 0x00 9. "R_STOP_DET,See IC_RAW_INTR_STAT for a detailed description of R_STOP_DET bit" "0: R_STOP_DET interrupt is inactive,1: R_STOP_DET interrupt is active"
            newline
            bitfld.long 0x00 8. "R_ACTIVITY,See IC_RAW_INTR_STAT for a detailed description of R_ACTIVITY bit" "0: R_ACTIVITY interrupt is inactive,1: R_ACTIVITY interrupt is active"
            newline
            bitfld.long 0x00 7. "R_RX_DONE,See IC_RAW_INTR_STAT for a detailed description of R_RX_DONE bit" "0: R_RX_DONE interrupt is inactive,1: R_RX_DONE interrupt is active"
            newline
            bitfld.long 0x00 6. "R_TX_ABRT,See IC_RAW_INTR_STAT for a detailed description of R_TX_ABRT bit" "0: R_TX_ABRT interrupt is inactive,1: R_TX_ABRT interrupt is active"
            newline
            bitfld.long 0x00 5. "R_RD_REQ,See IC_RAW_INTR_STAT for a detailed description of R_RD_REQ bit" "0: R_RD_REQ interrupt is inactive,1: R_RD_REQ interrupt is active"
            newline
            bitfld.long 0x00 4. "R_TX_EMPTY,See IC_RAW_INTR_STAT for a detailed description of R_TX_EMPTY bit" "0: R_TX_EMPTY interrupt is inactive,1: R_TX_EMPTY interrupt is active"
            newline
            bitfld.long 0x00 3. "R_TX_OVER,See IC_RAW_INTR_STAT for a detailed description of R_TX_OVER bit" "0: R_TX_OVER interrupt is inactive,1: R_TX_OVER interrupt is active"
            newline
            bitfld.long 0x00 2. "R_RX_FULL,See IC_RAW_INTR_STAT for a detailed description of R_RX_FULL bit" "0: R_RX_FULL interrupt is inactive,1: R_RX_FULL interrupt is active"
            newline
            bitfld.long 0x00 1. "R_RX_OVER,See IC_RAW_INTR_STAT for a detailed description of R_RX_OVER bit" "0: R_RX_OVER interrupt is inactive,1: R_RX_OVER interrupt is active"
            newline
            bitfld.long 0x00 0. "R_RX_UNDER,See IC_RAW_INTR_STAT for a detailed description of R_RX_UNDER bit" "0: RX_UNDER interrupt is inactive,1: RX_UNDER interrupt is active"

    group.long 0x30++0x03
        line.long 0x00 "IC_INTR_MASK,I2C Interrupt Mask Register"
            hexmask.long.word 0x00 20.--31. 1. "RSVD_IC_INTR_STAT,IC_INTR_STAT Reserved bits - Read Only"
            newline
            bitfld.long 0x00 17. "M_SLV_ADDR2_TAG,This bit masks the R_SLV_ADDR2_TAG interrupt in IC_INTR_STAT register" "0: SLV_ADDR2_TAG interrupt is masked,1: SLV_ADDR2_TAG interrupt is unmasked"
            newline
            bitfld.long 0x00 16. "M_SLV_ADDR1_TAG,This bit masks the R_SLV_ADDR1_TAG interrupt in IC_INTR_STAT register" "0: SLV_ADDR1_TAG interrupt is masked,1: SLV_ADDR1_TAG interrupt is unmasked"
            newline
            bitfld.long 0x00 15. "M_WR_REQ,This bit masks the R_WR_REQ interrupt in IC_INTR_STAT register" "0: WR_REQ interrupt is masked,1: WR_REQ interrupt is unmasked"
            newline
            bitfld.long 0x00 14. "M_SCL_STUCK_AT_LOW,This bit masks the R_SCL_STUCK_AT_LOW interrupt in IC_INTR_STAT register" "0: SCL_STUCK_AT_LOW interrupt is masked,1: SCL_STUCK_AT_LOW interrupt is unmasked"
            newline
            bitfld.long 0x00 13. "M_MASTER_ON_HOLD,This bit masks the R_MASTER_ON_HOLD interrupt in IC_INTR_STAT register" "0: MASTER_ON_HOLD interrupt is masked,1: MASTER_ON_HOLD interrupt is unmasked"
            newline
            rbitfld.long 0x00 12. "M_RESTART_DET_read_only,This M_RESTART_DET_read_only bit masks the R_RESTART_DET interrupt in IC_INTR_STAT register" "0: RESTART_DET interrupt is masked,1: RESTART_DET interrupt is unmasked"
            newline
            bitfld.long 0x00 11. "M_GEN_CALL,This bit masks the R_GEN_CALL interrupt in IC_INTR_STAT register" "0: GEN_CALL interrupt is masked,1: GEN_CALL interrupt is unmasked"
            newline
            bitfld.long 0x00 10. "M_START_DET,This bit masks the R_START_DET interrupt in IC_INTR_STAT register" "0: START_DET interrupt is masked,1: START_DET interrupt is unmasked"
            newline
            bitfld.long 0x00 9. "M_STOP_DET,This bit masks the R_STOP_DET interrupt in IC_INTR_STAT register" "0: STOP_DET interrupt is masked,1: STOP_DET interrupt is unmasked"
            newline
            bitfld.long 0x00 8. "M_ACTIVITY,This bit masks the R_ACTIVITY interrupt in IC_INTR_STAT register" "0: ACTIVITY interrupt is masked,1: ACTIVITY interrupt is unmasked"
            newline
            bitfld.long 0x00 7. "M_RX_DONE,This bit masks the R_RX_DONE interrupt in IC_INTR_STAT register" "0: RX_DONE interrupt is masked,1: RX_DONE interrupt is unmasked"
            newline
            bitfld.long 0x00 6. "M_TX_ABRT,This bit masks the R_TX_ABRT interrupt in IC_INTR_STAT register" "0: TX_ABORT interrupt is masked,1: TX_ABORT interrupt is unmasked"
            newline
            bitfld.long 0x00 5. "M_RD_REQ,This bit masks the R_RD_REQ interrupt in IC_INTR_STAT register" "0: RD_REQ interrupt is masked,1: RD_REQ interrupt is unmasked"
            newline
            bitfld.long 0x00 4. "M_TX_EMPTY,This bit masks the R_TX_EMPTY interrupt in IC_INTR_STAT register" "0: TX_EMPTY interrupt is masked,1: TX_EMPTY interrupt is unmasked"
            newline
            bitfld.long 0x00 3. "M_TX_OVER,This bit masks the R_TX_OVER interrupt in IC_INTR_STAT register" "0: TX_OVER interrupt is masked,1: TX_OVER interrupt is unmasked"
            newline
            bitfld.long 0x00 2. "M_RX_FULL,This bit masks the R_RX_FULL interrupt in IC_INTR_STAT register" "0: RX_FULL interrupt is masked,1: RX_FULL interrupt is unmasked"
            newline
            bitfld.long 0x00 1. "M_RX_OVER,This bit masks the R_RX_OVER interrupt in IC_INTR_STAT register" "0: RX_OVER interrupt is masked,1: RX_OVER interrupt is unmasked"
            newline
            bitfld.long 0x00 0. "M_RX_UNDER,This bit masks the R_RX_UNDER interrupt in IC_INTR_STAT register" "0: RX_UNDER interrupt is masked,1: RX_UNDER interrupt is unmasked"

    rgroup.long 0x34++0x03
        line.long 0x00 "IC_RAW_INTR_STAT,I2C Raw Interrupt Status Register"
            hexmask.long.word 0x00 20.--31. 1. "RSVD_IC_RAW_INTR_STAT,IC_RAW_INTR_STAT Reserved bits - Read Only"
            newline
            bitfld.long 0x00 17. "SLV_ADDR2_TAG,This bit is set to 1 when DW_apb_i2c is acting as slave and another I2C master is attempting to write/read I2C transfers with the Slave address IC_SAR2" "0: SLV_ADDR2_TAG interrupt is inactive,1: SLV_ADDR2_TAG interrupt is active"
            newline
            bitfld.long 0x00 16. "SLV_ADDR1_TAG,This bit is set to 1 when DW_apb_i2c is acting as slave and another I2C master is attempting to write/read I2C transfers with the Slave address IC_SAR" "0: SLV_ADDR1_TAG interrupt is inactive,1: SLV_ADDR1_TAG interrupt is active"
            newline
            bitfld.long 0x00 15. "WR_REQ,This bit is set to 1 when DW_apb_i2c is acting as slave and another I2C master is attempting to werite data into DW_apb_i2c" "0: WR_REQ interrupt is inactive,1: WR_REQ interrupt is active"
            newline
            bitfld.long 0x00 14. "SCL_STUCK_AT_LOW,Indicates whether the SCL Line is stuck at low for the IC_SCL_STUCK_LOW_TIMEOUT number of ic_clk periods" "0: SCL_STUCK_AT_LOW interrupt is inactive,1: SCL_STUCK_AT_LOW interrupt is active"
            newline
            bitfld.long 0x00 13. "MASTER_ON_HOLD,Indicates whether master is holding the bus and TX FIFO is empty" "0: MASTER_ON_HOLD interrupt is inactive,1: MASTER_ON_HOLD interrupt is active"
            newline
            bitfld.long 0x00 12. "RESTART_DET,Indicates whether a RESTART condition has occurred on the I2C interface when DW_apb_i2c is operating in Slave mode and the slave is being addressed" "0: RESTART_DET interrupt is inactive,1: RESTART_DET interrupt is active"
            newline
            bitfld.long 0x00 11. "GEN_CALL,Set only when a General Call address is received and it is acknowledged" "0: GEN_CALL interrupt is inactive,1: GEN_CALL interrupt is active"
            newline
            bitfld.long 0x00 10. "START_DET,Indicates whether a START or RESTART condition has occurred on the I2C interface regardless of whether DW_apb_i2c is operating in slave or master mode" "0: START_DET interrupt is inactive,1: START_DET interrupt is active"
            newline
            bitfld.long 0x00 9. "STOP_DET,Indicates whether a STOP condition has occurred on the I2C interface regardless of whether DW_apb_i2c is operating in slave or master mode" "0: STOP_DET interrupt is inactive,1: STOP_DET interrupt is active"
            newline
            bitfld.long 0x00 8. "ACTIVITY,This bit captures DW_apb_i2c activity and stays set until it is cleared" "0: RAW_INTR_ACTIVITY interrupt is inactive,1: RAW_INTR_ACTIVITY interrupt is active"
            newline
            bitfld.long 0x00 7. "RX_DONE,When the DW_apb_i2c is acting as a slave-transmitter this bit is set to 1 if the master does not acknowledge a transmitted byte" "0: RX_DONE interrupt is inactive,1: RX_DONE interrupt is active"
            newline
            bitfld.long 0x00 6. "TX_ABRT,This bit indicates if DW_apb_i2c as an I2C transmitter is unable to complete the intended actions on the contents of the transmit FIFO" "0: TX_ABRT interrupt is inactive,1: TX_ABRT interrupt is active"
            newline
            bitfld.long 0x00 5. "RD_REQ,This bit is set to 1 when DW_apb_i2c is acting as a slave and another I2C master is attempting to read data from DW_apb_i2c" "0: RD_REQ interrupt is inactive,1: RD_REQ interrupt is active"
            newline
            bitfld.long 0x00 4. "TX_EMPTY,The behavior of the TX_EMPTY interrupt status differs based on the TX_EMPTY_CTRL selection in the IC_CON register" "0: TX_EMPTY interrupt is inactive,1: TX_EMPTY interrupt is active"
            newline
            bitfld.long 0x00 3. "TX_OVER,Set during transmit if the transmit buffer is filled to IC_TX_BUFFER_DEPTH and the processor attempts to issue another I2C command by writing to the IC_DATA_CMD register" "0: TX_OVER interrupt is inactive,1: TX_OVER interrupt is active"
            newline
            bitfld.long 0x00 2. "RX_FULL,Set when the receive buffer reaches or goes above the RX_TL threshold in the IC_RX_TL register" "0: RX_FULL interrupt is inactive,1: RX_FULL interrupt is active"
            newline
            bitfld.long 0x00 1. "RX_OVER,Set if the receive buffer is completely filled to IC_RX_BUFFER_DEPTH and an additional byte is received from an external I2C device" "0: RX_OVER interrupt is inactive,1: RX_OVER interrupt is active"
            newline
            bitfld.long 0x00 0. "RX_UNDER,Set if the processor attempts to read the receive buffer when it is empty by reading from the IC_DATA_CMD register" "0: RX_UNDER interrupt is inactive,1: RX_UNDER interrupt is active"

    group.long 0x38++0x03
        line.long 0x00 "IC_RX_TL,I2C Receive FIFO Threshold Register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_IC_RX_TL,IC_RX_TL Reserved bits - Read Only"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "RX_TL,Receive FIFO Threshold Level"
    group.long 0x3C++0x03
        line.long 0x00 "IC_TX_TL,I2C Transmit FIFO Threshold Register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_IC_TX_TL,IC_TX_TL Reserved bits - Read Only"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "TX_TL,Transmit FIFO Threshold Level"

    rgroup.long 0x40++0x03
        line.long 0x00 "IC_CLR_INTR,Clear Combined and Individual Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_CLR_INTR,CLR_INTR Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_INTR,Read this register to clear the combined interrupt all individual interrupts and the IC_TX_ABRT_SOURCE register" "0,1"
    rgroup.long 0x44++0x03
        line.long 0x00 "IC_CLR_RX_UNDER,Clear RX_UNDER Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_CLR_RX_UNDER,IC_CLR_RX_UNDER Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_RX_UNDER,Read this register to clear the RX_UNDER interrupt (bit 0) of the IC_RAW_INTR_STAT register" "0,1"
    rgroup.long 0x48++0x03
        line.long 0x00 "IC_CLR_RX_OVER,Clear RX_OVER Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_CLR_RX_OVER,IC_CLR_RX_OVER Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_RX_OVER,Read this register to clear the RX_OVER interrupt (bit 1) of the IC_RAW_INTR_STAT register" "0,1"
    rgroup.long 0x4C++0x03
        line.long 0x00 "IC_CLR_TX_OVER,Clear TX_OVER Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_CLR_TX_OVER,IC_CLR_TX_OVER Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_TX_OVER,Read this register to clear the TX_OVER interrupt (bit 3) of the IC_RAW_INTR_STAT register" "0,1"
    rgroup.long 0x50++0x03
        line.long 0x00 "IC_CLR_RD_REQ,Clear RD_REQ Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_CLR_RD_REQ,IC_CLR_RD_REQ Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_RD_REQ,Read this register to clear the RD_REQ interrupt (bit 5) of the IC_RAW_INTR_STAT register" "0,1"
    rgroup.long 0x54++0x03
        line.long 0x00 "IC_CLR_TX_ABRT,Clear TX_ABRT Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_CLR_TX_ABRT,IC_CLR_TX_ABRT Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_TX_ABRT,Read this register to clear the TX_ABRT interrupt (bit 6) of the IC_RAW_INTR_STAT register and the IC_TX_ABRT_SOURCE register" "0,1"
    rgroup.long 0x58++0x03
        line.long 0x00 "IC_CLR_RX_DONE,Clear RX_DONE Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_CLR_RX_DONE,IC_CLR_RX_DONE Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_RX_DONE,Read this register to clear the RX_DONE interrupt (bit 7) of the IC_RAW_INTR_STAT register" "0,1"
    rgroup.long 0x5C++0x03
        line.long 0x00 "IC_CLR_ACTIVITY,Clear ACTIVITY Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_CLR_ACTIVITY,IC_CLR_ACTIVITY Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_ACTIVITY,Reading this register clears the ACTIVITY interrupt if the I2C is not active anymore" "0,1"
    rgroup.long 0x60++0x03
        line.long 0x00 "IC_CLR_STOP_DET,Clear STOP_DET Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_CLR_STOP_DET,IC_CLR_STOP_DET Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_STOP_DET,Read this register to clear the STOP_DET interrupt (bit 9) of the IC_RAW_INTR_STAT register" "0,1"
    rgroup.long 0x64++0x03
        line.long 0x00 "IC_CLR_START_DET,Clear START_DET Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_CLR_START_DET,IC_CLR_START_DET Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_START_DET,Read this register to clear the START_DET interrupt (bit 10) of the IC_RAW_INTR_STAT register" "0,1"
    rgroup.long 0x68++0x03
        line.long 0x00 "IC_CLR_GEN_CALL,Clear GEN_CALL Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_CLR_GEN_CALL,IC_CLR_GEN_CALL Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_GEN_CALL,Read this register to clear the GEN_CALL interrupt (bit 11) of IC_RAW_INTR_STAT register" "0,1"

    group.long 0x6C++0x03
        line.long 0x00 "IC_ENABLE,I2C Enable Register"
            hexmask.long.word 0x00 23.--31. 1. "RSVD_IC_ENABLE_2,IC_ENABLE Reserved bits - Read Only"
            newline
            bitfld.long 0x00 20. "IC_SAR2_EN,Controls whether the DW_apb_i2c SAR2 is enabled" "0: Slave address IC_SAR2 is disabled,1: Slave address IC_SAR2 is enabled"
            newline
            bitfld.long 0x00 19. "IC_SAR_EN,Controls whether the DW_apb_i2c SAR is enabled" "0: Slave address IC_SAR is disabled,1: Slave address IC_SAR is enabled"
            newline
            rbitfld.long 0x00 18. "RSVD_SMBUS_ALERT_EN,SMBUS_ALERT_EN Register field Reserved bits - Read Only" "0,1"
            newline
            rbitfld.long 0x00 17. "RSVD_SMBUS_SUSPEND_EN,SMBUS_SUSPEND_EN Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 16. "SMBUS_CLK_RESET,This bit is used in SMBus Host mode to initiate the SMBus Master Clock Reset" "0: Master will not initates SMBUS Clock Reset..,1: Master initates the SMBUS Clock Reset Mechanism"
            newline
            hexmask.long.word 0x00 4.--15. 1. "RSVD_IC_ENABLE_1,RSVD_IC_ENABLE_1 Reserved bits - Read Only"
            newline
            bitfld.long 0x00 3. "SDA_STUCK_RECOVERY_ENABLE,If SDA is stuck at low indicated through the TX_ABORT interrupt (IC_TX_ABRT_SOURCE[17]) then this bit is used as a control knob to initiate the SDA Recovery Mechanism (that is send at most 9 SCL clocks and STOP to release the.." "0: Master disabled the SDA stuck at low recovery..,1: Master initiates the SDA stuck at low.."
            newline
            bitfld.long 0x00 2. "TX_CMD_BLOCK,In Master mode" "0: Tx Command execution not blocked,1: Tx Command execution blocked"
            newline
            bitfld.long 0x00 1. "ABORT,When set the controller initiates the transfer abort" "0: ABORT operation not in progress,1: ABORT operation in progress"
            newline
            bitfld.long 0x00 0. "ENABLE,Controls whether the DW_apb_i2c is enabled" "0: I2C is disabled,1: I2C is enabled"

    rgroup.long 0x70++0x03
        line.long 0x00 "IC_STATUS,I2C Status Register"
            bitfld.long 0x00 27.--31. "RSVD_IC_STATUS_2,IC_STATUS Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 26. "RSVD_SMBUS_SLAVE_ADDR4_RESOLVED,SMBUS_SLAVE_ADDR4_RESOLVED Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 25. "RSVD_SMBUS_SLAVE_ADDR4_VALID,SMBUS_SLAVE_ADDR4_VALID Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 24. "RSVD_SMBUS_SLAVE_ADDR3_RESOLVED,SMBUS_SLAVE_ADDR3_RESOLVED Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 23. "RSVD_SMBUS_SLAVE_ADDR3_VALID,SMBUS_SLAVE_ADDR3_VALID Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 22. "RSVD_SMBUS_SLAVE_ADDR2_RESOLVED,SMBUS_SLAVE_ADDR2_RESOLVED Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 21. "RSVD_SMBUS_SLAVE_ADDR2_VALID,SMBUS_SLAVE_ADDR2_VALID Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 20. "RSVD_SMBUS_ALERT_STATUS,SMBUS_ALERT_STATUS Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 19. "RSVD_SMBUS_SUSPEND_STATUS,SMBUS_SUSPEND_STATUS Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 18. "RSVD_SMBUS_SLAVE_ADDR_RESOLVED,SMBUS_SLAVE_ADDR_RESOLVED Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 17. "RSVD_SMBUS_SLAVE_ADDR_VALID,SMBUS_SLAVE_ADDR_VALID Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 16. "SMBUS_QUICK_CMD_BIT,This bit indicates the R/W bit of the Quick command received" "0: SMBUS QUICK CMD Read/write is set to 0,1: SMBUS QUICK CMD Read/write is set to 1"
            newline
            bitfld.long 0x00 13.--15. "RSVD_IC_STATUS_1,RSVD_IC_STATUS_1 Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 12. "SLV_ISO_SAR_DATA_CLK_STRETCH,This bit indicates the Bus hold (clock stretching) in Slave mode with Multiple SAR feature - for isolating the write transfer related data corresponding to one slave address with another slave address" "0: Slave is not holding the bus to isolate..,1: Slave holds the bus to isolate current RX.."
            newline
            bitfld.long 0x00 11. "SDA_STUCK_NOT_RECOVERED,This bit indicates that SDA stuck at low is not recovered after the recovery mechanism" "0: SDA Stuck at low is recovered after recovery..,1: SDA Stuck at low is not recovered after.."
            newline
            bitfld.long 0x00 10. "SLV_HOLD_RX_FIFO_FULL,This bit indicates the BUS Hold in Slave mode due to Rx FIFO is Full and an additional byte has been received (This kind of Bus hold is applicable if IC_RX_FULL_HLD_BUS_EN is set to 1 and bit 9 of the IC_CON register.." "0: Slave is not holding the bus or Bus hold is..,1: Slave holds the bus due to Rx FIFO is full"
            newline
            bitfld.long 0x00 9. "SLV_HOLD_TX_FIFO_EMPTY,This bit indicates the BUS Hold in Slave mode for the Read request when the Tx FIFO is empty" "0: Slave is not holding the bus or Bus hold is..,1: Slave holds the bus due to Tx FIFO is empty"
            newline
            bitfld.long 0x00 8. "MST_HOLD_RX_FIFO_FULL,This bit indicates the BUS Hold in Master mode due to Rx FIFO is Full and additional byte has been received (This kind of Bus hold is applicable if IC_RX_FULL_HLD_BUS_EN is set to 1 and bit 9 of the IC_CON register.." "0: Master is not holding the bus or Bus hold is..,1: Master holds the bus due to Rx FIFO is full"
            newline
            bitfld.long 0x00 7. "MST_HOLD_TX_FIFO_EMPTY,If the IC_EMPTYFIFO_HOLD_MASTER_EN parameter is set to 1 the DW_apb_i2c master stalls the write transfer when Tx FIFO is empty and the the last byte does not have the Stop bit set" "0: Master is not holding the bus or Bus hold is..,1: Master holds the bus due to Tx FIFO is empty"
            newline
            bitfld.long 0x00 6. "SLV_ACTIVITY,Slave FSM Activity Status" "0: Slave is idle,1: Slave not idle"
            newline
            bitfld.long 0x00 5. "MST_ACTIVITY,Master FSM Activity Status" "0: Master is idle,1: Master not idle"
            newline
            bitfld.long 0x00 4. "RFF,Receive FIFO Completely Full" "0: Rx FIFO not full,1: Rx FIFO is full"
            newline
            bitfld.long 0x00 3. "RFNE,Receive FIFO Not Empty" "0: Rx FIFO is empty,1: Rx FIFO not empty"
            newline
            bitfld.long 0x00 2. "TFE,Transmit FIFO Completely Empty" "0: Tx FIFO not empty,1: Tx FIFO is empty"
            newline
            bitfld.long 0x00 1. "TFNF,Transmit FIFO Not Full" "0: Tx FIFO is full,1: Tx FIFO not full"
            newline
            bitfld.long 0x00 0. "ACTIVITY,I2C Activity Status" "0: I2C is idle,1: I2C is active"
    rgroup.long 0x74++0x03
        line.long 0x00 "IC_TXFLR,I2C Transmit FIFO Level Register"
            hexmask.long 0x00 6.--31. 1. "RSVD_TXFLR,TXFLR Register field Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0.--5. "TXFLR,Transmit FIFO Level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    rgroup.long 0x78++0x03
        line.long 0x00 "IC_RXFLR,I2C Receive FIFO Level Register"
            hexmask.long 0x00 6.--31. 1. "RSVD_RXFLR,RXFLR Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0.--5. "RXFLR,Receive FIFO Level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"

    group.long 0x7C++0x03
        line.long 0x00 "IC_SDA_HOLD,I2C SDA Hold Time Length Register"
            hexmask.long.byte 0x00 24.--31. 1. "RSVD_IC_SDA_HOLD,IC_SDA_HOLD Reserved bits - Read Only"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "IC_SDA_RX_HOLD,Sets the required SDA hold time in units of ic_clk period when DW_apb_i2c acts as a receiver"
            newline
            hexmask.long.word 0x00 0.--15. 1. "IC_SDA_TX_HOLD,Sets the required SDA hold time in units of ic_clk period when DW_apb_i2c acts as a transmitter"

    rgroup.long 0x80++0x03
        line.long 0x00 "IC_TX_ABRT_SOURCE,I2C Transmit Abort Source Register"
            hexmask.long.word 0x00 23.--31. 1. "TX_FLUSH_CNT,This field indicates the number of Tx FIFO Data Commands which are flushed due to TX_ABRT interrupt"
            newline
            bitfld.long 0x00 21.--22. "RSVD_IC_TX_ABRT_SOURCE,IC_TX_ABRT_SOURCE Reserved bits - Read Only" "0,1,2,3"
            newline
            bitfld.long 0x00 18.--20. "RSVD_ABRT_DEVICE_WRITE,ABRT_DEVICE_WRITE Register field Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 17. "ABRT_SDA_STUCK_AT_LOW,This is a master-mode-only bit" "0: This abort is not generated,1: This abort is generated because of Sda stuck.."
            newline
            bitfld.long 0x00 16. "ABRT_USER_ABRT,This is a master-mode-only bit" "0: Transfer abort detected by master- scenario..,1: Transfer abort detected by master"
            newline
            bitfld.long 0x00 15. "ABRT_SLVRD_INTX,When the processor side responds to a slave mode request for data to be transmitted to a remote master and user writes a 1 in CMD (bit 8) of IC_DATA_CMD register" "0: Slave trying to transmit to remote master in..,1: Slave trying to transmit to remote master in.."
            newline
            bitfld.long 0x00 14. "ABRT_SLV_ARBLOST,This field indicates that a Slave has lost the bus while transmitting data to a remote master" "0: Slave lost arbitration to remote master-..,1: Slave lost arbitration to remote master"
            newline
            bitfld.long 0x00 13. "ABRT_SLVFLUSH_TXFIFO,This field specifies that the Slave has received a read command and some data exists in the TX FIFO so the slave issues a TX_ABRT interrupt to flush old data in TX FIFO" "0: Slave flushes existing data in TX-FIFO upon..,1: Slave flushes existing data in TX-FIFO upon.."
            newline
            bitfld.long 0x00 12. "ARB_LOST,This field specifies that the Master has lost arbitration or if IC_TX_ABRT_SOURCE[14] is also set then the slave transmitter has lost arbitration" "0: Master or Slave-Transmitter lost arbitration-..,1: Master or Slave-Transmitter lost arbitration"
            newline
            bitfld.long 0x00 11. "ABRT_MASTER_DIS,This field indicates that the User tries to initiate a Master operation with the Master mode disabled" "0: User initiating master operation when MASTER..,1: User initiating master operation when MASTER.."
            newline
            bitfld.long 0x00 10. "ABRT_10B_RD_NORSTRT,This field indicates that the restart is disabled (IC_RESTART_EN bit (IC_CON[5]) =0) and the master sends a read command in 10-bit addressing mode" "0: Master not trying to read in 10Bit addressing..,1: Master trying to read in 10Bit addressing.."
            newline
            bitfld.long 0x00 9. "ABRT_SBYTE_NORSTRT,To clear Bit 9 the source of the ABRT_SBYTE_NORSTRT must be fixed first restart must be enabled (IC_CON[5]=1) the SPECIAL bit must be cleared (IC_TAR[11]) or the GC_OR_START bit must be cleared (IC_TAR[10])" "0: User trying to send START byte when RESTART..,1: User trying to send START byte when RESTART.."
            newline
            bitfld.long 0x00 8. "ABRT_HS_NORSTRT,This field indicates that the restart is disabled (IC_RESTART_EN bit (IC_CON[5]) =0) and the user is trying to use the master to transfer data in High Speed mode" "0: User trying to switch Master to HS mode when..,1: User trying to switch Master to HS mode when.."
            newline
            bitfld.long 0x00 7. "ABRT_SBYTE_ACKDET,This field indicates that the Master has sent a START Byte and the START Byte was acknowledged (wrong behavior)" "0: ACK detected for START byte- scenario not..,1: ABRT_SBYTE_ACKDET_GENERATED"
            newline
            bitfld.long 0x00 6. "ABRT_HS_ACKDET,This field indicates that the Master is in High Speed mode and the High Speed Master code was acknowledged (wrong behavior)" "0: HS Master code ACKed in HS Mode- scenario not..,1: HS Master code ACKed in HS Mode"
            newline
            bitfld.long 0x00 5. "ABRT_GCALL_READ,This field indicates that DW_apb_i2c in the master mode has sent a General Call but the user programmed the byte following the General Call to be a read from the bus (IC_DATA_CMD[9] is set to 1)" "0: GCALL is followed by read from bus-scenario..,1: GCALL is followed by read from bus"
            newline
            bitfld.long 0x00 4. "ABRT_GCALL_NOACK,This field indicates that DW_apb_i2c in master mode has sent a General Call and no slave on the bus acknowledged the General Call" "0: GCALL not ACKed by any slave-scenario not..,1: GCALL not ACKed by any slave"
            newline
            bitfld.long 0x00 3. "ABRT_TXDATA_NOACK,This field indicates the master-mode only bit" "0: Transmitted data non-ACKed by addressed..,1: Transmitted data not ACKed by addressed slave"
            newline
            bitfld.long 0x00 2. "ABRT_10ADDR2_NOACK,This field indicates that the Master is in 10-bit address mode and that the second address byte of the 10-bit address was not acknowledged by any slave" "0: This abort is not generated,1: Byte 2 of 10Bit Address not ACKed by any slave"
            newline
            bitfld.long 0x00 1. "ABRT_10ADDR1_NOACK,This field indicates that the Master is in 10-bit address mode and the first 10-bit address byte was not acknowledged by any slave" "0: This abort is not generated,1: Byte 1 of 10Bit Address not ACKed by any slave"
            newline
            bitfld.long 0x00 0. "ABRT_7B_ADDR_NOACK,This field indicates that the Master is in 7-bit addressing mode and the address sent was not acknowledged by any slave" "0: This abort is not generated,1: This abort is generated because of NOACK for.."

    group.long 0x84++0x03
        line.long 0x00 "IC_SLV_DATA_NACK_ONLY,Generate Slave Data NACK Register The register is used to generate a NACK for the data part of a transfer when DW_apb_i2c is acting as a slave-receiver"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_SLV_DATA_NACK_ONLY,IC_SLV_DATA_NACK_ONLY Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "NACK,Generate NACK" "0: Slave receiver generates NACK normally,1: Slave receiver generates NACK upon data.."
    group.long 0x88++0x03
        line.long 0x00 "IC_DMA_CR,DMA Control Register"
            hexmask.long 0x00 2.--31. 1. "RSVD_IC_DMA_CR_2_31,RSVD_IC_DMA_CR_2_31 Reserved bits - Read Only"
            newline
            bitfld.long 0x00 1. "TDMAE,Transmit DMA Enable" "0: transmit FIFO DMA channel disabled,1: Transmit FIFO DMA channel enabled"
            newline
            bitfld.long 0x00 0. "RDMAE,Receive DMA Enable" "0: Receive FIFO DMA channel disabled,1: Receive FIFO DMA channel enabled"
    group.long 0x8C++0x03
        line.long 0x00 "IC_DMA_TDLR,DMA Transmit Data Level Register"
            hexmask.long 0x00 5.--31. 1. "RSVD_DMA_TDLR,DMA_TDLR Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0.--4. "DMATDL,Transmit Data Level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    group.long 0x90++0x03
        line.long 0x00 "IC_DMA_RDLR,I2C Receive Data Level Register"
            hexmask.long 0x00 5.--31. 1. "RSVD_DMA_RDLR,DMA_RDLR Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0.--4. "DMARDL,Receive Data Level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    group.long 0x94++0x03
        line.long 0x00 "IC_SDA_SETUP,I2C SDA Setup Register"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_IC_SDA_SETUP,IC_SDA_SETUP Reserved bits - Read Only"
            newline
            abitfld.long 0x00 0.--7. "SDA_SETUP,SDA Setup (tSU:DAT)" "0x00=0: IC_SDA_SETUP should be programmed to a..,0x01=1: IC_SDA_SETUP should be programmed to a.."
    group.long 0x98++0x03
        line.long 0x00 "IC_ACK_GENERAL_CALL,I2C ACK General Call Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_ACK_GEN_1_31,RSVD_IC_ACK_GEN_1_31 Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "ACK_GEN_CALL,ACK General Call" "0: Generate NACK for General Call,1: Generate ACK for a General Call"

    rgroup.long 0x9C++0x03
        line.long 0x00 "IC_ENABLE_STATUS,I2C Enable Status Register"
            hexmask.long 0x00 3.--31. 1. "RSVD_IC_ENABLE_STATUS,IC_ENABLE_STATUS Reserved bits - Read Only"
            newline
            bitfld.long 0x00 2. "SLV_RX_DATA_LOST,Slave Received Data Lost" "0: Slave RX Data is not lost,1: Slave RX Data is lost"
            newline
            bitfld.long 0x00 1. "SLV_DISABLED_WHILE_BUSY,Slave Disabled While Busy (Transmit Receive)" "0: Slave is disabled when it is idle,1: Slave is disabled when it is active"
            newline
            bitfld.long 0x00 0. "IC_EN,IC Enable Status" "0: I2C disabled,1: I2C enabled"

    group.long 0xA0++0x03
        line.long 0x00 "IC_FS_SPKLEN,I2C SS FS or FM+ Spike Suppression Limit"
            hexmask.long.tbyte 0x00 8.--31. 1. "RSVD_IC_FS_SPKLEN,IC_FS_SPKLEN Reserved bits - Read Only"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "IC_FS_SPKLEN,This register must be set before any I2C bus transaction can take place to ensure stable operation"
    group.long 0xAC++0x03
        line.long 0x00 "IC_SCL_STUCK_AT_LOW_TIMEOUT,I2C SCL Stuck at Low Timeout"
            hexmask.long 0x00 0.--31. 1. "IC_SCL_STUCK_LOW_TIMEOUT,DW_apb_i2c generate the interrupt to indicate SCL stuck at low (ic_scl_stuck_at_low_intr/ic_scl_stuck_at_low_intr_n) if it detects the SCL stuck at low for the IC_SCL_STUCK_LOW_TIMEOUT in units of ic_clk period"
    group.long 0xB0++0x03
        line.long 0x00 "IC_SDA_STUCK_AT_LOW_TIMEOUT,I2C SDA Stuck at Low Timeout"
            hexmask.long 0x00 0.--31. 1. "IC_SDA_STUCK_LOW_TIMEOUT,DW_apb_i2c initiates the recovery of SDA line through enabling the SDA_STUCK_RECOVERY_EN (IC_ENABLE[3]) register bit if it detects the SDA stuck at low for the IC_SDA_STUCK_LOW_TIMEOUT in units of ic_clk period"

    rgroup.long 0xB4++0x03
        line.long 0x00 "IC_CLR_SCL_STUCK_DET,Clear SCL Stuck at Low Detect Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_CLR_SCL_STUCK_DET,CLR_SCL_STUCK_DET Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_SCL_STUCK_DET,Read this register to clear the SCL_STUCT_AT_LOW interrupt (bit 15) of the IC_RAW_INTR_STAT register" "0,1"

    group.long 0xBC++0x03
        line.long 0x00 "IC_SMBUS_CLK_LOW_SEXT,SMBus Slave Clock Extend Timeout Register"
            hexmask.long 0x00 0.--31. 1. "SMBUS_CLK_LOW_SEXT_TIMEOUT,This field is used to detect the Slave Clock Extend timeout (tLOW:SEXT) in master mode extended by the slave device in one message from the initial START to the STOP"
    group.long 0xC0++0x03
        line.long 0x00 "IC_SMBUS_CLK_LOW_MEXT,SMBus Master Clock Extend Timeout Register"
            hexmask.long 0x00 0.--31. 1. "SMBUS_CLK_LOW_MEXT_TIMEOUT,This field is used to detect the Master extend SMBus clock (SCLK) timeout defined from START-to-ACK ACK-to-ACK or ACK-to-STOP in Master mode"
    group.long 0xC4++0x03
        line.long 0x00 "IC_SMBUS_THIGH_MAX_IDLE_COUNT,SMBus Master THigh MAX Bus-idle count Register"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_SMBUS_THIGH_MAX_BUS_IDLE_CNT,SMBUS_THIGH_MAX_BUS_IDLE_CNT Reserved bits - Read Only"
            newline
            hexmask.long.word 0x00 0.--15. 1. "SMBUS_THIGH_MAX_BUS_IDLE_CNT,This field is used to set the required Bus-Idle time period used when a master has been dynamically added to the bus and may not have detected a state transition on the SMBCLK or SMBDAT lines"

    rgroup.long 0xC8++0x03
        line.long 0x00 "IC_SMBUS_INTR_STAT,SMBUS Interrupt Status Register"
            hexmask.long.tbyte 0x00 11.--31. 1. "RSVD_IC_SMBUS_INTR_STAT,IC_SMBUS_INTR_STAT Reserved bits - Read Only"
            newline
            bitfld.long 0x00 10. "RSVD_R_SMBUS_ALERT_DET,R_SMBUS_ALERT_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 9. "RSVD_R_SMBUS_SUSPEND_DET,R_SMBUS_SUSPEND_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 8. "RSVD_R_SLV_RX_PEC_NACK,R_SLV_RX_PEC_NACK Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 7. "RSVD_R_ARP_ASSGN_ADDR_CMD_DET,R_ARP_ASSGN_ADDR_CMD_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 6. "RSVD_R_ARP_GET_UDID_CMD_DET,R_ARP_GET_UDID_CMD_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 5. "RSVD_R_ARP_RST_CMD_DET,R_ARP_RST_CMD_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 4. "RSVD_R_ARP_PREPARE_CMD_DET,R_ARP_PREPARE_CMD_DET Regsiter field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 3. "R_HOST_NOTIFY_MST_DET,See IC_SMBUS_RAW_INTR_STAT for a detailed description of R_HOST_NOTIFY_MST_DET bit" "0: HOST_NOTIFY_MST_DET interrupt is inactive,1: HOST_NOTIFY_MST_DET interrupt is active"
            newline
            bitfld.long 0x00 2. "R_QUICK_CMD_DET,See IC_SMBUS_RAW_INTR_STAT for a detailed description of R_QUICK_CMD_DET bit" "0: QUICK_CMD_DET interrupt is inactive,1: QUICK_CMD_DET interrupt is active"
            newline
            bitfld.long 0x00 1. "R_MST_CLOCK_EXTND_TIMEOUT,See IC_SMBUS_RAW_INTR_STAT for a detailed description of R_MST_CLOCK_EXTND_TIMEOUT bit" "0: MST_CLOCK_EXTND_TIMEOUT interrupt is inactive,1: MST_CLOCK_EXTND_TIMEOUT interrupt is active"
            newline
            bitfld.long 0x00 0. "R_SLV_CLOCK_EXTND_TIMEOUT,See IC_SMBUS_RAW_INTR_STAT for a detailed description of R_SLV_CLOCK_EXTND_TIMEOUT bit" "0: SLV_CLOCK_EXTND_TIMEOUT interrupt is inactive,1: SLV_CLOCK_EXTND_TIMEOUT interrupt is active"

    group.long 0xCC++0x03
        line.long 0x00 "IC_SMBUS_INTR_MASK,SMBus Interrupt Mask Register"
            hexmask.long.tbyte 0x00 11.--31. 1. "RSVD_IC_SMBUS_INTR_MASK,IC_SMBUS_INTR_MASK Reserved bits - Read Only"
            newline
            rbitfld.long 0x00 9.--10. "RSVD_IC_SMBUS_INTR_MASK_9_10,RSVD_IC_SMBUS_INTR_MASK_9_10 Register field Reserved bits" "0,1,2,3"
            newline
            rbitfld.long 0x00 4.--8. "RSVD_M_ARP_4_8,RSVD_M_ARP_4_8 Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 3. "M_HOST_NOTIFY_MST_DET,This bit masks the R_HOST_NOTIFY_MST_DET interrupt in IC_SMBUS_INTR_STAT register" "0: HOST_NOTIFY_MST_DET interrupt is masked,1: HOST_NOTIFY_MST_DET interrupt is unmasked"
            newline
            bitfld.long 0x00 2. "M_QUICK_CMD_DET,This bit masks the R_QUICK_CMD_DET interrupt in IC_SMBUS_INTR_STAT register" "0: QUICK_CMD_DET interrupt is masked,1: QUICK_CMD_DET interrupt is unmasked"
            newline
            bitfld.long 0x00 1. "M_MST_CLOCK_EXTND_TIMEOUT,This bit masks the R_MST_CLOCK_EXTND_TIMEOUT interrupt in IC_SMBUS_INTR_STAT register" "0: MST_CLOCK_EXTND_TIMEOUT interrupt is masked,1: MST_CLOCK_EXTND_TIMEOUT interrupt is unmasked"
            newline
            bitfld.long 0x00 0. "M_SLV_CLOCK_EXTND_TIMEOUT,This bit masks the R_SLV_CLOCK_EXTND_TIMEOUT interrupt in IC_SMBUS_INTR_STAT register" "0: SLV_CLOCK_EXTND_TIMEOUT interrupt is masked,1: SLV_CLOCK_EXTND_TIMEOUT interrupt is unmasked"

    rgroup.long 0xD0++0x03
        line.long 0x00 "IC_SMBUS_RAW_INTR_STAT,SMBus Raw Interrupt Status Register"
            hexmask.long.tbyte 0x00 11.--31. 1. "RSVD_IC_SMBUS_RAW_INTR_STAT,IC_SMBUS_RAW_INTR_STAT Reserved bits - Read Only"
            newline
            bitfld.long 0x00 10. "RSVD_SMBUS_ALERT_DET,SMBUS_ALERT_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 9. "RSVD_SMBUS_SUSPEND_DET,SMBUS_SUSPEND_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 8. "RSVD_SLV_RX_PEC_NACK,SLV_RX_PEC_NACK Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 7. "RSVD_ARP_ASSGN_ADDR_CMD_DET,ARP_ASSGN_ADDR_CMD_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 6. "RSVD_ARP_GET_UDID_CMD_DET,ARP_GET_UDID_CMD_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 5. "RSVD_ARP_RST_CMD_DET,ARP_RST_CMD_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 4. "RSVD_ARP_PREPARE_CMD_DET,ARP_PREPARE_CMD_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 3. "HOST_NTFY_MST_DET,Indicates whether a Notify ARP Master ARP command has been received" "0: HOST_NTFY_MST_DET interrupt is inactive,1: HOST_NTFY_MST_DET interrupt is active"
            newline
            bitfld.long 0x00 2. "QUICK_CMD_DET,Indicates whether a Quick command has been received on the SMBus interface regardless of whether DW_apb_i2c is operating in slave or master mode" "0: Quick Command interrupt is inactive,1: Quick Command interrupt is active"
            newline
            bitfld.long 0x00 1. "MST_CLOCK_EXTND_TIMEOUT,Indicates whether the Master device transaction (START-to-ACK ACK-to-ACK or ACK-to-STOP) from START to STOP exceeds IC_SMBUS_CLOCK_LOW_MEXT time with in each byte of message" "0: Master Clock Extend Timeout interrupt is..,1: Master Clock Extend Timeout interrupt is active"
            newline
            bitfld.long 0x00 0. "SLV_CLOCK_EXTND_TIMEOUT,Indicates whether the transaction from Slave (i.e from START to STOP) exceeds IC_SMBUS_CLK_LOW_SEXT time" "0: Slave Clock Extend Timeout interrupt is..,1: Slave Clock Extend Timeout interrupt is active"

    wgroup.long 0xD4++0x03
        line.long 0x00 "IC_CLR_SMBUS_INTR,SMBus Clear Interrupt Register"
            hexmask.long.tbyte 0x00 11.--31. 1. "RSVD_IC_CLR_SMBUS_INTR,IC_CLR_SMBUS_INTR Reserved bits - Read Only"
            newline
            bitfld.long 0x00 10. "RSVD_CLR_SMBUS_ALERT_DET,CLR_SMBUS_ALERT_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 9. "RSVD_CLR_SMBUS_SUSPEND_DET,CLR_SMBUS_SUSPEND_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 8. "RSVD_CLR_SLV_RX_PEC_NACK,CLR_SLV_RX_PEC_NACK Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 7. "RSVD_CLR_ARP_ASSGN_ADDR_CMD_DET,CLR_ARP_ASSGN_ADDR_CMD_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 6. "RSVD_CLR_ARP_GET_UDID_CMD_DET,CLR_ARP_GET_UDID_CMD_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 5. "RSVD_CLR_ARP_RST_CMD_DET,CLR_ARP_RST_CMD_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 4. "RSVD_CLR_ARP_PREPARE_CMD_DET,CLR_ARP_PREPARE_CMD_DET Register field Reserved bits - Read Only" "0,1"
            newline
            bitfld.long 0x00 3. "CLR_HOST_NOTIFY_MST_DET,Write this register bit to clear the HOST_NOTIFY_MST_DET interrupt (bit 3) of the IC_SMBUS_RAW_INTR_STAT register" "0,1"
            newline
            bitfld.long 0x00 2. "CLR_QUICK_CMD_DET,Write this register bit to clear the QUICK_CMD_DET interrupt (bit 2) of the IC_SMBUS_RAW_INTR_STAT register" "0,1"
            newline
            bitfld.long 0x00 1. "CLR_MST_CLOCK_EXTND_TIMEOUT,Write this register bit to clear the MST_CLOCK_EXTND_TIMEOUT interrupt (bit 1) of the IC_SMBUS_RAW_INTR_STAT register" "0,1"
            newline
            bitfld.long 0x00 0. "CLR_SLV_CLOCK_EXTND_TIMEOUT,Write this register bit to clear the SLV_CLOCK_EXTND_TIMEOUT interrupt (bit 0) of the IC_SMBUS_RAW_INTR_STAT register" "0,1"

    group.long 0xF0++0x03
        line.long 0x00 "REG_TIMEOUT_RST,Name: Register timeout counter reset register Size: REG_TIMEOUT_WIDTH bits Address: 0xF0 Read/Write Access: Read/Write This register keeps the timeout value of register timer counter"
            hexmask.long 0x00 4.--31. 1. "RSVD_REG_TIMEOUT_RST,Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0.--3. "REG_TIMEOUT_RST_rw,This field holds reset value of REG_TIMEOUT counter register" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0xF4++0x03
        line.long 0x00 "IC_COMP_PARAM_1,Component Parameter Register 1 Note: This is a constant read-only register that contains encoded information about the component's parameter settings"
            hexmask.long.byte 0x00 24.--31. 1. "RSVD_IC_COMP_PARAM_1,IC_COMP_PARAM_1 Reserved bits - Read Only"
            newline
            abitfld.long 0x00 16.--23. "TX_BUFFER_DEPTH,The value of this register is derived from the IC_TX_BUFFER_DEPTH coreConsultant parameter" "0x00=0: Reserved,0x01=1: ,0x03=3: ,0xFF=255: 256"
            newline
            abitfld.long 0x00 8.--15. "RX_BUFFER_DEPTH,The value of this register is derived from the IC_RX_BUFFER_DEPTH coreConsultant parameter" "0x00=0: Reserved,0x01=1: ,0x03=3: ,0xFF=255: 256"
            newline
            bitfld.long 0x00 7. "ADD_ENCODED_PARAMS,The value of this register is derived from the IC_ADD_ENCODED_PARAMS coreConsultant parameter" "0: Disables capability of reading encoded..,1: Enables capability of reading encoded.."
            newline
            bitfld.long 0x00 6. "HAS_DMA,The value of this register is derived from the IC_HAS_DMA coreConsultant parameter" "0: DMA handshaking signals are disabled,1: DMA handshaking signals are enabled"
            newline
            bitfld.long 0x00 5. "INTR_IO,The value of this register is derived from the IC_INTR_IO coreConsultant parameter" "0: INDIVIDUAL Interrupt outputs,1: COMBINED Interrupt outputs"
            newline
            bitfld.long 0x00 4. "HC_COUNT_VALUES,The value of this register is derived from the IC_HC_COUNT VALUES coreConsultant parameter" "0: Programmable count values for each mode,1: Hard code the count values for each mode"
            newline
            bitfld.long 0x00 2.--3. "MAX_SPEED_MODE,The value of this register is derived from the IC_MAX_SPEED_MODE coreConsultant parameter" "?,1: IC MAX SPEED is STANDARD MODE,2: IC MAX SPEED is FAST MODE,3: IC MAX SPEED is HIGH MODE"
            newline
            bitfld.long 0x00 0.--1. "APB_DATA_WIDTH,The value of this register is derived from the APB_DATA_WIDTH coreConsultant parameter" "0: APB data bus width is 08 bits,1: APB data bus width is 16 bits,2: APB data bus width is 32 bits,?..."
    rgroup.long 0xF8++0x03
        line.long 0x00 "IC_COMP_VERSION,I2C Component Version Register"
            hexmask.long 0x00 0.--31. 1. "IC_COMP_VERSION,Specific values for this register are described in the Releases Table in the DW_apb_i2c Release Notes"
    rgroup.long 0xFC++0x03
        line.long 0x00 "IC_COMP_TYPE,I2C Component Type Register"
            hexmask.long 0x00 0.--31. 1. "IC_COMP_TYPE,DesignWare Component Type number = 0x44_57_01_40"

    group.long 0x100++0x03
        line.long 0x00 "IC_SAR2,I2C Slave Address Register 2"
            hexmask.long.tbyte 0x00 10.--31. 1. "RSVD_IC_SAR2,IC_SAR2 Reserved bits - Read Only"
            newline
            hexmask.long.word 0x00 0.--9. 1. "IC_SAR2,The IC_SAR2 holds the slave address 2 when the I2C is operating as a slave"

    rgroup.long 0x11C++0x03
        line.long 0x00 "IC_CLR_WR_REQ,Clear WR_REQ Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_CLR_WR_REQ,IC_CLR_WR_REQ Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_WR_REQ,Read this register to clear the WR_REQ interrupt (bit 15) of the IC_RAW_INTR_STAT register" "0,1"
    rgroup.long 0x120++0x03
        line.long 0x00 "IC_CLR_SLV_ADDR_TAG,Clear CLR_SLV_ADDR_TAG Interrupt Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_IC_CLR_SLV_ADDR_TAG,IC_CLR_SLV_ADDR_TAG Reserved bits - Read Only"
            newline
            bitfld.long 0x00 0. "CLR_SLV_ADDR_TAG,Read this register to clear all SLV_ADDRx_TAG (Where x is 1 through IC_NUM_SARS) interrupts (bit 16 ...(16+IC_NUM_SARS-1)) of the IC_RAW_INTR_STAT register" "0,1"
tree.end

tree "IOCTRL ()"
    base ad:0x89001000
    group.long 0x00++0x03
        line.long 0x00 "GPIO_00,GPIO_00 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,?,?,?,4: IO used for TestMux-TestBus bit 0,5: IO used for DSP General Purpose input 0,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x04++0x03
        line.long 0x00 "GPIO_01,GPIO_01 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,?,?,?,4: IO used for TestMux-TestBus bit 1,5: IO used for DSP General Purpose input 1,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x08++0x03
        line.long 0x00 "GPIO_02,GPIO_02 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for Ethernet PHY Interrupt(input),?,?,4: IO used for TestMux-TestBus bit 2,5: IO used for DSP General Purpose input 2,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x0C++0x03
        line.long 0x00 "GPIO_03,GPIO_03 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for MMIC Frame Start (output),?,?,4: IO used for TestMux-TestBus bit 3,5: IO used for DSP General Purpose input 3,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x10++0x03
        line.long 0x00 "GPIO_04,GPIO_04 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for UART Tx (output),?,?,4: IO used for TestMux-TestBus bit 4,5: IO used for DSP General Purpose input 4,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x14++0x03
        line.long 0x00 "GPIO_05,GPIO_05 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for UART Rx (input),?,?,4: IO used for TestMux-TestBus bit 5,5: IO used for DSP General Purpose input 5,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x18++0x03
        line.long 0x00 "GPIO_06,GPIO_06 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for I2C Serial Clock (output),?,?,4: IO used for TestMux-TestBus bit 6,5: IO used for DSP General Purpose input 6,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x1C++0x03
        line.long 0x00 "GPIO_07,GPIO_07 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for I2C Serial Data,?,?,4: IO used for TestMux-TestBus bit 7,5: IO used for DSP General Purpose input 7,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x20++0x03
        line.long 0x00 "GPIO_08,GPIO_08 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for GP SPI Clock,?,?,4: IO used for TestMux-TestBus bit 8,5: IO used for DSP General Purpose output 0,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x24++0x03
        line.long 0x00 "GPIO_09,GPIO_09 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for GP SPI CSN,?,?,4: IO used for TestMux-TestBus bit 9,5: IO used for DSP General Purpose output 1,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x28++0x03
        line.long 0x00 "GPIO_10,GPIO_10 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for GP SPI D0,?,?,4: IO used for TestMux-TestBus bit 10,5: IO used for DSP General Purpose output 2,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x2C++0x03
        line.long 0x00 "GPIO_11,GPIO_11 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for GP SPI D1,?,?,4: IO used for TestMux-TestBus bit 11,5: IO used for DSP General Purpose output 3,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x30++0x03
        line.long 0x00 "GPIO_12,GPIO_12 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for GP SPI D2,?,?,4: IO used for TestMux-TestBus bit 12,5: IO used for DSP General Purpose output 4,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x34++0x03
        line.long 0x00 "GPIO_13,GPIO_13 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for GP SPI D3,?,?,4: IO used for TestMux-TestBus bit 13,5: IO used for DSP General Purpose output 5,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x38++0x03
        line.long 0x00 "GPIO_14,GPIO_14 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for PWM 0 (output),?,?,4: IO used for TestMux-TestBus bit 14,5: IO used for DSP General Purpose output 6,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x3C++0x03
        line.long 0x00 "GPIO_15,GPIO_15 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "0: IO controlled by GPIO Controller settings,1: IO used for PWM 1 (output),?,?,4: IO used for TestMux-TestBus bit 15,5: IO used for DSP General Purpose output 7,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x40++0x03
        line.long 0x00 "GPIO_16,GPIO_16 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "?,1: IO used for PWM 2 (output),?,?,4: IO used for TestMux-TestBus bit 16,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x44++0x03
        line.long 0x00 "GPIO_17,GPIO_17 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "?,1: IO used for PWM 3 (output),?,?,4: IO used for TestMux-TestBus bit 17,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x48++0x03
        line.long 0x00 "GPIO_18,GPIO_18 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "?,1: IO used for CAN 0 RXD,?,?,4: IO used for TestMux-TestBus bit 18,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x4C++0x03
        line.long 0x00 "GPIO_19,GPIO_19 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "?,1: IO used for CAN 0 TXD,?,?,4: IO used for TestMux-TestBus bit 19,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x50++0x03
        line.long 0x00 "GPIO_20,GPIO_20 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "?,1: IO used for CAN 0 STDBY,?,?,4: IO used for TestMux-TestBus bit 20,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x54++0x03
        line.long 0x00 "GPIO_21,GPIO_21 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "?,1: IO used for CAN 1 RXD,?,?,4: IO used for TestMux-TestBus bit 21,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x58++0x03
        line.long 0x00 "GPIO_22,GPIO_22 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "?,1: IO used for CAN 1 TXD,?,?,4: IO used for TestMux-TestBus bit 22,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x5C++0x03
        line.long 0x00 "GPIO_23,GPIO_23 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "?,1: IO used for CAN 1 STDBY,?,?,4: IO used for TestMux-TestBus bit 23,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x60++0x03
        line.long 0x00 "GPIO_24,GPIO_24 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "?,1: IO used for Ethernet MDIO,?,?,4: IO used for TestMux-TestBus bit 0,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x64++0x03
        line.long 0x00 "GPIO_25,GPIO_25 Control"
            bitfld.long 0x00 16.--18. "FUNC_SEL,Select Functional mode" "?,1: IO used for Ethernet MDC,?,?,4: IO used for TestMux-TestBus bit 1,?..."
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 9. "IN_INV,Invert input signal going into the core" "0,1"
            newline
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0x98++0x03
        line.long 0x00 "TEST_BUS_00,Test 24-bit Bus 0 Control Register"
            hexmask.long.tbyte 0x00 0.--23. 1. "DATA,Control directly the Test Bus 00 output It is mainly used to validate the test configuration"
    group.long 0x9C++0x03
        line.long 0x00 "TEST_BUS_CTRL,Test Bus Select Control Register"
            bitfld.long 0x00 0.--4. "SEL,Select which one of the XXX 24-bit buses is connected to GPIO outputs" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    group.long 0xA0++0x03
        line.long 0x00 "FLASH_QSPI_CLK,FLASH_QSPI_CLK Control"
            bitfld.long 0x00 16. "OE_N,Enable Output from pad (active low)" "0,1"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            newline
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xA4++0x03
        line.long 0x00 "FLASH_QSPI_CSN,FLASH_QSPI_CSN Control"
            bitfld.long 0x00 16. "OE_N,Enable Output from pad (active low)" "0,1"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            newline
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xA8++0x03
        line.long 0x00 "FLASH_QSPI_D0,FLASH_QSPI_D0 Control"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xAC++0x03
        line.long 0x00 "FLASH_QSPI_D1,FLASH_QSPI_D1 Control"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xB0++0x03
        line.long 0x00 "FLASH_QSPI_D2,FLASH_QSPI_D2 Control"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xB4++0x03
        line.long 0x00 "FLASH_QSPI_D3,FLASH_QSPI_D3 Control"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xB8++0x03
        line.long 0x00 "MM_QSPI_CLK,MM_QSPI_CLK Control"
            bitfld.long 0x00 16. "OE_N,Enable Output from pad (active low)" "0,1"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            newline
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xBC++0x03
        line.long 0x00 "MM_QSPI_CSN,MM_QSPI_CSN Control"
            bitfld.long 0x00 16. "OE_N,Enable Output from pad (active low)" "0,1"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            newline
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xC0++0x03
        line.long 0x00 "MM_QSPI_D0,MM_QSPI_D0 Control"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xC4++0x03
        line.long 0x00 "MM_QSPI_D1,MM_QSPI_D1 Control"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xC8++0x03
        line.long 0x00 "MM_QSPI_D2,MM_QSPI_D2 Control"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xCC++0x03
        line.long 0x00 "MM_QSPI_D3,MM_QSPI_D3 Control"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 4.--7. "DS,Select Output Drive Strength" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xD0++0x03
        line.long 0x00 "MM_ERROR,MM_ERROR Control"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xD4++0x03
        line.long 0x00 "MM_FRAME_SOT,MM_FRAME_SOT Control"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xD8++0x03
        line.long 0x00 "MM_IRQ,MM_IRQ Control"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
            bitfld.long 0x00 1. "PS,Select Pull Resistor" "0: Pull Down Selected,1: Pull Up Selected"
            newline
            bitfld.long 0x00 0. "PE,Enable Pull Resistor" "0: Resistor disabled,1: Resistor enabled"
    group.long 0xDC++0x03
        line.long 0x00 "SBI,SBI Control"
            bitfld.long 0x00 12. "ST,Enable Schmitt Trigger input function" "0: Schmitt Trigger disabled,1: Schmitt Trigger enabled"
            bitfld.long 0x00 8. "IE,Enable Input signal going into the core" "0: Input disabled,1: Input enabled"
    group.long 0xE0++0x03
        line.long 0x00 "SPARE,Spare Register"
            hexmask.long 0x00 0.--31. 1. "SPARE,Spare registers"
    group.long 0xE4++0x03
        line.long 0x00 "CTL_IO,Lock control"
            hexmask.long 0x00 0.--31. 1. "LOCK_KEY,Write 0x9bd8ca97 to allow write access to this SFR bank"

    rgroup.long 0xE8++0x03
        line.long 0x00 "STS_IO,Lock status"
            bitfld.long 0x00 0. "LOCK_N,Lock status for this SFR bank" "0,1"
tree.end

tree "MIPI ()"
    base ad:0x84480000
    group.long 0x00++0x03
        line.long 0x00 "CTRL,Control"
            bitfld.long 0x00 24. "FW_READ_REQUEST_TRIGGER,Firmware generated read request trigger" "0,1"
            newline
            bitfld.long 0x00 20. "PING_PONG_OCP_ACCESS_FORCE,Active high OCP access force" "0,1"
            newline
            bitfld.long 0x00 16. "OCP_RD_ADDRESS_EN,RESERVED" "0,1"
            newline
            bitfld.long 0x00 12. "OCP_WR_ADDRESS_EN,RESERVED" "0,1"
            newline
            bitfld.long 0x00 8. "TRANSPOSER_BYPASS,Active high transposer bypass bit" "0,1"
            newline
            bitfld.long 0x00 4. "DEBUG_ENA,Active high debug mode enable" "0,1"
            newline
            bitfld.long 0x00 0. "ENA,Active high mipi_wrapper enable" "0,1"
    group.long 0x04++0x03
        line.long 0x00 "MIPI_CTRL_0,Mipi d-phy 0 control register"
            bitfld.long 0x00 28. "DPHY_CLK_FHS_MODE,Enables the slave clock lane feature to maintain HS reception state during continuous clock mode operation" "0: (default) Feature disabled,1: Feature enabled"
            newline
            bitfld.long 0x00 24. "CLK_PNCH,Controls polarity change feature of clock lanes" "0: (default) polarity change feature is disabled,1: polarity change feature is enabled CLK LANE.."
            newline
            bitfld.long 0x00 20. "D3_PNCH,Controls polarity change feature of data lanes" "0: (default) polarity change feature is disabled,1: polarity change feature is enabled"
            newline
            bitfld.long 0x00 16. "D2_PNCH,Controls polarity change feature of data lanes" "0: (default) polarity change feature is disabled,1: polarity change feature is enabled"
            newline
            bitfld.long 0x00 12. "D1_PNCH,Controls polarity change feature of data lanes" "0: (default) polarity change feature is disabled,1: polarity change feature is enabled"
            newline
            bitfld.long 0x00 8. "D0_PNCH,Controls polarity change feature of data lanes" "0: (default) polarity change feature is disabled,1: polarity change feature is enabled"
            newline
            bitfld.long 0x00 4.--5. "LANE0_SEL,Control signal to select data lane as lane 0" "0: selects PPI Lane0 as Lane 0 [Default],1: selects PPI Lane1 as Lane 0,2: selects PPI Lane2 as Lane 0,3: selects PPI Lane3 as Lane 0"
            newline
            bitfld.long 0x00 0. "ALIGN_SW,This feature is used to configure high speed sync token alignment" "0: Feature disabled [Default],1: Feature enabled"
    group.long 0x08++0x03
        line.long 0x00 "MIPI_CTRL_1,Mipi d-phy 1 control register"
            bitfld.long 0x00 16.--21. "U_PRG_RXHS_SETTLE,Bits used to program T_HS_SETTLE" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            hexmask.long.byte 0x00 8.--14. 1. "UC_PRG_RXHS_SETTLE,Bits used to program T_CLK_SETTLE"
            newline
            bitfld.long 0x00 4. "PD_PHY,Power Down input for PHY" "0,1"
            newline
            bitfld.long 0x00 0.--1. "RCAL_SOC,On-chip termination control bits" "0: 20% higher than mid-range,1: Mid-range impedance setting,2: 15% lower than mid-range,3: 25% lower than mid-range"
    group.long 0x0C++0x03
        line.long 0x00 "MIPI_CTRL_2,Mipi d-phy 2 control register"
            bitfld.long 0x00 8.--10. "VCAL_LPRX,Adjust the threshold voltage and hysteresis of LP-RX.3'b100 VCAL_LPRX [Default] at normal operation" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0.--5. "TEST_ENBL,Six-bit signal that enables the testing modes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0x10++0x03
        line.long 0x00 "MIPI_CTRL_3,Mipi d-phy 3 control register"
            hexmask.long 0x00 0.--31. 1. "TEST_PATTERN,This is the programmable test pattern used by BIST pattern generator and pattern matcher on DPHY IP"
    group.long 0x14++0x03
        line.long 0x00 "CSI2_PKT_INFO,Packet setup"
            bitfld.long 0x00 28.--29. "CSR_NUM_ACTIVE_ADC_CHANNELS," "?,1: 2 channels,2: RESERVED,3: 4 channels valid - always"
            newline
            hexmask.long.word 0x00 16.--26. 1. "CSR_CHIRP_PER_FRAME,Max 2K chirps/frame actual value = CSR +1"
            newline
            bitfld.long 0x00 12. "CSR_SYMB_12_14_BIT_N," "0,1"
            newline
            hexmask.long.word 0x00 0.--10. 1. "CSR_SYMB_PER_CHIRP,min 64 symbols/chirp-max 2K symbols/chirp per enabled ADC channel (for max of 8K CSI-2 packet size) actual value = csr +1"

    rgroup.long 0x18++0x03
        line.long 0x00 "MIPI_STATUS,Mipi status"
            bitfld.long 0x00 0. "CLK_BIST_ACTIVE,Output signal showing that the clock lane is active and running" "0,1"

    group.long 0x1C++0x03
        line.long 0x00 "TESTMUX_CTRL,testmux control"
            bitfld.long 0x00 2. "TESTMUX_SEL,Select testmux" "0: Selecting csi2 debug testmux,1: Selecting ping pong debug testmux"
            newline
            bitfld.long 0x00 1. "PING_PONG_DEBUG_TESTMUX_SEL,Selector for Ping Pong debug testmux" "0,1"
            newline
            bitfld.long 0x00 0. "CSI2_DEBUG_TESTMUX_SEL,Selector for csi2 testmux bus" "0,1"

    rgroup.long 0x20++0x03
        line.long 0x00 "MIPI_STATUS_0_CH0,Mipi d-phy 0 status register"
            bitfld.long 0x00 24.--25. "D0_BIST_ACTIVE,Output signal showing that the BIST test is active and running DY_BIST_ACTIVE[0]: Shows that the first LP entry command is received" "0,1,2,3"
            newline
            hexmask.long.word 0x00 8.--17. 1. "D0_BIST_ERR_CNT,Output bus that shows the number of failing words in case of having test failure"
            newline
            bitfld.long 0x00 4.--5. "D0_BIST_VALID,Output signal showing that the SYNC token is received and the data is valid: DY_BIST_VALID[0]: Shows that the first burst data is valid.DY_BIST_VALID[1]: Shows that the second burst data is valid" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--1. "D0_BIST_PASS,Two-bit signal showing the pass/fail test result.BIST_PASS[0]: Shows that the first HS burst has been received properly.BIST_PASS[1]: Shows that the Second HS burst has been received properly" "0,1,2,3"
    rgroup.long 0x24++0x03
        line.long 0x00 "MIPI_STATUS_1_CH0,Mipi d-phy 1 status register"
            hexmask.long.tbyte 0x00 0.--18. 1. "D0_BIST_WORD_CNT,Output bus that shows the number of words that have been sent in the BIST mode"

    group.long 0x28++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_0_CH0,Interference detection control register"
            bitfld.long 0x00 28. "FORWARD_INTERFERENCE_DETECTION_0,If asserted polluted binary marker for each sample is attached to sample value and shared with the rest of Soc" "0,1"
            newline
            bitfld.long 0x00 24.--25. "DETECTION_MODE_0,Sample will be marked as pollutted depending on interference detection mode" "0: The sample is marked as polluted if greater..,1: The sample is marked as polluted if greater..,2: The sample is marked as polluted if greater..,3: The sample is marked as polluted if greater.."
            newline
            bitfld.long 0x00 20. "SQUARE_ACCUM_SEL_0,Square value accumulator selector" "0: Absolute value accumulator selected,1: Square value accumulator selected"
            newline
            bitfld.long 0x00 16. "ABS_DIFF_SEL_0,Absolute differential value accumulator selector" "0: Hardcoded absolute differential value..,1: Absolute differential value accumulator.."
            newline
            bitfld.long 0x00 12. "ABS_SEL_0,Absolute value accumulator selector" "0: Hardcoded absolute value threshold selected,1: Absolute value accumulator selected"
            newline
            bitfld.long 0x00 8.--10. "ABS_DIFF_PROG_SHIFT_0,Programable right shift applied to absolute differential value accumulator" "?,?,2: 1/64 factor applied to absolute differential..,3: 1/128 factor applied to absolute differential..,4: 1/256 factor applied to absolute differential..,5: 1/512 factor applied to absolute differential..,6: 1/1024 factor applied to absolute..,7: 1/2048 factor applied to absolute.."
            newline
            bitfld.long 0x00 4.--6. "ABS_PROG_SHIFT_0,Programable right shift applied to absolute value accumulator" "?,?,2: 1/64 factor applied to absolute value..,3: 1/128 factor applied to absolute value..,4: 1/256 factor applied to absolute value..,5: 1/512 factor applied to absolute value..,6: 1/1024 factor applied to absolute value..,7: 1/2048 factor applied to absolute value.."
            newline
            bitfld.long 0x00 0. "DETECTION_ENA_0,Interference detection enable" "0: Disabled,1: Enabled"
    group.long 0x2C++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_1_CH0,Interference detection control register"
            hexmask.long.word 0x00 16.--30. 1. "ABS_DIFF_THR_0,Defines the comparison threshold against Absolute differential value accumulator for interference detection.Unsigned value"
            newline
            hexmask.long.word 0x00 0.--13. 1. "ABS_THR_0,Defines the comparison threshold against Absolute value accumulator for interference detection"
    group.long 0x30++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_2_CH0,Interference detection control register"
            hexmask.long.word 0x00 16.--30. 1. "ABS_DIFF_PROG_MULT_0,Absolute differential value accumulator multiplicative factor"
            newline
            hexmask.long.word 0x00 0.--14. 1. "ABS_PROG_MULT_0,Absolute value accumulator multiplicative factor"
    group.long 0x34++0x03
        line.long 0x00 "IDM_POLLUTION_WEIGHTS_THR_CH0,Pollution weights threshold"
            bitfld.long 0x00 0.--3. "IDM_POLLUTION_WEIGHTS_THR_CH0,Comparison Threshold agains pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x38++0x03
        line.long 0x00 "IDM_POLLUTION_WEIGHTS_CH0,Interference detection Pollution weights"
            bitfld.long 0x00 24.--27. "IDM_POLLUTION_WEIGHTS_6_CH0,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 20.--23. "IDM_POLLUTION_WEIGHTS_5_CH0,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 16.--19. "IDM_POLLUTION_WEIGHTS_4_CH0,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 12.--15. "IDM_POLLUTION_WEIGHTS_3_CH0,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 8.--11. "IDM_POLLUTION_WEIGHTS_2_CH0,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 4.--7. "IDM_POLLUTION_WEIGHTS_1_CH0,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0.--3. "IDM_POLLUTION_WEIGHTS_0_CH0,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3C++0x03
        line.long 0x00 "IDM_MITIGATION_CONTROL_CH0,Interference mitigation control register"
            bitfld.long 0x00 8.--9. "ZERO_WINDOW_SIZE_0,Amount of samples on both sides of polluted samples zeroed when zeroing mitigation is applied" "0,1,2,3"
            newline
            bitfld.long 0x00 4. "MITIGATION_MODE_0,Pollutted region is affected depending on interference mitigation mode" "0: polluted samples and their boundaries are..,1: if the weight for each sample is greater than.."
            newline
            bitfld.long 0x00 0. "MITIGATION_BYP_0,Interference mitigation Bypass" "0: Disabled,1: Enabled"
    group.long 0x40++0x03
        line.long 0x00 "IDM_STAT_MEM_CTRL_CH0,Interference Statistic memory control register"
            bitfld.long 0x00 0. "STAT_MEM_LOG_ABS_ACCUM_0,Register field selects which accumulator is logged on idm statistic memory" "0: Differential absolute value accumulator..,1: Absolute value accumulator selected"
    group.long 0x44++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_0_CH0,DC estimation control register"
            bitfld.long 0x00 24. "DC_HARDCODED_THR_ENA_0,DC hardcoded threshold enable" "0: DC hardcoded threshold disable,1: DC hardcoded threshold enable"
            newline
            hexmask.long.word 0x00 8.--17. 1. "DC_ACCUM_PROG_MULT_0,DC accumulator multiplicative factor"
            newline
            bitfld.long 0x00 4.--6. "DC_ACCUM_PROG_SHIFT_0,Programable right shift applied to absolute value accumulator" "?,?,2: 1/64 factor applied to DC accumulator,3: 1/128 factor applied to DC accumulator,4: 1/256 factor applied to DC accumulator,5: 1/512 factor applied to DC accumulator,6: 1/1024 factor applied to DC accumulator,7: 1/2048 factor applied to DC accumulator"
            newline
            bitfld.long 0x00 0.--1. "DC_ESTIMATION_MODE_0,DC estimation enable" "0: DC estimation disabled,1: Chirp based DC estimation enabled,2: Frame based DC estimation enabled,?..."
    group.long 0x48++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_1_CH0,DC estimation control register"
            hexmask.long.word 0x00 16.--26. 1. "DC_ESTIMATION_N_SAMPLES_0,Amount of samples considered for DC estimation"
            newline
            hexmask.long.word 0x00 0.--10. 1. "DC_ESTIMATION_START_SAMPLE_0,DC estimation starting sample index within the chirp"
    group.long 0x4C++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_2_CH0,DC estimation control register"
            hexmask.long.word 0x00 8.--18. 1. "FRAME_DC_ACCUM_PROG_MULT_0,Frame DC accumulator multiplicative factor"
            newline
            bitfld.long 0x00 0.--3. "FRAME_DC_ACCUM_PROG_SHIFT_0,Programable right shift applied to absolute value accumulator" "0: 1/(64x64) factor applied to DC accumulator,1: 1/(64x128) factor applied to DC accumulator,2: 1/(64x256) factor applied to DC accumulator,3: 1/(64x512) factor applied to DC accumulator,4: 1/(64x1024) factor applied to DC accumulator,5: 1/(64x2048) factor applied to DC accumulator,6: 1/(128x2048) factor applied to DC accumulator,7: 1/(256x2048) factor applied to DC accumulator,8: 1/(512x2048) factor applied to DC accumulator,9: 1/(1024x2048) factor applied to DC accumulator,10: 1/(2048x2048) factor applied to DC accumulator,?..."
    group.long 0x50++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_3_CH0,DC estimation control register"
            hexmask.long.word 0x00 16.--26. 1. "FRAME_DC_ESTIMATION_N_FRAMES_0,amount of chirps considered for frame DC estimation"
            newline
            hexmask.long.word 0x00 0.--10. 1. "FRAME_DC_ESTIMATION_START_FRAME_0,Frame DC estimation starting chirp index within the frame"
    group.long 0x54++0x03
        line.long 0x00 "DC_COMPENSATION_CONTROL_0_CH0,DC compensation control register"
            bitfld.long 0x00 0. "DC_COMPENSATION_BYP_0,DC compensation bypass" "0: DC compensation active,1: DC compensation bypassed"
    group.long 0x58++0x03
        line.long 0x00 "DC_HARDCODED_THR_CH_0,DC hardcoded threshold"
            hexmask.long.word 0x00 0.--15. 1. "DC_HARDCODED_THR_CH_0,DC hardcoded threshold"

    rgroup.long 0x5C++0x03
        line.long 0x00 "MIPI_STATUS_0_CH1,Mipi d-phy 0 status register"
            bitfld.long 0x00 24.--25. "D1_BIST_ACTIVE,Output signal showing that the BIST test is active and running DY_BIST_ACTIVE[0]: Shows that the first LP entry command is received" "0,1,2,3"
            newline
            hexmask.long.word 0x00 8.--17. 1. "D1_BIST_ERR_CNT,Output bus that shows the number of failing words in case of having test failure"
            newline
            bitfld.long 0x00 4.--5. "D1_BIST_VALID,Output signal showing that the SYNC token is received and the data is valid: DY_BIST_VALID[0]: Shows that the first burst data is valid.DY_BIST_VALID[1]: Shows that the second burst data is valid" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--1. "D1_BIST_PASS,Two-bit signal showing the pass/fail test result.BIST_PASS[0]: Shows that the first HS burst has been received properly.BIST_PASS[1]: Shows that the Second HS burst has been received properly" "0,1,2,3"
    rgroup.long 0x60++0x03
        line.long 0x00 "MIPI_STATUS_1_CH1,Mipi d-phy 1 status register"
            hexmask.long.tbyte 0x00 0.--18. 1. "D1_BIST_WORD_CNT,Output bus that shows the number of words that have been sent in the BIST mode"

    group.long 0x64++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_0_CH1,Interference detection control register"
            bitfld.long 0x00 28. "FORWARD_INTERFERENCE_DETECTION_1,If asserted polluted binary marker for each sample is attached to sample value and shared with the rest of Soc" "0,1"
            newline
            bitfld.long 0x00 24.--25. "DETECTION_MODE_1,Sample will be marked as pollutted depending on interference detection mode" "0: The sample is marked as polluted if greater..,1: The sample is marked as polluted if greater..,2: The sample is marked as polluted if greater..,3: The sample is marked as polluted if greater.."
            newline
            bitfld.long 0x00 20. "SQUARE_ACCUM_SEL_1,Square value accumulator selector" "0: Absolute value accumulator selected,1: Square value accumulator selected"
            newline
            bitfld.long 0x00 16. "ABS_DIFF_SEL_1,Absolute differential value accumulator selector" "0: Hardcoded absolute differential value..,1: Absolute differential value accumulator.."
            newline
            bitfld.long 0x00 12. "ABS_SEL_1,Absolute value accumulator selector" "0: Hardcoded absolute value threshold selected,1: Absolute value accumulator selected"
            newline
            bitfld.long 0x00 8.--10. "ABS_DIFF_PROG_SHIFT_1,Programable right shift applied to absolute differential value accumulator" "?,?,2: 1/64 factor applied to absolute differential..,3: 1/128 factor applied to absolute differential..,4: 1/256 factor applied to absolute differential..,5: 1/512 factor applied to absolute differential..,6: 1/1024 factor applied to absolute..,7: 1/2048 factor applied to absolute.."
            newline
            bitfld.long 0x00 4.--6. "ABS_PROG_SHIFT_1,Programable right shift applied to absolute value accumulator" "?,?,2: 1/64 factor applied to absolute value..,3: 1/128 factor applied to absolute value..,4: 1/256 factor applied to absolute value..,5: 1/512 factor applied to absolute value..,6: 1/1024 factor applied to absolute value..,7: 1/2048 factor applied to absolute value.."
            newline
            bitfld.long 0x00 0. "DETECTION_ENA_1,Interference detection enable" "0: Disabled,1: Enabled"
    group.long 0x68++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_1_CH1,Interference detection control register"
            hexmask.long.word 0x00 16.--30. 1. "ABS_DIFF_THR_1,Defines the comparison threshold against Absolute differential value accumulator for interference detection.Unsigned value"
            newline
            hexmask.long.word 0x00 0.--13. 1. "ABS_THR_1,Defines the comparison threshold against Absolute value accumulator for interference detection"
    group.long 0x6C++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_2_CH1,Interference detection control register"
            hexmask.long.word 0x00 16.--30. 1. "ABS_DIFF_PROG_MULT_1,Absolute differential value accumulator multiplicative factor"
            newline
            hexmask.long.word 0x00 0.--14. 1. "ABS_PROG_MULT_1,Absolute value accumulator multiplicative factor"
    group.long 0x70++0x03
        line.long 0x00 "IDM_POLLUTION_WEIGHTS_THR_CH1,Pollution weights threshold"
            bitfld.long 0x00 0.--3. "IDM_POLLUTION_WEIGHTS_THR_CH1,Comparison Threshold agains pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x74++0x03
        line.long 0x00 "IDM_POLLUTION_WEIGHTS_CH1,Interference detection Pollution weights"
            bitfld.long 0x00 24.--27. "IDM_POLLUTION_WEIGHTS_6_CH1,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 20.--23. "IDM_POLLUTION_WEIGHTS_5_CH1,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 16.--19. "IDM_POLLUTION_WEIGHTS_4_CH1,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 12.--15. "IDM_POLLUTION_WEIGHTS_3_CH1,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 8.--11. "IDM_POLLUTION_WEIGHTS_2_CH1,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 4.--7. "IDM_POLLUTION_WEIGHTS_1_CH1,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0.--3. "IDM_POLLUTION_WEIGHTS_0_CH1,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x78++0x03
        line.long 0x00 "IDM_MITIGATION_CONTROL_CH1,Interference mitigation control register"
            bitfld.long 0x00 8.--9. "ZERO_WINDOW_SIZE_1,Amount of samples on both sides of polluted samples zeroed when zeroing mitigation is applied" "0,1,2,3"
            newline
            bitfld.long 0x00 4. "MITIGATION_MODE_1,Pollutted region is affected depending on interference mitigation mode" "0: polluted samples and their boundaries are..,1: if the weight for each sample is greater than.."
            newline
            bitfld.long 0x00 0. "MITIGATION_BYP_1,Interference mitigation Bypass" "0: Disabled,1: Enabled"
    group.long 0x7C++0x03
        line.long 0x00 "IDM_STAT_MEM_CTRL_CH1,Interference Statistic memory control register"
            bitfld.long 0x00 0. "STAT_MEM_LOG_ABS_ACCUM_1,Register field selects which accumulator is logged on idm statistic memory" "0: Differential absolute value accumulator..,1: Absolute value accumulator selected"
    group.long 0x80++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_0_CH1,DC estimation control register"
            bitfld.long 0x00 24. "DC_HARDCODED_THR_ENA_1,DC hardcoded threshold enable" "0: DC hardcoded threshold disable,1: DC hardcoded threshold enable"
            newline
            hexmask.long.word 0x00 8.--17. 1. "DC_ACCUM_PROG_MULT_1,DC accumulator multiplicative factor"
            newline
            bitfld.long 0x00 4.--6. "DC_ACCUM_PROG_SHIFT_1,Programable right shift applied to absolute value accumulator" "?,?,2: 1/64 factor applied to DC accumulator,3: 1/128 factor applied to DC accumulator,4: 1/256 factor applied to DC accumulator,5: 1/512 factor applied to DC accumulator,6: 1/1024 factor applied to DC accumulator,7: 1/2048 factor applied to DC accumulator"
            newline
            bitfld.long 0x00 0.--1. "DC_ESTIMATION_MODE_1,DC estimation enable" "0: DC estimation disabled,1: Chirp based DC estimation enabled,2: Frame based DC estimation enabled,?..."
    group.long 0x84++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_1_CH1,DC estimation control register"
            hexmask.long.word 0x00 16.--26. 1. "DC_ESTIMATION_N_SAMPLES_1,Amount of samples considered for DC estimation"
            newline
            hexmask.long.word 0x00 0.--10. 1. "DC_ESTIMATION_START_SAMPLE_1,DC estimation starting sample index within the chirp"
    group.long 0x88++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_2_CH1,DC estimation control register"
            hexmask.long.word 0x00 8.--18. 1. "FRAME_DC_ACCUM_PROG_MULT_1,Frame DC accumulator multiplicative factor"
            newline
            bitfld.long 0x00 0.--3. "FRAME_DC_ACCUM_PROG_SHIFT_1,Programable right shift applied to absolute value accumulator" "0: 1/(64x64) factor applied to DC accumulator,1: 1/(64x128) factor applied to DC accumulator,2: 1/(64x256) factor applied to DC accumulator,3: 1/(64x512) factor applied to DC accumulator,4: 1/(64x1024) factor applied to DC accumulator,5: 1/(64x2048) factor applied to DC accumulator,6: 1/(128x2048) factor applied to DC accumulator,7: 1/(256x2048) factor applied to DC accumulator,8: 1/(512x2048) factor applied to DC accumulator,9: 1/(1024x2048) factor applied to DC accumulator,10: 1/(2048x2048) factor applied to DC accumulator,?..."
    group.long 0x8C++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_3_CH1,DC estimation control register"
            hexmask.long.word 0x00 16.--26. 1. "FRAME_DC_ESTIMATION_N_FRAMES_1,amount of chirps considered for frame DC estimation"
            newline
            hexmask.long.word 0x00 0.--10. 1. "FRAME_DC_ESTIMATION_START_FRAME_1,Frame DC estimation starting chirp index within the frame"
    group.long 0x90++0x03
        line.long 0x00 "DC_COMPENSATION_CONTROL_0_CH1,DC compensation control register"
            bitfld.long 0x00 0. "DC_COMPENSATION_BYP_1,DC compensation bypass" "0: DC compensation active,1: DC compensation bypassed"
    group.long 0x94++0x03
        line.long 0x00 "DC_HARDCODED_THR_CH_1,DC hardcoded threshold"
            hexmask.long.word 0x00 0.--15. 1. "DC_HARDCODED_THR_CH_1,DC hardcoded threshold"

    rgroup.long 0x98++0x03
        line.long 0x00 "MIPI_STATUS_0_CH2,Mipi d-phy 0 status register"
            bitfld.long 0x00 24.--25. "D2_BIST_ACTIVE,Output signal showing that the BIST test is active and running DY_BIST_ACTIVE[0]: Shows that the first LP entry command is received" "0,1,2,3"
            newline
            hexmask.long.word 0x00 8.--17. 1. "D2_BIST_ERR_CNT,Output bus that shows the number of failing words in case of having test failure"
            newline
            bitfld.long 0x00 4.--5. "D2_BIST_VALID,Output signal showing that the SYNC token is received and the data is valid: DY_BIST_VALID[0]: Shows that the first burst data is valid.DY_BIST_VALID[1]: Shows that the second burst data is valid" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--1. "D2_BIST_PASS,Two-bit signal showing the pass/fail test result.BIST_PASS[0]: Shows that the first HS burst has been received properly.BIST_PASS[1]: Shows that the Second HS burst has been received properly" "0,1,2,3"
    rgroup.long 0x9C++0x03
        line.long 0x00 "MIPI_STATUS_1_CH2,Mipi d-phy 1 status register"
            hexmask.long.tbyte 0x00 0.--18. 1. "D2_BIST_WORD_CNT,Output bus that shows the number of words that have been sent in the BIST mode"

    group.long 0xA0++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_0_CH2,Interference detection control register"
            bitfld.long 0x00 28. "FORWARD_INTERFERENCE_DETECTION_2,If asserted polluted binary marker for each sample is attached to sample value and shared with the rest of Soc" "0,1"
            newline
            bitfld.long 0x00 24.--25. "DETECTION_MODE_2,Sample will be marked as pollutted depending on interference detection mode" "0: The sample is marked as polluted if greater..,1: The sample is marked as polluted if greater..,2: The sample is marked as polluted if greater..,3: The sample is marked as polluted if greater.."
            newline
            bitfld.long 0x00 20. "SQUARE_ACCUM_SEL_2,Square value accumulator selector" "0: Absolute value accumulator selected,1: Square value accumulator selected"
            newline
            bitfld.long 0x00 16. "ABS_DIFF_SEL_2,Absolute differential value accumulator selector" "0: Hardcoded absolute differential value..,1: Absolute differential value accumulator.."
            newline
            bitfld.long 0x00 12. "ABS_SEL_2,Absolute value accumulator selector" "0: Hardcoded absolute value threshold selected,1: Absolute value accumulator selected"
            newline
            bitfld.long 0x00 8.--10. "ABS_DIFF_PROG_SHIFT_2,Programable right shift applied to absolute differential value accumulator" "?,?,2: 1/64 factor applied to absolute differential..,3: 1/128 factor applied to absolute differential..,4: 1/256 factor applied to absolute differential..,5: 1/512 factor applied to absolute differential..,6: 1/1024 factor applied to absolute..,7: 1/2048 factor applied to absolute.."
            newline
            bitfld.long 0x00 4.--6. "ABS_PROG_SHIFT_2,Programable right shift applied to absolute value accumulator" "?,?,2: 1/64 factor applied to absolute value..,3: 1/128 factor applied to absolute value..,4: 1/256 factor applied to absolute value..,5: 1/512 factor applied to absolute value..,6: 1/1024 factor applied to absolute value..,7: 1/2048 factor applied to absolute value.."
            newline
            bitfld.long 0x00 0. "DETECTION_ENA_2,Interference detection enable" "0: Disabled,1: Enabled"
    group.long 0xA4++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_1_CH2,Interference detection control register"
            hexmask.long.word 0x00 16.--30. 1. "ABS_DIFF_THR_2,Defines the comparison threshold against Absolute differential value accumulator for interference detection.Unsigned value"
            newline
            hexmask.long.word 0x00 0.--13. 1. "ABS_THR_2,Defines the comparison threshold against Absolute value accumulator for interference detection"
    group.long 0xA8++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_2_CH2,Interference detection control register"
            hexmask.long.word 0x00 16.--30. 1. "ABS_DIFF_PROG_MULT_2,Absolute differential value accumulator multiplicative factor"
            newline
            hexmask.long.word 0x00 0.--14. 1. "ABS_PROG_MULT_2,Absolute value accumulator multiplicative factor"
    group.long 0xAC++0x03
        line.long 0x00 "IDM_POLLUTION_WEIGHTS_THR_CH2,Pollution weights threshold"
            bitfld.long 0x00 0.--3. "IDM_POLLUTION_WEIGHTS_THR_CH2,Comparison Threshold agains pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0xB0++0x03
        line.long 0x00 "IDM_POLLUTION_WEIGHTS_CH2,Interference detection Pollution weights"
            bitfld.long 0x00 24.--27. "IDM_POLLUTION_WEIGHTS_6_CH2,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 20.--23. "IDM_POLLUTION_WEIGHTS_5_CH2,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 16.--19. "IDM_POLLUTION_WEIGHTS_4_CH2,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 12.--15. "IDM_POLLUTION_WEIGHTS_3_CH2,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 8.--11. "IDM_POLLUTION_WEIGHTS_2_CH2,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 4.--7. "IDM_POLLUTION_WEIGHTS_1_CH2,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0.--3. "IDM_POLLUTION_WEIGHTS_0_CH2,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0xB4++0x03
        line.long 0x00 "IDM_MITIGATION_CONTROL_CH2,Interference mitigation control register"
            bitfld.long 0x00 8.--9. "ZERO_WINDOW_SIZE_2,Amount of samples on both sides of polluted samples zeroed when zeroing mitigation is applied" "0,1,2,3"
            newline
            bitfld.long 0x00 4. "MITIGATION_MODE_2,Pollutted region is affected depending on interference mitigation mode" "0: polluted samples and their boundaries are..,1: if the weight for each sample is greater than.."
            newline
            bitfld.long 0x00 0. "MITIGATION_BYP_2,Interference mitigation Bypass" "0: Disabled,1: Enabled"
    group.long 0xB8++0x03
        line.long 0x00 "IDM_STAT_MEM_CTRL_CH2,Interference Statistic memory control register"
            bitfld.long 0x00 0. "STAT_MEM_LOG_ABS_ACCUM_2,Register field selects which accumulator is logged on idm statistic memory" "0: Differential absolute value accumulator..,1: Absolute value accumulator selected"
    group.long 0xBC++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_0_CH2,DC estimation control register"
            bitfld.long 0x00 24. "DC_HARDCODED_THR_ENA_2,DC hardcoded threshold enable" "0: DC hardcoded threshold disable,1: DC hardcoded threshold enable"
            newline
            hexmask.long.word 0x00 8.--17. 1. "DC_ACCUM_PROG_MULT_2,DC accumulator multiplicative factor"
            newline
            bitfld.long 0x00 4.--6. "DC_ACCUM_PROG_SHIFT_2,Programable right shift applied to absolute value accumulator" "?,?,2: 1/64 factor applied to DC accumulator,3: 1/128 factor applied to DC accumulator,4: 1/256 factor applied to DC accumulator,5: 1/512 factor applied to DC accumulator,6: 1/1024 factor applied to DC accumulator,7: 1/2048 factor applied to DC accumulator"
            newline
            bitfld.long 0x00 0.--1. "DC_ESTIMATION_MODE_2,DC estimation enable" "0: DC estimation disabled,1: Chirp based DC estimation enabled,2: Frame based DC estimation enabled,?..."
    group.long 0xC0++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_1_CH2,DC estimation control register"
            hexmask.long.word 0x00 16.--26. 1. "DC_ESTIMATION_N_SAMPLES_2,Amount of samples considered for DC estimation"
            newline
            hexmask.long.word 0x00 0.--10. 1. "DC_ESTIMATION_START_SAMPLE_2,DC estimation starting sample index within the chirp"
    group.long 0xC4++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_2_CH2,DC estimation control register"
            hexmask.long.word 0x00 8.--18. 1. "FRAME_DC_ACCUM_PROG_MULT_2,Frame DC accumulator multiplicative factor"
            newline
            bitfld.long 0x00 0.--3. "FRAME_DC_ACCUM_PROG_SHIFT_2,Programable right shift applied to absolute value accumulator" "0: 1/(64x64) factor applied to DC accumulator,1: 1/(64x128) factor applied to DC accumulator,2: 1/(64x256) factor applied to DC accumulator,3: 1/(64x512) factor applied to DC accumulator,4: 1/(64x1024) factor applied to DC accumulator,5: 1/(64x2048) factor applied to DC accumulator,6: 1/(128x2048) factor applied to DC accumulator,7: 1/(256x2048) factor applied to DC accumulator,8: 1/(512x2048) factor applied to DC accumulator,9: 1/(1024x2048) factor applied to DC accumulator,10: 1/(2048x2048) factor applied to DC accumulator,?..."
    group.long 0xC8++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_3_CH2,DC estimation control register"
            hexmask.long.word 0x00 16.--26. 1. "FRAME_DC_ESTIMATION_N_FRAMES_2,amount of chirps considered for frame DC estimation"
            newline
            hexmask.long.word 0x00 0.--10. 1. "FRAME_DC_ESTIMATION_START_FRAME_2,Frame DC estimation starting chirp index within the frame"
    group.long 0xCC++0x03
        line.long 0x00 "DC_COMPENSATION_CONTROL_0_CH2,DC compensation control register"
            bitfld.long 0x00 0. "DC_COMPENSATION_BYP_2,DC compensation bypass" "0: DC compensation active,1: DC compensation bypassed"
    group.long 0xD0++0x03
        line.long 0x00 "DC_HARDCODED_THR_CH_2,DC hardcoded threshold"
            hexmask.long.word 0x00 0.--15. 1. "DC_HARDCODED_THR_CH_2,DC hardcoded threshold"

    rgroup.long 0xD4++0x03
        line.long 0x00 "MIPI_STATUS_0_CH3,Mipi d-phy 0 status register"
            bitfld.long 0x00 24.--25. "D3_BIST_ACTIVE,Output signal showing that the BIST test is active and running DY_BIST_ACTIVE[0]: Shows that the first LP entry command is received" "0,1,2,3"
            newline
            hexmask.long.word 0x00 8.--17. 1. "D3_BIST_ERR_CNT,Output bus that shows the number of failing words in case of having test failure"
            newline
            bitfld.long 0x00 4.--5. "D3_BIST_VALID,Output signal showing that the SYNC token is received and the data is valid: DY_BIST_VALID[0]: Shows that the first burst data is valid.DY_BIST_VALID[1]: Shows that the second burst data is valid" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--1. "D3_BIST_PASS,Two-bit signal showing the pass/fail test result.BIST_PASS[0]: Shows that the first HS burst has been received properly.BIST_PASS[1]: Shows that the Second HS burst has been received properly" "0,1,2,3"
    rgroup.long 0xD8++0x03
        line.long 0x00 "MIPI_STATUS_1_CH3,Mipi d-phy 1 status register"
            hexmask.long.tbyte 0x00 0.--18. 1. "D3_BIST_WORD_CNT,Output bus that shows the number of words that have been sent in the BIST mode"

    group.long 0xDC++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_0_CH3,Interference detection control register"
            bitfld.long 0x00 28. "FORWARD_INTERFERENCE_DETECTION_3,If asserted polluted binary marker for each sample is attached to sample value and shared with the rest of Soc" "0,1"
            newline
            bitfld.long 0x00 24.--25. "DETECTION_MODE_3,Sample will be marked as pollutted depending on interference detection mode" "0: The sample is marked as polluted if greater..,1: The sample is marked as polluted if greater..,2: The sample is marked as polluted if greater..,3: The sample is marked as polluted if greater.."
            newline
            bitfld.long 0x00 20. "SQUARE_ACCUM_SEL_3,Square value accumulator selector" "0: Absolute value accumulator selected,1: Square value accumulator selected"
            newline
            bitfld.long 0x00 16. "ABS_DIFF_SEL_3,Absolute differential value accumulator selector" "0: Hardcoded absolute differential value..,1: Absolute differential value accumulator.."
            newline
            bitfld.long 0x00 12. "ABS_SEL_3,Absolute value accumulator selector" "0: Hardcoded absolute value threshold selected,1: Absolute value accumulator selected"
            newline
            bitfld.long 0x00 8.--10. "ABS_DIFF_PROG_SHIFT_3,Programable right shift applied to absolute differential value accumulator" "?,?,2: 1/64 factor applied to absolute differential..,3: 1/128 factor applied to absolute differential..,4: 1/256 factor applied to absolute differential..,5: 1/512 factor applied to absolute differential..,6: 1/1024 factor applied to absolute..,7: 1/2048 factor applied to absolute.."
            newline
            bitfld.long 0x00 4.--6. "ABS_PROG_SHIFT_3,Programable right shift applied to absolute value accumulator" "?,?,2: 1/64 factor applied to absolute value..,3: 1/128 factor applied to absolute value..,4: 1/256 factor applied to absolute value..,5: 1/512 factor applied to absolute value..,6: 1/1024 factor applied to absolute value..,7: 1/2048 factor applied to absolute value.."
            newline
            bitfld.long 0x00 0. "DETECTION_ENA_3,Interference detection enable" "0: Disabled,1: Enabled"
    group.long 0xE0++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_1_CH3,Interference detection control register"
            hexmask.long.word 0x00 16.--30. 1. "ABS_DIFF_THR_3,Defines the comparison threshold against Absolute differential value accumulator for interference detection.Unsigned value"
            newline
            hexmask.long.word 0x00 0.--13. 1. "ABS_THR_3,Defines the comparison threshold against Absolute value accumulator for interference detection"
    group.long 0xE4++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_2_CH3,Interference detection control register"
            hexmask.long.word 0x00 16.--30. 1. "ABS_DIFF_PROG_MULT_3,Absolute differential value accumulator multiplicative factor"
            newline
            hexmask.long.word 0x00 0.--14. 1. "ABS_PROG_MULT_3,Absolute value accumulator multiplicative factor"
    group.long 0xE8++0x03
        line.long 0x00 "IDM_POLLUTION_WEIGHTS_THR_CH3,Pollution weights threshold"
            bitfld.long 0x00 0.--3. "IDM_POLLUTION_WEIGHTS_THR_CH3,Comparison Threshold agains pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0xEC++0x03
        line.long 0x00 "IDM_POLLUTION_WEIGHTS_CH3,Interference detection Pollution weights"
            bitfld.long 0x00 24.--27. "IDM_POLLUTION_WEIGHTS_6_CH3,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 20.--23. "IDM_POLLUTION_WEIGHTS_5_CH3,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 16.--19. "IDM_POLLUTION_WEIGHTS_4_CH3,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 12.--15. "IDM_POLLUTION_WEIGHTS_3_CH3,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 8.--11. "IDM_POLLUTION_WEIGHTS_2_CH3,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 4.--7. "IDM_POLLUTION_WEIGHTS_1_CH3,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0.--3. "IDM_POLLUTION_WEIGHTS_0_CH3,Pollution sample weight.Only applicable when MITIGATION_MODE=1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0xF0++0x03
        line.long 0x00 "IDM_MITIGATION_CONTROL_CH3,Interference mitigation control register"
            bitfld.long 0x00 8.--9. "ZERO_WINDOW_SIZE_3,Amount of samples on both sides of polluted samples zeroed when zeroing mitigation is applied" "0,1,2,3"
            newline
            bitfld.long 0x00 4. "MITIGATION_MODE_3,Pollutted region is affected depending on interference mitigation mode" "0: polluted samples and their boundaries are..,1: if the weight for each sample is greater than.."
            newline
            bitfld.long 0x00 0. "MITIGATION_BYP_3,Interference mitigation Bypass" "0: Disabled,1: Enabled"
    group.long 0xF4++0x03
        line.long 0x00 "IDM_STAT_MEM_CTRL_CH3,Interference Statistic memory control register"
            bitfld.long 0x00 0. "STAT_MEM_LOG_ABS_ACCUM_3,Register field selects which accumulator is logged on idm statistic memory" "0: Differential absolute value accumulator..,1: Absolute value accumulator selected"
    group.long 0xF8++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_0_CH3,DC estimation control register"
            bitfld.long 0x00 24. "DC_HARDCODED_THR_ENA_3,DC hardcoded threshold enable" "0: DC hardcoded threshold disable,1: DC hardcoded threshold enable"
            newline
            hexmask.long.word 0x00 8.--17. 1. "DC_ACCUM_PROG_MULT_3,DC accumulator multiplicative factor"
            newline
            bitfld.long 0x00 4.--6. "DC_ACCUM_PROG_SHIFT_3,Programable right shift applied to absolute value accumulator" "?,?,2: 1/64 factor applied to DC accumulator,3: 1/128 factor applied to DC accumulator,4: 1/256 factor applied to DC accumulator,5: 1/512 factor applied to DC accumulator,6: 1/1024 factor applied to DC accumulator,7: 1/2048 factor applied to DC accumulator"
            newline
            bitfld.long 0x00 0.--1. "DC_ESTIMATION_MODE_3,DC estimation enable" "0: DC estimation disabled,1: Chirp based DC estimation enabled,2: Frame based DC estimation enabled,?..."
    group.long 0xFC++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_1_CH3,DC estimation control register"
            hexmask.long.word 0x00 16.--26. 1. "DC_ESTIMATION_N_SAMPLES_3,Amount of samples considered for DC estimation"
            newline
            hexmask.long.word 0x00 0.--10. 1. "DC_ESTIMATION_START_SAMPLE_3,DC estimation starting sample index within the chirp"
    group.long 0x100++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_2_CH3,DC estimation control register"
            hexmask.long.word 0x00 8.--18. 1. "FRAME_DC_ACCUM_PROG_MULT_3,Frame DC accumulator multiplicative factor"
            newline
            bitfld.long 0x00 0.--3. "FRAME_DC_ACCUM_PROG_SHIFT_3,Programable right shift applied to absolute value accumulator" "0: 1/(64x64) factor applied to DC accumulator,1: 1/(64x128) factor applied to DC accumulator,2: 1/(64x256) factor applied to DC accumulator,3: 1/(64x512) factor applied to DC accumulator,4: 1/(64x1024) factor applied to DC accumulator,5: 1/(64x2048) factor applied to DC accumulator,6: 1/(128x2048) factor applied to DC accumulator,7: 1/(256x2048) factor applied to DC accumulator,8: 1/(512x2048) factor applied to DC accumulator,9: 1/(1024x2048) factor applied to DC accumulator,10: 1/(2048x2048) factor applied to DC accumulator,?..."
    group.long 0x104++0x03
        line.long 0x00 "DC_ESTIMATION_CONTROL_3_CH3,DC estimation control register"
            hexmask.long.word 0x00 16.--26. 1. "FRAME_DC_ESTIMATION_N_FRAMES_3,amount of chirps considered for frame DC estimation"
            newline
            hexmask.long.word 0x00 0.--10. 1. "FRAME_DC_ESTIMATION_START_FRAME_3,Frame DC estimation starting chirp index within the frame"
    group.long 0x108++0x03
        line.long 0x00 "DC_COMPENSATION_CONTROL_0_CH3,DC compensation control register"
            bitfld.long 0x00 0. "DC_COMPENSATION_BYP_3,DC compensation bypass" "0: DC compensation active,1: DC compensation bypassed"
    group.long 0x10C++0x03
        line.long 0x00 "DC_HARDCODED_THR_CH_3,DC hardcoded threshold"
            hexmask.long.word 0x00 0.--15. 1. "DC_HARDCODED_THR_CH_3,DC hardcoded threshold"
    group.long 0x110++0x03
        line.long 0x00 "CSR_META_FIFO_CTL,CSR_META_FIFO_CTL- Meta frames are sent to the Meta FIFO"
            bitfld.long 0x00 12. "CSR_META_FIFO_ACCIDENTAL_READ_PROT_DISABLE,Disable metadata fifo accidental read protection" "0,1"
            newline
            bitfld.long 0x00 8. "CSR_META_FLUSH_FIFO,Clears the META FIFO" "0,1"
            newline
            hexmask.long.byte 0x00 0.--6. 1. "CSR_META_FIFO_WATERMARK,Matadata fifo watermark"
    group.long 0x114++0x03
        line.long 0x00 "FETCH_FROM_FIFO_BURST,Fetch from metadata fifo burst length"
            bitfld.long 0x00 0.--1. "FETCH_FROM_FIFO_BURST,Fetch from fifo burst needs to be configured on each metadata fifo read access" "0: 32 bits access,1: 2 consecutive 32 bit accesses,2: 3 consecutive 32 bit accesses,3: 4 consecutive 32 bit accesses"

    rgroup.long 0x118++0x03
        line.long 0x00 "CSR_META_FIFO_STATUS,CSR_META_FIFO_STATUS - Meta frames are sent to the Meta FIFO"
            hexmask.long.byte 0x00 0.--6. 1. "CSR_META_FIFO_COUNT,Meta Fifo count value corresponds to number of words stored in the fifo"

    group.long 0x210++0x03
        line.long 0x00 "CSR_TEST_PATTERN_INTER_CHIRP_IDLE,CSR_TEST_PATTERN_INTER_CHIRP_IDLE"
            hexmask.long.word 0x00 0.--11. 1. "CSR_TEST_PATTERN_INTER_CHIRP_IDLE,TEST PATTERN Generator setting which determines the number of clock cycles (running at 500MHz) between successive chirps when test pattern generation enabled"
    group.long 0x214++0x03
        line.long 0x00 "FUSA_IRQ0_EN,Interrupt0 enable register"
            bitfld.long 0x00 28. "CSI2_ULPS_MARK_ACTIVE_EN_3,CSI2 ULPS Mark status on Data Lane 3" "0,1"
            newline
            bitfld.long 0x00 27. "CSI2_ULPS_MARK_ACTIVE_EN_2,CSI2 ULPS Mark status on Data Lane 2" "0,1"
            newline
            bitfld.long 0x00 26. "CSI2_ULPS_MARK_ACTIVE_EN_1,CSI2 ULPS Mark status on Data Lane 1" "0,1"
            newline
            bitfld.long 0x00 25. "CSI2_ULPS_MARK_ACTIVE_EN_0,CSI2 ULPS Mark status on Data Lane 0" "0,1"
            newline
            bitfld.long 0x00 24. "CSI2_ULPS_ACTIVE_EN_3,CSI2 ULPS Data Lane 3 active" "0,1"
            newline
            bitfld.long 0x00 23. "CSI2_ULPS_ACTIVE_EN_2,CSI2 ULPS Data Lane 2 active" "0,1"
            newline
            bitfld.long 0x00 22. "CSI2_ULPS_ACTIVE_EN_1,CSI2 ULPS Data Lane 1 active" "0,1"
            newline
            bitfld.long 0x00 21. "CSI2_ULPS_ACTIVE_EN_0,CSI2 ULPS Data Lane 0 active" "0,1"
            newline
            bitfld.long 0x00 20. "CSI2_ULPS_CLK_MARK_ACTIVE_EN,CSI2 ULPS mark status on CLK lane" "0,1"
            newline
            bitfld.long 0x00 19. "CSI2_ULPS_CLK_ACTIVE_EN,CSI2 ULPS CLK active" "0,1"
            newline
            bitfld.long 0x00 18. "CSI2_CMD_ECC_RECEIVED_EN_5,RESERVED" "0,1"
            newline
            bitfld.long 0x00 17. "CSI2_CMD_ECC_RECEIVED_EN_4,RESERVED" "0,1"
            newline
            bitfld.long 0x00 16. "CSI2_CMD_ECC_RECEIVED_EN_3,RESERVED" "0,1"
            newline
            bitfld.long 0x00 15. "CSI2_CMD_ECC_RECEIVED_EN_2,RESERVED" "0,1"
            newline
            bitfld.long 0x00 14. "CSI2_CMD_ECC_RECEIVED_EN_1,RESERVED" "0,1"
            newline
            bitfld.long 0x00 13. "CSI2_CMD_ECC_RECEIVED_EN_0,RESERVED" "0,1"
            newline
            bitfld.long 0x00 12. "CSI2_IP_PARITY_ERROR_EN,CSI2 CSR parity error" "0,1"
            newline
            bitfld.long 0x00 11. "CSI2_WATCHDOG_ERROR_EN,CSI2 watchdog error" "0,1"
            newline
            bitfld.long 0x00 10. "CSI2_INTERNAL_ERROR_EN,CSI2 internal error" "0,1"
            newline
            bitfld.long 0x00 9. "CSI2_BIST_ERROR_EN,CSI2 bist error" "0,1"
            newline
            bitfld.long 0x00 8. "CSI2_PARITY_ERROR_EN,CSI2 parity error" "0,1"
            newline
            bitfld.long 0x00 7. "CSI2_CRC_ERROR_EN,CSI2 crc error.IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 6. "CSI2_ECC_TWO_BIT_ERROR_EN,CSI2 ecc two bit error" "0,1"
            newline
            bitfld.long 0x00 5. "CSI2_ECC_ONE_BIT_ERROR_EN,CSI2 ecc one bit error" "0,1"
            newline
            bitfld.long 0x00 4. "CSI2_EXIT_HS_ERROR_EN,CSI2 exit_hs_error from PHY IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 3. "CSI2_UNSUPPORTED_DATA_TYPE_EN,CSI2 unsupported data type" "0,1"
            newline
            bitfld.long 0x00 2. "CSI2_FIFO_OVERFLOW_ERROR_EN,CSI2 internal fifo overflow" "0,1"
            newline
            bitfld.long 0x00 1. "CSR_STS_ERR_CHIRP_FRAME_NOT_CORRECT_EN,Not correct amount of Chirps per frame received" "0,1"
            newline
            bitfld.long 0x00 0. "CSR_STS_ERR_SYMBOLS_CHIRP_NOT_CORRECT_EN,Not correct amount of Symbols per chirp received in CSI2 long packets" "0,1"
    group.long 0x218++0x03
        line.long 0x00 "FUSA_IRQ1_EN,Interrupt1 enable register"
            bitfld.long 0x00 27.--30. "CSR_SRAM_UNDERFLOW_EN,CSI2 SRAM underflow IRQ Enable" "?,1: CSI2 SRAM underflow for RX ADC0 IRQ Enable,2: CSI2 SRAM underflow for RX ADC1 IRQ Enable,?,4: CSI2 SRAM underflow for RX ADC2 IRQ Enable,?,?,?,8: CSI2 SRAM underflow for RX ADC3 IRQ Enable,?..."
            newline
            bitfld.long 0x00 23.--26. "CSR_SRAM_OVERFLOW_EN,CSI2 SRAM overflow IRQ Enable" "?,1: CSI2 SRAM overflow for RX ADC0 IRQ Enable,2: CSI2 SRAM overflow for RX ADC1 IRQ Enable,?,4: CSI2 SRAM overflow for RX ADC2 IRQ Enable,?,?,?,8: CSI2 SRAM overflow for RX ADC3 IRQ Enable,?..."
            newline
            bitfld.long 0x00 22. "CSR_FRAME_CNT_INCORRECT_EN,RESERVED" "0,1"
            newline
            bitfld.long 0x00 21. "CSR_FRAME_END_ASSERTED_AT_WRONG_TIME_EN,FRAME MAL-FORMED asserted if Frame end seen when not expected - ie before eop of long packet or meta data IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 20. "CSR_END_OF_FRAME_NOT_SEEN_BEFORE_START_EN,FRAME MAL-FORMED asserted if start of next frame seen before end of frame IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 19. "CSR_META_FIFO_WATERMARK_BELOW_EN,CSR Meta data fifo watermark below IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 18. "CSR_META_FIFO_WATERMARK_EXCEEDED_EN,CSR Meta data fifo watermark exceeded IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 17. "CSR_META_FIFO_OVERFLOW_EN,CSR Meta data fifo overflow IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 16. "CSR_META_FIFO_FULL_EN,CSR Meta data fifo full IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 15. "CSR_META_FIFO_EMPTY_EN,CSR Meta data fifo empty IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 14. "CSR_META_READ_ERR_EN,Meta data fifo read error IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 13. "CSI2_IRQ_OUT_EN,CSI2 IP IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 12. "CSI2_DEVICE_CONFIGURED_EN,RESERVED" "0,1"
            newline
            bitfld.long 0x00 11. "CSI2_PPI_STOPSTATE_LN3_EN,RESERVED" "0,1"
            newline
            bitfld.long 0x00 10. "CSI2_PPI_STOPSTATE_LN2_EN,RESERVED" "0,1"
            newline
            bitfld.long 0x00 9. "CSI2_PPI_STOPSTATE_LN1_EN,RESERVED" "0,1"
            newline
            bitfld.long 0x00 8. "CSI2_PPI_STOPSTATE_LN0_EN,RESERVED" "0,1"
            newline
            bitfld.long 0x00 7. "CSI2_ALTCAL_ACTIVE_EN_3,RESERVED" "0,1"
            newline
            bitfld.long 0x00 6. "CSI2_ALTCAL_ACTIVE_EN_2,RESERVED" "0,1"
            newline
            bitfld.long 0x00 5. "CSI2_ALTCAL_ACTIVE_EN_1,RESERVED" "0,1"
            newline
            bitfld.long 0x00 4. "CSI2_ALTCAL_ACTIVE_EN_0,RESERVED" "0,1"
            newline
            bitfld.long 0x00 3. "CSI2_SKEWCAL_ACTIVE_EN_3,RESERVED" "0,1"
            newline
            bitfld.long 0x00 2. "CSI2_SKEWCAL_ACTIVE_EN_2,RESERVED" "0,1"
            newline
            bitfld.long 0x00 1. "CSI2_SKEWCAL_ACTIVE_EN_1,RESERVED" "0,1"
            newline
            bitfld.long 0x00 0. "CSI2_SKEWCAL_ACTIVE_EN_0,RESERVED" "0,1"
    group.long 0x21C++0x03
        line.long 0x00 "FUSA_IRQ2_EN,Interrupt2 enable register"
            bitfld.long 0x00 27. "APB_PSTRB_PARITY_ERROR_EN,APB interface pstrb parity error IRQ enable" "0,1"
            newline
            bitfld.long 0x00 26. "APB_PSEL_PARITY_ERROR_EN,APB interface psel parity error IRQ enable" "0,1"
            newline
            bitfld.long 0x00 25. "APB_PENABLE_PARITY_ERROR_EN,APB interface penable parity error IRQ enable" "0,1"
            newline
            bitfld.long 0x00 24. "APB_PCTRL_PARITY_ERROR_EN,APB interface pctrl parity error IRQ enable" "0,1"
            newline
            bitfld.long 0x00 23. "APB_PADDR_PARITY_ERROR_EN,APB interface paddr parity error IRQ enable" "0,1"
            newline
            bitfld.long 0x00 22. "APB_PWDATA_PARITY_ERROR_EN,APB interface pwdata parity error IRQ enable" "0,1"
            newline
            bitfld.long 0x00 21. "OCP_BYTEEN_PARITY_ERROR_EN,OCP interface byteen parity error IRQ enable" "0,1"
            newline
            bitfld.long 0x00 20. "OCP_DATA_PARITY_ERROR_EN,OCP interface data parity error IRQ enable" "0,1"
            newline
            bitfld.long 0x00 19. "OCP_COMMAND_PARITY_ERROR_EN,OCP interface command parity error IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 18. "OCP_ADDRESS_PARITY_ERROR_EN,OCP interface address parity IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 17. "IDM_STAT_MEM_ECC_DED_EN,Idm Stat Memory ECC DED error occurred.IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 16. "IDM_STAT_MEM_ECC_SEC_COUNT_EXCEEDED_EN,Idm Stat Memory ECC sec error count exceed CTL_ERR_SEC_LIM..IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 15. "PING_PONG_ECC_DED_EN,Ping Pong Buffer ECC DED error occurred" "0,1"
            newline
            bitfld.long 0x00 14. "PING_PONG_ECC_SEC_COUNT_EXCEEDED_EN,Ping Pong Buffer ECC sec error count exceed CTL_ERR_SEC_LIM.IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 13. "PING_PONG_UNDERFLOW_EN,Ping Pong Buffer Underflow IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 12. "PING_PONG_OVERFLOW_EN,Ping Pong Buffer Overflow IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 11. "CSR_STS_PARITY_ERROR_EN_3,CSI2 Pixel parity error on RX ADC 3 IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 10. "CSR_STS_PARITY_ERROR_EN_2,CSI2 Pixel parity error on RX ADC 2 IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 9. "CSR_STS_PARITY_ERROR_EN_1,CSI2 Pixel parity error on RX ADC 1 IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 8. "CSR_STS_PARITY_ERROR_EN_0,CSI2 Pixel parity error on RX ADC 0 IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 7. "CSR_STS_DED_EN_3,CSR CSI2 SRAM status DED (Double Error Detection) detected on RX ADC 3 IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 6. "CSR_STS_DED_EN_2,CSR CSI2 SRAM status DED (Double Error Detection) detected on RX ADC 2 IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 5. "CSR_STS_DED_EN_1,CSR CSI2 SRAM status DED (Double Error Detection) detected on RX ADC 1 IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 4. "CSR_STS_DED_EN_0,CSR CSI2 SRAM status DED (Double Error Detection) detected on RX ADC 0 IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 3. "CSR_STS_COUNT_EXCEEDED_EN_3,CSI2 SRAM ECC SEC count exceeded threshold for RX ADC 3 IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 2. "CSR_STS_COUNT_EXCEEDED_EN_2,CSI2 SRAM ECC SEC count exceeded threshold for RX ADC 2 IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 1. "CSR_STS_COUNT_EXCEEDED_EN_1,CSI2 SRAM ECC SEC count exceeded threshold for RX ADC 1 IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 0. "CSR_STS_COUNT_EXCEEDED_EN_0,CSI2 SRAM ECC SEC count exceeded threshold for RX ADC 0 IRQ Enable" "0,1"
    group.long 0x220++0x03
        line.long 0x00 "FUSA_IRQ0_FLAG,Interrupt flag register"
            bitfld.long 0x00 29. "CSI2_ULPS_MARK_ACTIVE_FLAG_3,Receive Ultra Low Power State Mark status" "0,1"
            newline
            bitfld.long 0x00 28. "CSI2_ULPS_MARK_ACTIVE_FLAG_2,Receive Ultra Low Power State Mark status" "0,1"
            newline
            bitfld.long 0x00 27. "CSI2_ULPS_MARK_ACTIVE_FLAG_1,Receive Ultra Low Power State Mark status" "0,1"
            newline
            bitfld.long 0x00 26. "CSI2_ULPS_MARK_ACTIVE_FLAG_0,Receive Ultra Low Power State Mark status" "0,1"
            newline
            bitfld.long 0x00 25. "CSI2_ULPS_ACTIVE_FLAG_3,Receive Ultra Low Power State active" "0,1"
            newline
            bitfld.long 0x00 24. "CSI2_ULPS_ACTIVE_FLAG_2,Receive Ultra Low Power State active" "0,1"
            newline
            bitfld.long 0x00 23. "CSI2_ULPS_ACTIVE_FLAG_1,Receive Ultra Low Power State active" "0,1"
            newline
            bitfld.long 0x00 22. "CSI2_ULPS_ACTIVE_FLAG_0,Receive Ultra Low Power State active" "0,1"
            newline
            bitfld.long 0x00 20. "CSI2_ULPS_CLK_MARK_ACTIVE_FLAG,Receive Ultra Low Power State Mark status" "0,1"
            newline
            bitfld.long 0x00 19. "CSI2_ULPS_CLK_ACTIVE_FLAG,Receive Ultra Low Power State active for clock lane" "0,1"
            newline
            bitfld.long 0x00 18. "CSI2_CMD_ECC_RECEIVED_FLAG_5,RESERVED" "0,1"
            newline
            bitfld.long 0x00 17. "CSI2_CMD_ECC_RECEIVED_FLAG_4,RESERVED" "0,1"
            newline
            bitfld.long 0x00 16. "CSI2_CMD_ECC_RECEIVED_FLAG_3,RESERVED" "0,1"
            newline
            bitfld.long 0x00 15. "CSI2_CMD_ECC_RECEIVED_FLAG_2,RESERVED" "0,1"
            newline
            bitfld.long 0x00 14. "CSI2_CMD_ECC_RECEIVED_FLAG_1,RESERVED" "0,1"
            newline
            bitfld.long 0x00 13. "CSI2_CMD_ECC_RECEIVED_FLAG_0,RESERVED" "0,1"
            newline
            bitfld.long 0x00 12. "CSI2_IP_PARITY_ERROR_FLAG,CSRs registers are protected with a parity bit" "0,1"
            newline
            bitfld.long 0x00 11. "CSI2_WATCHDOG_ERROR_FLAG,Asserted if CSI2 watchdog timer runs out" "0,1"
            newline
            bitfld.long 0x00 10. "CSI2_INTERNAL_ERROR_FLAG,Asserted if an internal error occurs" "0,1"
            newline
            bitfld.long 0x00 9. "CSI2_BIST_ERROR_FLAG,Asserted if Built In Self Test (BIST) fails" "0,1"
            newline
            bitfld.long 0x00 8. "CSI2_PARITY_ERROR_FLAG,Asserted if parity generated off pixel outputs does not match internal parity calculation" "0,1"
            newline
            bitfld.long 0x00 7. "CSI2_CRC_ERROR_FLAG,Assertted when the CRC calculated on the received data does not match the CRC the transmitter sent at the end of the packet" "0,1"
            newline
            bitfld.long 0x00 6. "CSI2_ECC_TWO_BIT_ERROR_FLAG,Two CSI2 packet header bit errors were detected and not corrected" "0,1"
            newline
            bitfld.long 0x00 5. "CSI2_ECC_ONE_BIT_ERROR_FLAG,Single bit error in the CSI2 packet header was detected and corrected" "0,1"
            newline
            bitfld.long 0x00 4. "CSI2_EXIT_HS_ERROR_FLAG,Asserted to indicate that the PHY has stopped high speed transmission before the number of required bytes have been received" "0,1"
            newline
            bitfld.long 0x00 3. "CSI2_UNSUPPORTED_DATA_TYPE_FLAG,If CSI2 is configured to only support a subset of the CSI-2 packet data types and the received packet does not match one ofthe supported data types this error will be asserted" "0,1"
            newline
            bitfld.long 0x00 2. "CSI2_FIFO_OVERFLOW_ERROR_FLAG,Asserted by CSi2 RX Core if internal FIFO overflows" "0,1"
            newline
            bitfld.long 0x00 1. "CSR_ERR_CHIRP_FRAME_NOT_CORRECT_FLAG,Not correct amount of Chirps per frame received" "0,1"
            newline
            bitfld.long 0x00 0. "CSR_ERR_SYMBOLS_CHIRP_NOT_CORRECT_FLAG,Not correct amount of Symbols per chirp received in CSI2 long packets" "0,1"
    group.long 0x224++0x03
        line.long 0x00 "FUSA_IRQ1_FLAG,Interrupt flag register"
            bitfld.long 0x00 28.--31. "CSR_SRAM_UNDERFLOW_FLAG,CSI2 SRAM underflow IRQ Flag asserted if CSI2 SRAM underflows in specific channel" "?,1: CSI2 SRAM underflow for RX ADC0 IRQ Flag,2: CSI2 SRAM underflow for RX ADC1 IRQ Flag,?,4: CSI2 SRAM underflow for RX ADC2 IRQ Flag,?,?,?,8: CSI2 SRAM underflow for RX ADC3 IRQ Flag,?..."
            newline
            bitfld.long 0x00 24.--27. "CSR_SRAM_OVERFLOW_FLAG,CSI2 SRAM overflow asserted if CSI2 SRAM overflows in specific channel" "?,1: CSI2 SRAM overflow for RX ADC0 IRQ Flag,2: CSI2 SRAM overflow for RX ADC1 IRQ Flag,?,4: CSI2 SRAM overflow for RX ADC2 IRQ Flag,?,?,?,8: CSI2 SRAM overflow for RX ADC3 IRQ Flag,?..."
            newline
            bitfld.long 0x00 22. "CSR_FRAME_CNT_INCORRECT_FLAG,RESERVED" "0,1"
            newline
            bitfld.long 0x00 21. "CSR_FRAME_END_ASSERTED_AT_WRONG_TIME_FLAG,FRAME MAL-FORMED asserted if Frame end seen when not expected - ie before eop of long packet or meta data" "0,1"
            newline
            bitfld.long 0x00 20. "CSR_END_OF_FRAME_NOT_SEEN_BEFORE_START_FLAG,FRAME MAL-FORMED asserted if start of next frame seen before end of frame" "0,1"
            newline
            bitfld.long 0x00 19. "CSR_META_FIFO_WATERMARK_BELOW_FLAG,META FIFO BELOW WATERMARK asserted when metadata fifo content is less than CSR_META_FIFO_WATERMARK" "0,1"
            newline
            bitfld.long 0x00 18. "CSR_META_FIFO_WATERMARK_EXCEEDED_FLAG,CSR Meta data fifo watermark exceeded asserted when meta data fifo is filled beyond CSR_META_FIFO_WATERMARK" "0,1"
            newline
            bitfld.long 0x00 17. "CSR_META_FIFO_OVERFLOW_FLAG,META FIFO OVERFLOW asserted when metadata packet is received and metadata fifo is already full" "0,1"
            newline
            bitfld.long 0x00 16. "CSR_META_FIFO_FULL_FLAG,META DATA FIFO FULL asserted when metadata fifo is full" "0,1"
            newline
            bitfld.long 0x00 15. "CSR_META_FIFO_EMPTY_FLAG,META DATA FIFO EMPTY asserted when metadata fifo is empty" "0,1"
            newline
            bitfld.long 0x00 14. "CSR_META_READ_ERR_FLAG,META DATA FIFO was read when there was no valid data to" "0,1"
            newline
            bitfld.long 0x00 13. "CSI2_IRQ_OUT_FLAG,CSI2 IP IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 12. "CSI2_DEVICE_CONFIGURED_FLAG,RESERVED" "0,1"
            newline
            bitfld.long 0x00 11. "CSI2_PPI_STOPSTATE_LN3_FLAG,RESERVED" "0,1"
            newline
            bitfld.long 0x00 10. "CSI2_PPI_STOPSTATE_LN2_FLAG,RESERVED" "0,1"
            newline
            bitfld.long 0x00 9. "CSI2_PPI_STOPSTATE_LN1_FLAG,RESERVED" "0,1"
            newline
            bitfld.long 0x00 8. "CSI2_PPI_STOPSTATE_LN0_FLAG,RESERVED" "0,1"
            newline
            bitfld.long 0x00 7. "CSI2_ALTCAL_ACTIVE_FLAG_3,RESERVED" "0,1"
            newline
            bitfld.long 0x00 6. "CSI2_ALTCAL_ACTIVE_FLAG_2,RESERVED" "0,1"
            newline
            bitfld.long 0x00 5. "CSI2_ALTCAL_ACTIVE_FLAG_1,RESERVED" "0,1"
            newline
            bitfld.long 0x00 4. "CSI2_ALTCAL_ACTIVE_FLAG_0,RESERVED" "0,1"
            newline
            bitfld.long 0x00 3. "CSI2_SKEWCAL_ACTIVE_FLAG_3,RESERVED" "0,1"
            newline
            bitfld.long 0x00 2. "CSI2_SKEWCAL_ACTIVE_FLAG_2,RESERVED" "0,1"
            newline
            bitfld.long 0x00 1. "CSI2_SKEWCAL_ACTIVE_FLAG_1,RESERVED" "0,1"
            newline
            bitfld.long 0x00 0. "CSI2_SKEWCAL_ACTIVE_FLAG_0,RESERVED" "0,1"
    group.long 0x228++0x03
        line.long 0x00 "FUSA_IRQ2_FLAG,Interrupt2 flag register"
            bitfld.long 0x00 27. "APB_PSTRB_PARITY_ERROR_FLAG,APB interface pstrb parity error flag" "0,1"
            newline
            bitfld.long 0x00 26. "APB_PSEL_PARITY_ERROR_FLAG,APB interface psel parity error flag" "0,1"
            newline
            bitfld.long 0x00 25. "APB_PENABLE_PARITY_ERROR_FLAG,APB interface penable parity error flag" "0,1"
            newline
            bitfld.long 0x00 24. "APB_PCTRL_PARITY_ERROR_FLAG,APB interface pctrl parity error flag" "0,1"
            newline
            bitfld.long 0x00 23. "APB_PADDR_PARITY_ERROR_FLAG,APB interface paddr parity error flag" "0,1"
            newline
            bitfld.long 0x00 22. "APB_PWDATA_PARITY_ERROR_FLAG,APB interface pwdata parity error flag" "0,1"
            newline
            bitfld.long 0x00 21. "OCP_BYTEEN_PARITY_ERROR_FLAG,OCP interface byteen parity error flag" "0,1"
            newline
            bitfld.long 0x00 20. "OCP_DATA_PARITY_ERROR_FLAG,OCP interface data parity error flag.Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 19. "OCP_COMMAND_PARITY_ERROR_FLAG,OCP interface command parity error flag.Can be read for status write a '1 to clear the flag" "0,1"
            newline
            bitfld.long 0x00 18. "OCP_ADDRESS_PARITY_ERROR_FLAG,OCP interface address parity error flag" "0,1"
            newline
            bitfld.long 0x00 17. "IDM_STAT_MEM_ECC_DED_FLAG,Idm Stat Memory ECC DED error occurred" "0,1"
            newline
            bitfld.long 0x00 16. "IDM_STAT_MEM_ECC_SEC_COUNT_EXCEEDED_FLAG,Idm Stat Memory ECC sec error count exceed CTL_ERR_SEC_LIM" "0,1"
            newline
            bitfld.long 0x00 15. "PING_PONG_ECC_DED_FLAG,Ping Pong Buffer ECC DED error occurred" "0,1"
            newline
            bitfld.long 0x00 14. "PING_PONG_ECC_SEC_COUNT_EXCEEDED_FLAG,Ping Pong Buffer ECC sec error count exceed CTL_ERR_SEC_LIM" "0,1"
            newline
            bitfld.long 0x00 13. "PING_PONG_UNDERFLOW_FLAG,Ping Pong Buffer Underflow IRQ flag" "0,1"
            newline
            bitfld.long 0x00 12. "PING_PONG_OVERFLOW_FLAG,Ping Pong Buffer Overflow IRQ flag" "0,1"
            newline
            bitfld.long 0x00 11. "CSR_STS_PARITY_ERROR_FLAG_3,CSI2 Pixel parity error on RX ADC 3 IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 10. "CSR_STS_PARITY_ERROR_FLAG_2,CSI2 Pixel parity error on RX ADC 2 IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 9. "CSR_STS_PARITY_ERROR_FLAG_1,CSI2 Pixel parity error on RX ADC 1 IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 8. "CSR_STS_PARITY_ERROR_FLAG_0,CSI2 Pixel parity error on RX ADC 0 IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 7. "CSR_STS_DED_FLAG_3,CSR CSI2 SRAM status DED (Double Error Detection) detected on RX ADC 3 IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 6. "CSR_STS_DED_FLAG_2,CSR CSI2 SRAM status DED (Double Error Detection) detected on RX ADC 2 IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 5. "CSR_STS_DED_FLAG_1,CSR CSI2 SRAM status DED (Double Error Detection) detected on RX ADC 1 IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 4. "CSR_STS_DED_FLAG_0,CSR CSI2 SRAM status DED (Double Error Detection) detected on RX ADC 0 IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 3. "CSR_STS_COUNT_EXCEEDED_FLAG_3,CSI2 SRAM ECC SEC -Single Error Correction - count has exceeded CSI2_SRAM_SEC_COUNT_THRESH for Rx ADC 3" "0,1"
            newline
            bitfld.long 0x00 2. "CSR_STS_COUNT_EXCEEDED_FLAG_2,CSI2 SRAM ECC SEC -Single Error Correction - count has exceeded CSI2_SRAM_SEC_COUNT_THRESH for Rx ADC 2" "0,1"
            newline
            bitfld.long 0x00 1. "CSR_STS_COUNT_EXCEEDED_FLAG_1,CSI2 SRAM ECC SEC -Single Error Correction - count has exceeded CSI2_SRAM_SEC_COUNT_THRESH for Rx ADC 1" "0,1"
            newline
            bitfld.long 0x00 0. "CSR_STS_COUNT_EXCEEDED_FLAG_0,CSI2 SRAM ECC SEC -Single Error Correction - count has exceeded CSI2_SRAM_SEC_COUNT_THRESH for Rx ADC 0" "0,1"
    group.long 0x22C++0x03
        line.long 0x00 "CHIRP_IRQ_EN,Chirp control Interrupt enable register"
            bitfld.long 0x00 8. "CHIRP_END_EN,Chirp end IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 0. "CHIRP_START_EN,Chirp start IRQ Enable" "0,1"
    group.long 0x230++0x03
        line.long 0x00 "CHIRP_IRQ_FLAG,Chirp control Interrupt flag register"
            bitfld.long 0x00 8. "CHIRP_END_FLAG,Chirp end IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 0. "CHIRP_START_FLAG,Chirp start IRQ Flag" "0,1"
    group.long 0x234++0x03
        line.long 0x00 "FRAME_IRQ_EN,Frame control Interrupt enable register"
            bitfld.long 0x00 8. "FRAME_END_EN,Frame end IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 0. "FRAME_START_EN,Frame start IRQ Enable" "0,1"
    group.long 0x238++0x03
        line.long 0x00 "FRAME_IRQ_FLAG,Frame control Interrupt flag register"
            bitfld.long 0x00 8. "FRAME_END_FLAG,Frame end IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 0. "FRAME_START_FLAG,Frame start IRQ Flag" "0,1"
    group.long 0x23C++0x03
        line.long 0x00 "CSI2_DEBUG_CHIRP_FRAME_IRQ_EN,CSI2_Interface Chirp control Interrupt enable register"
            bitfld.long 0x00 3. "CSI2_DEBUG_FRAME_END_EN,CSI2 interface Frame end IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 2. "CSI2_DEBUG_FRAME_START_EN,CSI2 interface Frame start IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 1. "CSI2_DEBUG_CHIRP_END_EN,CSI2 interface Chirp end IRQ Enable" "0,1"
            newline
            bitfld.long 0x00 0. "CSI2_DEBUG_CHIRP_START_EN,CSI2 interface Chirp start IRQ Enable" "0,1"
    group.long 0x240++0x03
        line.long 0x00 "CSI2_DEBUG_CHIRP_FRAME_IRQ_FLAG,CSI2 interface Chirp control Interrupt flag register"
            bitfld.long 0x00 3. "CSI2_DEBUG_FRAME_END_FLAG,CSI2 interface Frame end IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 2. "CSI2_DEBUG_FRAME_START_FLAG,CSI2 interface Frame start IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 1. "CSI2_DEBUG_CHIRP_END_FLAG,CSI2 interface Chirp end IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 0. "CSI2_DEBUG_CHIRP_START_FLAG,CSI2 interface Chirp start IRQ Flag" "0,1"
    group.long 0x244++0x03
        line.long 0x00 "CSI2_SHORT_PKT_HEADER,short pkt header vc and data type values"
            bitfld.long 0x00 14.--19. "CSI2_SHORT_PKT_END_DATA_TYPE,Short Packet end Data Type value - determines Vsync" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 10.--13. "CSI2_SHORT_PKT_END_VC,Short Packet end virtual channel value - determines Vsync" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 4.--9. "CSI2_SHORT_PKT_START_DATA_TYPE,Short Packet start Data Type value - determines Vsync" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0.--3. "CSI2_SHORT_PKT_START_VC,Short Packet start virtual channel value - determines Vsync" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x248++0x03
        line.long 0x00 "CSI2_LONG_PKT_HEADER,long pkt header vc and data type values"
            bitfld.long 0x00 20.--25. "CSI2_META_PKT_DATA_TYPE,Meta Packet Data Type value - determines meta packet" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--19. "CSI2_META_PKT_VC,Meta Packet virtual channel value - determines meta packet" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 4.--9. "CSI2_LONG_PKT_DATA_TYPE,Long Packet Data Type value - determines Hsync" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0.--3. "CSI2_LONG_PKT_VC,Long Packet virtual channel value - determines Hsync" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x24C++0x03
        line.long 0x00 "CSI2_RESET,DPHY-CSI2 interface reset register"
            bitfld.long 0x00 4. "CSR_CSI2_RX_PHY_RESET_N,CSI2 main reset -active low for phy" "0,1"
            newline
            bitfld.long 0x00 3. "CSR_CSI2_RX_BYTE_CLK_LN3_RESET_N,Lane 3 reset -active low for phy" "0,1"
            newline
            bitfld.long 0x00 2. "CSR_CSI2_RX_BYTE_CLK_LN2_RESET_N,Lane 2 reset -active low for phy" "0,1"
            newline
            bitfld.long 0x00 1. "CSR_CSI2_RX_BYTE_CLK_LN1_RESET_N,Lane 1 reset -active low for phy" "0,1"
            newline
            bitfld.long 0x00 0. "CSR_CSI2_RX_BYTE_CLK_LN0_RESET_N,Lane 0 reset -active low for phy" "0,1"

    rgroup.long 0x250++0x03
        line.long 0x00 "CSI2_ERROR,CSR CSI2 status"
            bitfld.long 0x00 0.--4. "CSR_STS_CSI2_ECC_ONE_BIT_ERROR_POS,Position of the correct single bit error in the packet header" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    rgroup.long 0x254++0x03
        line.long 0x00 "CSI2_PAYLOAD,CSR CSI2 status"
            hexmask.long.word 0x00 16.--31. 1. "CSR_STS_CSI2_PAYLOAD_CRC_RECEIVED,Received packet CRC at CSI2 interface"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CSR_STS_CSI2_PAYLOAD_CRC_CALCULATED,CRC internally computed at CSI2 interface"
    rgroup.long 0x258++0x03
        line.long 0x00 "CSI2_DEBUG_FRAME_CHIRP_COUNT,CSI2 interface debug frame and chirp counts"
            hexmask.long.word 0x00 16.--31. 1. "CSI2_DEBUG_TOTAL_CHIRP_COUNT,CSI2 interface debug total chirp count"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CSI2_DEBUG_TOTAL_FRAME_COUNT,CSI2 interface debug total frame count"
    rgroup.long 0x25C++0x03
        line.long 0x00 "CSI2_DEBUG_MISC_META_COUNT,CSI2 interface debug misc and meta counts"
            bitfld.long 0x00 20. "CSI2_DEBUG_TEST_PATTERN_REQ,CSI2 interface debug test pattern request" "0,1"
            newline
            bitfld.long 0x00 16.--18. "CSI2_DEBUG_CSI2_FSM,CSI2 interface debug FSM value" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CSI2_DEBUG_TOTAL_META_COUNT,CSI2 interface debug total meta count"

    group.long 0x260++0x03
        line.long 0x00 "RUN_PRBS_0,PRBS checker control register"
            bitfld.long 0x00 3. "CSR_CLEAR_CNT_CH_0,Clear internal error and cycle counters for channel 0" "0,1"
            newline
            bitfld.long 0x00 2. "CSR_SNAP_CNT_CH_0,Take a snapshot of Error and Cycle counters - can be a single cycle pulse for channel 0 Take a snapshot of Error and Cycle counters - can be a single-cycle pulse" "0,1"
            newline
            bitfld.long 0x00 1. "CSR_CONT_CHK_CH_0,Continue checking (from a stop state) for channel 0" "0,1"
            newline
            bitfld.long 0x00 0. "CSR_RUN_CHK_CH_0,Run PRBS checker for channel 0" "0,1"
    group.long 0x264++0x03
        line.long 0x00 "CSR_PRBS_CHECKER_0,PRBS CHECKER Programmable controls"
            bitfld.long 0x00 8.--9. "CSR_CTL_STOP_EN_CH_0,Enable Stopping based on either Error(bit[1]) or Cycle(bit[0]) counters for channel 0" "0,1,2,3"
            newline
            bitfld.long 0x00 4.--7. "CSR_CTL_LOCK_THR_CH_0,PRBS checker must receive 2^(CSR_CTL_LOCK_THR+1) error-free data samples to declare LOCK for channel 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 2. "CSR_CTL_PAR_SEL_CH_0,PRBS checker parallelism selector" "0: parallelism of,1: parallelism of 12"
            newline
            bitfld.long 0x00 0.--1. "CSR_CTL_POLY_SEL_CH_0,PRBS checker Select which CRC polynomial to use" "0: PRBS7,1: PRBS15,2: PRBS23,3: PRBS31- channel 0"
    group.long 0x268++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_STOP_THRESHOLD_0,PRBS CHECKER Stop on Error (total) threshold"
            hexmask.long 0x00 0.--30. 1. "CSR_CTL_STOP_ERR_CH_0,Stop on Error (total) threshold for channel 0"
    group.long 0x26C++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_MANTISSA_THRESHOLD_0,PRBS CHECKER Stop on Cycle Mantissa threshold"
            hexmask.long 0x00 0.--28. 1. "CSR_PRBS_CHECKER_CTL_STOP_CMAN_CH_0,Stop on Cycle Mantissa threshold for channel 0"
    group.long 0x270++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_MISC_CTRL_0,PRBS CHECKER misc control"
            bitfld.long 0x00 4. "CSR_CTL_CLEAR_SNAP_CH_0,RESERVED" "0,1"
            newline
            bitfld.long 0x00 0.--2. "CSR_CTL_STOP_CEXP_CH_0,Stop on Cycle Exponent threshold for channel 0" "0,1,2,3,4,5,6,7"

    rgroup.long 0x274++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_STATUS_0,PRBS CHECKER PRBS CHECKER Error count stats"
            bitfld.long 0x00 8.--10. "CSR_STS_CYC_EXP_CH_0,Cycle count Exponent for channel 0" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 7. "CSR_STS_ERRT_SAT_CH_0,Error Total saturation for channel 0" "0,1"
            newline
            bitfld.long 0x00 6. "CSR_STS_ERR1_SAT_CH_0,Error bad 1's saturation for channel 0" "0,1"
            newline
            bitfld.long 0x00 5. "CSR_STS_ERR0_SAT_CH_0,Error bad 0's saturation for channel 0" "0,1"
            newline
            bitfld.long 0x00 4. "CSR_STS_ALL0S_CH_0,Input data is all 0's" "0,1"
            newline
            bitfld.long 0x00 0.--3. "CSR_STS_STATE_CH_0,One-hot encoded state" "?,1: IDLE,2: RE,?,4: LOCK,?,?,?,8: STOP for,?..."
    rgroup.long 0x278++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_ERR0_CNT_0,PRBS CHECKER Error count for bad 0's"
            hexmask.long 0x00 0.--30. 1. "CSR_STS_ERR0_CNT_CH_0,Error count for bad 0's for channel 0"
    rgroup.long 0x27C++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_ERR1_CNT_0,PRBS CHECKER Error count for bad 1's"
            hexmask.long 0x00 0.--30. 1. "CSR_STS_ERR1_CNT_CH_0,Error count for bad 1's for channel 0"
    rgroup.long 0x280++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_ERRT_CNT_0,PRBS CHECKER Error count Total (sum of err0's and err1's)"
            hexmask.long 0x00 0.--30. 1. "CSR_STS_ERRT_CNT_CH_0,Error count Total (sum of err0's and err1's) for channel 0"
    rgroup.long 0x284++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_CYC_MAN_0,PRBS CHECKER Cycle count Mantissa"
            hexmask.long 0x00 0.--28. 1. "CSR_STS_CYC_MAN_CH_0,Cycle count Mantissa"

    group.long 0x288++0x03
        line.long 0x00 "CSR_TEST_PATTERN0_0,Test Pattern control0"
            bitfld.long 0x00 1.--2. "CSR_TEST_PATTERN_WAVEFORM_SEL_0," "0,1,2,3"
            newline
            bitfld.long 0x00 0. "CSR_TEST_PATTERN_EN_0,Enable test pattern generation instead of RX CSI-2 data" "0,1"
    group.long 0x28C++0x03
        line.long 0x00 "CSR_TEST_PATTERN1_0,Test Pattern control1"
            bitfld.long 0x00 24.--28. "CSR_TEST_PATTERN_SHIFT2_VALUE_0,Generated pattern scale factor shift value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 16.--20. "CSR_TEST_PATTERN_SHIFT1_VALUE_0,Generated pattern scale factor shift value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            hexmask.long.word 0x00 0.--10. 1. "CSR_TEST_PATTERN_THR_0,Threshold used for pulse pattern generation"
    group.long 0x290++0x03
        line.long 0x00 "CSR_TEST_PATTERN2_0,Test Pattern control2"
            hexmask.long.word 0x00 16.--31. 1. "CSR_TEST_PATTERN_OFFSET_0,Test pattern offset for generator counter"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CSR_TEST_PATTERN_STEP_0,Test pattern step for generator counter"
    group.long 0x294++0x03
        line.long 0x00 "CSI2_SRAM_SEC_CTRL_0,Single Error Correction Control"
            bitfld.long 0x00 17. "CSI2_SRAM_CLR_ECC_SEC_CNT_0,Toggle to '1' to clear SEC counter" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CSI2_SRAM_SEC_COUNT_THRESH_0,Single Error Correction count threshold"

    rgroup.long 0x298++0x03
        line.long 0x00 "CSI2_SRAM_ECC_ERROR_SEC_COUNT_0,Error single error correctoun count"
            hexmask.long.word 0x00 0.--15. 1. "CSI2_SRAM_ERROR_SEC_COUNT_0,CSI2 SRAM ECC - Error single error correction count for channel 0"

    group.long 0x29C++0x03
        line.long 0x00 "RUN_PRBS_1,PRBS checker control register"
            bitfld.long 0x00 3. "CSR_CLEAR_CNT_CH_1,Clear internal error and cycle counters for channel 1" "0,1"
            newline
            bitfld.long 0x00 2. "CSR_SNAP_CNT_CH_1,Take a snapshot of Error and Cycle counters - can be a single cycle pulse for channel 1 Take a snapshot of Error and Cycle counters - can be a single-cycle pulse" "0,1"
            newline
            bitfld.long 0x00 1. "CSR_CONT_CHK_CH_1,Continue checking (from a stop state) for channel 1" "0,1"
            newline
            bitfld.long 0x00 0. "CSR_RUN_CHK_CH_1,Run PRBS checker for channel 1" "0,1"
    group.long 0x2A0++0x03
        line.long 0x00 "CSR_PRBS_CHECKER_1,PRBS CHECKER Programmable controls"
            bitfld.long 0x00 8.--9. "CSR_CTL_STOP_EN_CH_1,Enable Stopping based on either Error(bit[1]) or Cycle(bit[0]) counters for channel 1" "0,1,2,3"
            newline
            bitfld.long 0x00 4.--7. "CSR_CTL_LOCK_THR_CH_1,PRBS checker must receive 2^(CSR_CTL_LOCK_THR+1) error-free data samples to declare LOCK for channel 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 2. "CSR_CTL_PAR_SEL_CH_1,PRBS checker parallelism selector" "0: parallelism of,1: parallelism of 12"
            newline
            bitfld.long 0x00 0.--1. "CSR_CTL_POLY_SEL_CH_1,PRBS checker Select which CRC polynomial to use" "0: PRBS7,1: PRBS15,2: PRBS23,3: PRBS31- channel 1"
    group.long 0x2A4++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_STOP_THRESHOLD_1,PRBS CHECKER Stop on Error (total) threshold"
            hexmask.long 0x00 0.--30. 1. "CSR_CTL_STOP_ERR_CH_1,Stop on Error (total) threshold for channel 1"
    group.long 0x2A8++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_MANTISSA_THRESHOLD_1,PRBS CHECKER Stop on Cycle Mantissa threshold"
            hexmask.long 0x00 0.--28. 1. "CSR_PRBS_CHECKER_CTL_STOP_CMAN_CH_1,Stop on Cycle Mantissa threshold for channel 1"
    group.long 0x2AC++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_MISC_CTRL_1,PRBS CHECKER misc control"
            bitfld.long 0x00 4. "CSR_CTL_CLEAR_SNAP_CH_1,RESERVED" "0,1"
            newline
            bitfld.long 0x00 0.--2. "CSR_CTL_STOP_CEXP_CH_1,Stop on Cycle Exponent threshold for channel 1" "0,1,2,3,4,5,6,7"

    rgroup.long 0x2B0++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_STATUS_1,PRBS CHECKER PRBS CHECKER Error count stats"
            bitfld.long 0x00 8.--10. "CSR_STS_CYC_EXP_CH_1,Cycle count Exponent for channel 1" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 7. "CSR_STS_ERRT_SAT_CH_1,Error Total saturation for channel 1" "0,1"
            newline
            bitfld.long 0x00 6. "CSR_STS_ERR1_SAT_CH_1,Error bad 1's saturation for channel 1" "0,1"
            newline
            bitfld.long 0x00 5. "CSR_STS_ERR0_SAT_CH_1,Error bad 0's saturation for channel 1" "0,1"
            newline
            bitfld.long 0x00 4. "CSR_STS_ALL0S_CH_1,Input data is all 0's" "0,1"
            newline
            bitfld.long 0x00 0.--3. "CSR_STS_STATE_CH_1,One-hot encoded state" "?,1: IDLE,2: RE,?,4: LOCK,?,?,?,8: STOP for,?..."
    rgroup.long 0x2B4++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_ERR0_CNT_1,PRBS CHECKER Error count for bad 0's"
            hexmask.long 0x00 0.--30. 1. "CSR_STS_ERR0_CNT_CH_1,Error count for bad 0's for channel 1"
    rgroup.long 0x2B8++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_ERR1_CNT_1,PRBS CHECKER Error count for bad 1's"
            hexmask.long 0x00 0.--30. 1. "CSR_STS_ERR1_CNT_CH_1,Error count for bad 1's for channel 1"
    rgroup.long 0x2BC++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_ERRT_CNT_1,PRBS CHECKER Error count Total (sum of err0's and err1's)"
            hexmask.long 0x00 0.--30. 1. "CSR_STS_ERRT_CNT_CH_1,Error count Total (sum of err0's and err1's) for channel 1"
    rgroup.long 0x2C0++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_CYC_MAN_1,PRBS CHECKER Cycle count Mantissa"
            hexmask.long 0x00 0.--28. 1. "CSR_STS_CYC_MAN_CH_1,Cycle count Mantissa"

    group.long 0x2C4++0x03
        line.long 0x00 "CSR_TEST_PATTERN0_1,Test Pattern control0"
            bitfld.long 0x00 1.--2. "CSR_TEST_PATTERN_WAVEFORM_SEL_1," "0,1,2,3"
            newline
            bitfld.long 0x00 0. "CSR_TEST_PATTERN_EN_1,Enable test pattern generation instead of RX CSI-2 data" "0,1"
    group.long 0x2C8++0x03
        line.long 0x00 "CSR_TEST_PATTERN1_1,Test Pattern control1"
            bitfld.long 0x00 24.--28. "CSR_TEST_PATTERN_SHIFT2_VALUE_1,Generated pattern scale factor shift value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 16.--20. "CSR_TEST_PATTERN_SHIFT1_VALUE_1,Generated pattern scale factor shift value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            hexmask.long.word 0x00 0.--10. 1. "CSR_TEST_PATTERN_THR_1,Threshold used for pulse pattern generation"
    group.long 0x2CC++0x03
        line.long 0x00 "CSR_TEST_PATTERN2_1,Test Pattern control2"
            hexmask.long.word 0x00 16.--31. 1. "CSR_TEST_PATTERN_OFFSET_1,Test pattern offset for generator counter"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CSR_TEST_PATTERN_STEP_1,Test pattern step for generator counter"
    group.long 0x2D0++0x03
        line.long 0x00 "CSI2_SRAM_SEC_CTRL_1,Single Error Correction Control"
            bitfld.long 0x00 17. "CSI2_SRAM_CLR_ECC_SEC_CNT_1,Toggle to '1' to clear SEC counter" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CSI2_SRAM_SEC_COUNT_THRESH_1,Single Error Correction count threshold"

    rgroup.long 0x2D4++0x03
        line.long 0x00 "CSI2_SRAM_ECC_ERROR_SEC_COUNT_1,Error single error correctoun count"
            hexmask.long.word 0x00 0.--15. 1. "CSI2_SRAM_ERROR_SEC_COUNT_1,CSI2 SRAM ECC - Error single error correction count for channel 1"

    group.long 0x2D8++0x03
        line.long 0x00 "RUN_PRBS_2,PRBS checker control register"
            bitfld.long 0x00 3. "CSR_CLEAR_CNT_CH_2,Clear internal error and cycle counters for channel 2" "0,1"
            newline
            bitfld.long 0x00 2. "CSR_SNAP_CNT_CH_2,Take a snapshot of Error and Cycle counters - can be a single cycle pulse for channel 2 Take a snapshot of Error and Cycle counters - can be a single-cycle pulse" "0,1"
            newline
            bitfld.long 0x00 1. "CSR_CONT_CHK_CH_2,Continue checking (from a stop state) for channel 2" "0,1"
            newline
            bitfld.long 0x00 0. "CSR_RUN_CHK_CH_2,Run PRBS checker for channel 2" "0,1"
    group.long 0x2DC++0x03
        line.long 0x00 "CSR_PRBS_CHECKER_2,PRBS CHECKER Programmable controls"
            bitfld.long 0x00 8.--9. "CSR_CTL_STOP_EN_CH_2,Enable Stopping based on either Error(bit[1]) or Cycle(bit[0]) counters for channel 2" "0,1,2,3"
            newline
            bitfld.long 0x00 4.--7. "CSR_CTL_LOCK_THR_CH_2,PRBS checker must receive 2^(CSR_CTL_LOCK_THR+1) error-free data samples to declare LOCK for channel 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 2. "CSR_CTL_PAR_SEL_CH_2,PRBS checker parallelism selector" "0: parallelism of,1: parallelism of 12"
            newline
            bitfld.long 0x00 0.--1. "CSR_CTL_POLY_SEL_CH_2,PRBS checker Select which CRC polynomial to use" "0: PRBS7,1: PRBS15,2: PRBS23,3: PRBS31- channel 2"
    group.long 0x2E0++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_STOP_THRESHOLD_2,PRBS CHECKER Stop on Error (total) threshold"
            hexmask.long 0x00 0.--30. 1. "CSR_CTL_STOP_ERR_CH_2,Stop on Error (total) threshold for channel 2"
    group.long 0x2E4++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_MANTISSA_THRESHOLD_2,PRBS CHECKER Stop on Cycle Mantissa threshold"
            hexmask.long 0x00 0.--28. 1. "CSR_PRBS_CHECKER_CTL_STOP_CMAN_CH_2,Stop on Cycle Mantissa threshold for channel 2"
    group.long 0x2E8++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_MISC_CTRL_2,PRBS CHECKER misc control"
            bitfld.long 0x00 4. "CSR_CTL_CLEAR_SNAP_CH_2,RESERVED" "0,1"
            newline
            bitfld.long 0x00 0.--2. "CSR_CTL_STOP_CEXP_CH_2,Stop on Cycle Exponent threshold for channel 2" "0,1,2,3,4,5,6,7"

    rgroup.long 0x2EC++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_STATUS_2,PRBS CHECKER PRBS CHECKER Error count stats"
            bitfld.long 0x00 8.--10. "CSR_STS_CYC_EXP_CH_2,Cycle count Exponent for channel 2" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 7. "CSR_STS_ERRT_SAT_CH_2,Error Total saturation for channel 2" "0,1"
            newline
            bitfld.long 0x00 6. "CSR_STS_ERR1_SAT_CH_2,Error bad 1's saturation for channel 2" "0,1"
            newline
            bitfld.long 0x00 5. "CSR_STS_ERR0_SAT_CH_2,Error bad 0's saturation for channel 2" "0,1"
            newline
            bitfld.long 0x00 4. "CSR_STS_ALL0S_CH_2,Input data is all 0's" "0,1"
            newline
            bitfld.long 0x00 0.--3. "CSR_STS_STATE_CH_2,One-hot encoded state" "?,1: IDLE,2: RE,?,4: LOCK,?,?,?,8: STOP for,?..."
    rgroup.long 0x2F0++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_ERR0_CNT_2,PRBS CHECKER Error count for bad 0's"
            hexmask.long 0x00 0.--30. 1. "CSR_STS_ERR0_CNT_CH_2,Error count for bad 0's for channel 2"
    rgroup.long 0x2F4++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_ERR1_CNT_2,PRBS CHECKER Error count for bad 1's"
            hexmask.long 0x00 0.--30. 1. "CSR_STS_ERR1_CNT_CH_2,Error count for bad 1's for channel 2"
    rgroup.long 0x2F8++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_ERRT_CNT_2,PRBS CHECKER Error count Total (sum of err0's and err1's)"
            hexmask.long 0x00 0.--30. 1. "CSR_STS_ERRT_CNT_CH_2,Error count Total (sum of err0's and err1's) for channel 2"
    rgroup.long 0x2FC++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_CYC_MAN_2,PRBS CHECKER Cycle count Mantissa"
            hexmask.long 0x00 0.--28. 1. "CSR_STS_CYC_MAN_CH_2,Cycle count Mantissa"

    group.long 0x300++0x03
        line.long 0x00 "CSR_TEST_PATTERN0_2,Test Pattern control0"
            bitfld.long 0x00 1.--2. "CSR_TEST_PATTERN_WAVEFORM_SEL_2," "0,1,2,3"
            newline
            bitfld.long 0x00 0. "CSR_TEST_PATTERN_EN_2,Enable test pattern generation instead of RX CSI-2 data" "0,1"
    group.long 0x304++0x03
        line.long 0x00 "CSR_TEST_PATTERN1_2,Test Pattern control1"
            bitfld.long 0x00 24.--28. "CSR_TEST_PATTERN_SHIFT2_VALUE_2,Generated pattern scale factor shift value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 16.--20. "CSR_TEST_PATTERN_SHIFT1_VALUE_2,Generated pattern scale factor shift value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            hexmask.long.word 0x00 0.--10. 1. "CSR_TEST_PATTERN_THR_2,Threshold used for pulse pattern generation"
    group.long 0x308++0x03
        line.long 0x00 "CSR_TEST_PATTERN2_2,Test Pattern control2"
            hexmask.long.word 0x00 16.--31. 1. "CSR_TEST_PATTERN_OFFSET_2,Test pattern offset for generator counter"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CSR_TEST_PATTERN_STEP_2,Test pattern step for generator counter"
    group.long 0x30C++0x03
        line.long 0x00 "CSI2_SRAM_SEC_CTRL_2,Single Error Correction Control"
            bitfld.long 0x00 17. "CSI2_SRAM_CLR_ECC_SEC_CNT_2,Toggle to '1' to clear SEC counter" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CSI2_SRAM_SEC_COUNT_THRESH_2,Single Error Correction count threshold"

    rgroup.long 0x310++0x03
        line.long 0x00 "CSI2_SRAM_ECC_ERROR_SEC_COUNT_2,Error single error correctoun count"
            hexmask.long.word 0x00 0.--15. 1. "CSI2_SRAM_ERROR_SEC_COUNT_2,CSI2 SRAM ECC - Error single error correction count for channel 2"

    group.long 0x314++0x03
        line.long 0x00 "RUN_PRBS_3,PRBS checker control register"
            bitfld.long 0x00 3. "CSR_CLEAR_CNT_CH_3,Clear internal error and cycle counters for channel 3" "0,1"
            newline
            bitfld.long 0x00 2. "CSR_SNAP_CNT_CH_3,Take a snapshot of Error and Cycle counters - can be a single cycle pulse for channel 3 Take a snapshot of Error and Cycle counters - can be a single-cycle pulse" "0,1"
            newline
            bitfld.long 0x00 1. "CSR_CONT_CHK_CH_3,Continue checking (from a stop state) for channel 3" "0,1"
            newline
            bitfld.long 0x00 0. "CSR_RUN_CHK_CH_3,Run PRBS checker for channel 3" "0,1"
    group.long 0x318++0x03
        line.long 0x00 "CSR_PRBS_CHECKER_3,PRBS CHECKER Programmable controls"
            bitfld.long 0x00 8.--9. "CSR_CTL_STOP_EN_CH_3,Enable Stopping based on either Error(bit[1]) or Cycle(bit[0]) counters for channel 3" "0,1,2,3"
            newline
            bitfld.long 0x00 4.--7. "CSR_CTL_LOCK_THR_CH_3,PRBS checker must receive 2^(CSR_CTL_LOCK_THR+1) error-free data samples to declare LOCK for channel 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 2. "CSR_CTL_PAR_SEL_CH_3,PRBS checker parallelism selector" "0: parallelism of,1: parallelism of 12"
            newline
            bitfld.long 0x00 0.--1. "CSR_CTL_POLY_SEL_CH_3,PRBS checker Select which CRC polynomial to use" "0: PRBS7,1: PRBS15,2: PRBS23,3: PRBS31- channel 3"
    group.long 0x31C++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_STOP_THRESHOLD_3,PRBS CHECKER Stop on Error (total) threshold"
            hexmask.long 0x00 0.--30. 1. "CSR_CTL_STOP_ERR_CH_3,Stop on Error (total) threshold for channel 3"
    group.long 0x320++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_MANTISSA_THRESHOLD_3,PRBS CHECKER Stop on Cycle Mantissa threshold"
            hexmask.long 0x00 0.--28. 1. "CSR_PRBS_CHECKER_CTL_STOP_CMAN_CH_3,Stop on Cycle Mantissa threshold for channel 3"
    group.long 0x324++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_MISC_CTRL_3,PRBS CHECKER misc control"
            bitfld.long 0x00 4. "CSR_CTL_CLEAR_SNAP_CH_3,RESERVED" "0,1"
            newline
            bitfld.long 0x00 0.--2. "CSR_CTL_STOP_CEXP_CH_3,Stop on Cycle Exponent threshold for channel 3" "0,1,2,3,4,5,6,7"

    rgroup.long 0x328++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_STATUS_3,PRBS CHECKER PRBS CHECKER Error count stats"
            bitfld.long 0x00 8.--10. "CSR_STS_CYC_EXP_CH_3,Cycle count Exponent for channel 3" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 7. "CSR_STS_ERRT_SAT_CH_3,Error Total saturation for channel 3" "0,1"
            newline
            bitfld.long 0x00 6. "CSR_STS_ERR1_SAT_CH_3,Error bad 1's saturation for channel 3" "0,1"
            newline
            bitfld.long 0x00 5. "CSR_STS_ERR0_SAT_CH_3,Error bad 0's saturation for channel 3" "0,1"
            newline
            bitfld.long 0x00 4. "CSR_STS_ALL0S_CH_3,Input data is all 0's" "0,1"
            newline
            bitfld.long 0x00 0.--3. "CSR_STS_STATE_CH_3,One-hot encoded state" "?,1: IDLE,2: RE,?,4: LOCK,?,?,?,8: STOP for,?..."
    rgroup.long 0x32C++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_ERR0_CNT_3,PRBS CHECKER Error count for bad 0's"
            hexmask.long 0x00 0.--30. 1. "CSR_STS_ERR0_CNT_CH_3,Error count for bad 0's for channel 3"
    rgroup.long 0x330++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_ERR1_CNT_3,PRBS CHECKER Error count for bad 1's"
            hexmask.long 0x00 0.--30. 1. "CSR_STS_ERR1_CNT_CH_3,Error count for bad 1's for channel 3"
    rgroup.long 0x334++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_ERRT_CNT_3,PRBS CHECKER Error count Total (sum of err0's and err1's)"
            hexmask.long 0x00 0.--30. 1. "CSR_STS_ERRT_CNT_CH_3,Error count Total (sum of err0's and err1's) for channel 3"
    rgroup.long 0x338++0x03
        line.long 0x00 "CSI2_PRBS_CHECKER_CYC_MAN_3,PRBS CHECKER Cycle count Mantissa"
            hexmask.long 0x00 0.--28. 1. "CSR_STS_CYC_MAN_CH_3,Cycle count Mantissa"

    group.long 0x33C++0x03
        line.long 0x00 "CSR_TEST_PATTERN0_3,Test Pattern control0"
            bitfld.long 0x00 1.--2. "CSR_TEST_PATTERN_WAVEFORM_SEL_3," "0,1,2,3"
            newline
            bitfld.long 0x00 0. "CSR_TEST_PATTERN_EN_3,Enable test pattern generation instead of RX CSI-2 data" "0,1"
    group.long 0x340++0x03
        line.long 0x00 "CSR_TEST_PATTERN1_3,Test Pattern control1"
            bitfld.long 0x00 24.--28. "CSR_TEST_PATTERN_SHIFT2_VALUE_3,Generated pattern scale factor shift value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 16.--20. "CSR_TEST_PATTERN_SHIFT1_VALUE_3,Generated pattern scale factor shift value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            hexmask.long.word 0x00 0.--10. 1. "CSR_TEST_PATTERN_THR_3,Threshold used for pulse pattern generation"
    group.long 0x344++0x03
        line.long 0x00 "CSR_TEST_PATTERN2_3,Test Pattern control2"
            hexmask.long.word 0x00 16.--31. 1. "CSR_TEST_PATTERN_OFFSET_3,Test pattern offset for generator counter"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CSR_TEST_PATTERN_STEP_3,Test pattern step for generator counter"
    group.long 0x348++0x03
        line.long 0x00 "CSI2_SRAM_SEC_CTRL_3,Single Error Correction Control"
            bitfld.long 0x00 17. "CSI2_SRAM_CLR_ECC_SEC_CNT_3,Toggle to '1' to clear SEC counter" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CSI2_SRAM_SEC_COUNT_THRESH_3,Single Error Correction count threshold"

    rgroup.long 0x34C++0x03
        line.long 0x00 "CSI2_SRAM_ECC_ERROR_SEC_COUNT_3,Error single error correctoun count"
            hexmask.long.word 0x00 0.--15. 1. "CSI2_SRAM_ERROR_SEC_COUNT_3,CSI2 SRAM ECC - Error single error correction count for channel 3"

    group.long 0x350++0x03
        line.long 0x00 "PING_PONG_ECC_CTRL,Ping Pong buffers ECC Control Reg"
            bitfld.long 0x00 17. "PING_PONG_CLR_ECC_SEC_CNT,Toggle to '1' to clear SEC counter" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "PING_PONG_CTL_ERR_SEC_LIM,If SEC count exceeds the value of this field then an interrrupt will be triggered"

    rgroup.long 0x354++0x03
        line.long 0x00 "PING_PONG_ECC_STAT,Ping Pong buffers ECC Status Reg"
            hexmask.long.word 0x00 0.--15. 1. "PING_PONG_STS_ECC_SEC_CNT,SEC event counter for ping pong buffer memories"

    group.long 0x358++0x03
        line.long 0x00 "IDM_STAT_MEM_ECC_CTRL,Idm Statistic Memory ECC Control Reg"
            bitfld.long 0x00 17. "IDM_STAT_MEM_CLR_ECC_SEC_CNT,Toggle to '1' to clear SEC counter" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "IDM_STAT_MEM_CTL_ERR_SEC_LIM,If SEC count exceeds the value of this field then an interrrupt will be triggered"

    rgroup.long 0x35C++0x03
        line.long 0x00 "IDM_STAT_MEM_ECC_STAT,Idm Statistic Memory ECC Status Reg"
            hexmask.long.word 0x00 0.--15. 1. "IDM_STAT_MEM_STS_ECC_SEC_CNT,SEC event counter for idm statistic memory"
    rgroup.long 0x360++0x03
        line.long 0x00 "PING_PONG_DEBUG_STS_REG_1,Ping pong debug status reg 1"
            bitfld.long 0x00 30. "STS_READ_REQUEST_RA,Read request for RA interface" "0,1"
            newline
            bitfld.long 0x00 29. "PING_PONG_BUF_EMPTY,Ping pong buffer empty indicator" "0,1"
            newline
            hexmask.long.word 0x00 18.--28. 1. "WR_ADDRESS,Write buffer address"
            newline
            bitfld.long 0x00 17. "WR_BUF_PONG,If high pong buffer is being written" "0,1"
            newline
            bitfld.long 0x00 13.--16. "AV_CHIRPS,Total number of chirps stored in ping pong buffers to be read by the master" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.word 0x00 2.--12. 1. "RD_ADDRESS,Read buffer address"
            newline
            bitfld.long 0x00 1. "RD_BUF_PONG,If high pong buffer is being" "0,1"
            newline
            bitfld.long 0x00 0. "PING_PONG_BUF_FULL,Ping pong buffer full condition" "0,1"
    rgroup.long 0x364++0x03
        line.long 0x00 "PING_PONG_DEBUG_STS_REG_2,Ping pong debug status reg 2"
            hexmask.long.word 0x00 0.--10. 1. "PING_PONG_CHIRP_COUNTER,Ping pong internal chirp counter"

    group.long 0x368++0x03
        line.long 0x00 "CTL_LOCK,Lock control"
            hexmask.long 0x00 0.--31. 1. "CTL_MIPI_LOCK_KEY,Write 0x68E26F31 to allow write access to this SFR bank"

    rgroup.long 0x36C++0x03
        line.long 0x00 "STS_LOCK,Lock status"
            bitfld.long 0x00 0. "STS_MIPI_LOCK_N,Lock status for this SFR bank" "0,1"

    group.long 0x370++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_3_CH0,Interference detection and mitigation control register"
            hexmask.long.word 0x00 0.--10. 1. "SEGMENT_SIZE_CH0,Chirp is divided in groups of SEGMENT_SIZE samples to compute interference detection accumulators"
    group.long 0x374++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_3_CH1,Interference detection and mitigation control register"
            hexmask.long.word 0x00 0.--10. 1. "SEGMENT_SIZE_CH1,Chirp is divided in groups of SEGMENT_SIZE samples to compute interference detection accumulators"
    group.long 0x378++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_3_CH2,Interference detection and mitigation control register"
            hexmask.long.word 0x00 0.--10. 1. "SEGMENT_SIZE_CH2,Chirp is divided in groups of SEGMENT_SIZE samples to compute interference detection accumulators"
    group.long 0x37C++0x03
        line.long 0x00 "IDM_DETECTION_CONTROL_3_CH3,Interference detection and mitigation control register"
            hexmask.long.word 0x00 0.--10. 1. "SEGMENT_SIZE_CH3,Chirp is divided in groups of SEGMENT_SIZE samples to compute interference detection accumulators"
    group.long 0x380++0x03
        line.long 0x00 "FORWARD_INTERFERENCE_DETECTION_CONTROL,Forward Interference detection control"
            hexmask.long.byte 0x00 24.--30. 1. "USER_DEFINED_STRETCHING_FUNCTION,Stretching function value when USER_DEFINED_STRETCHING_FUNCTION_EN is asserted"
            newline
            bitfld.long 0x00 22. "USER_DEFINED_STRETCHING_FUNCTION_EN,If asserted stretching function on both sides of polluted samples is defined by USER_DEFINED_STRETCHING_FUNCTION" "0,1"
            newline
            bitfld.long 0x00 20. "DISCARD_WHOLE_CHIRP_EN,If enabled and maximum amount of polluted samples in all enabled Rx channels is grater than MAX_POLLUTED_SAMPLES the whole chirp for all enabled Rx channels is forced to zero" "0,1"
            newline
            hexmask.long.word 0x00 8.--18. 1. "MAX_POLLUTED_SAMPLES,If DISCARD_WHOLE_CHIRP_EN asserted and maximum amount of polluted samples in all enabled Rx channels is grater than MAX_POLLUTED_SAMPLES the whole chirp for all enabled Rx channels is forced to zero"
            newline
            bitfld.long 0x00 4.--6. "STRETCHING_FACTOR_SHIFT_2,Stretching function on both sides of polluted samples is computed as a fraction of maximum amount of polluted samples in all enabled Rx channels" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0.--2. "STRETCHING_FACTOR_SHIFT_1,Stretching function on both sides of polluted samples is computed as a fraction of maximum amount of polluted samples in all enabled Rx channels" "0,1,2,3,4,5,6,7"
    group.long 0x384++0x03
        line.long 0x00 "SPARE,Spare Register"
            hexmask.long 0x00 0.--31. 1. "SPARE,Spare registers"
tree.end

tree "PWM (Pulse-Width Modulator)"
    repeat 2. (list 0. 1.) (list ad:0x91936000 ad:0x91938000)
        tree "PWM$1"
            base $2
            group.long 0x00++0x03
                line.long 0x00 "PWM_CSR,PWM Control Status Register"
                    bitfld.long 0x00 4.--5. "PRESCALER_SEL,Prescaler select register this register helps in dividing down system clock by a certain degree" "0: Divide by 1,1: Divide by 2,2: Divide by 4,3: Divide by 8"
                    bitfld.long 0x00 3. "EOF_ENABLE,End of Frame Enable Register" "0: External EOF Update feature disabled,1: External EOF Update feature enabled"
                    newline
                    bitfld.long 0x00 2. "EOC_ENABLE,End of Chirp Enable Register" "0: External EOC Update feature disabled,1: External EOC Update feature enabled"
                    bitfld.long 0x00 1. "RAMP_UPDATE_TIMER_ENABLE,Ramp update timer enable this is to enable triggering of ramp updates via internal timer" "0: Internal Ramp Update feature disabled,1: Internal Ramp Update feature enabled"
                    newline
                    bitfld.long 0x00 0. "PWM_ENABLE,Enable PWM" "0: PWM is disabled,1: PWM is enabled"
            group.long 0x04++0x03
                line.long 0x00 "RAMPUP_SETUP,PWM Ramp Up Setting Register"
                    hexmask.long.word 0x00 16.--31. 1. "RAMP0_F_STEP,PWM Ramp Up Stepping Freq Register"
                    hexmask.long.word 0x00 0.--15. 1. "RAMP0_F_START,PWM Ramp Up Start Freq Register"
            group.long 0x08++0x03
                line.long 0x00 "RAMPUP_UPDATE_INTERVAL,PWM Ramp Up Update Interval Register"
                    hexmask.long.word 0x00 0.--15. 1. "RAMP0_UPDATE_INTERVAL,PWM Ramp Up Update Interval Register"
            group.long 0x10++0x03
                line.long 0x00 "RAMPUP_MAX_STEP_COUNT,PWM Ramp Up Max Step Count Register"
                    hexmask.long.word 0x00 0.--15. 1. "RAMP0_MAX_STEP_COUNT,PWM Ramp Up Max Step Count Register"
            group.long 0x14++0x03
                line.long 0x00 "RAMPDWN_SETUP,PWM Ramp Down Setting Register"
                    hexmask.long.word 0x00 16.--31. 1. "RAMP1_F_STEP,PWM Ramp Down Stepping Freq Register"
                    hexmask.long.word 0x00 0.--15. 1. "RAMP1_F_START,PWM Ramp Down Start Freq Register"
            group.long 0x18++0x03
                line.long 0x00 "RAMPDWN_UPDATE_INTERVAL,PWM Ramp Down Update Interval Register"
                    hexmask.long.word 0x00 0.--15. 1. "RAMP1_UPDATE_INTERVAL,PWM Ramp Down Update Interval Register"
            group.long 0x1C++0x03
                line.long 0x00 "RAMPDWN_MAX_STEP_COUNT,PWM Ramp Down Max Step Count Register"
                    hexmask.long.word 0x00 0.--15. 1. "RAMP1_MAX_STEP_COUNT,PWM Ramp Down Max Step Count Register"
            group.long 0x20++0x03
                line.long 0x00 "DITHER_SETUP,PWM Dither Setup Register"
                    hexmask.long.word 0x00 0.--15. 1. "DITHER_F_STEP,PWM Dither Step Register"
            group.long 0x24++0x03
                line.long 0x00 "DITHER_UPDATE_INTERVAL,PWM Dither Update Interval Register"
                    hexmask.long.word 0x00 0.--15. 1. "DITHER_UPDATE_INTERVAL,PWM Dither Update Interval Register"
            group.long 0x28++0x03
                line.long 0x00 "DUTY_CYCLE,PWM Duty Cycle Register"
                    hexmask.long.tbyte 0x00 0.--16. 1. "DUTY_CYCLE,PWM Duty Cycle Register"

            rgroup.long 0x40++0x03
                line.long 0x00 "STS_PWM_RAMP,PWM Ramp state"
                    bitfld.long 0x00 0. "STS_PWM_RAMP_STATE,PWM Ramp state" "0,1"
            rgroup.long 0x44++0x03
                line.long 0x00 "STS_PWM_FREQ,PWM Frequency"
                    hexmask.long.word 0x00 16.--31. 1. "STS_PWM_FREQ_DITHER,Current frequency with dithering"
                    hexmask.long.word 0x00 0.--15. 1. "STS_PWM_FREQ_CURR,Current frequency without dithering"

            group.long 0x48++0x03
                line.long 0x00 "CTL_LOCK,Lock control"
                    hexmask.long 0x00 0.--31. 1. "CTL_PWM_LOCK_KEY,Write 0x8664C3FE to allow write access to this SFR bank"

            rgroup.long 0x4C++0x03
                line.long 0x00 "STS_LOCK,Lock status"
                    bitfld.long 0x00 0. "STS_PWM_LOCK_N,Lock status for this SFR bank" "0,1"
        tree.end
    repeat.end
    repeat 2. (list 2. 3.) (list ad:0x9193A000 ad:0x9193C000)
        tree "PWM$1"
            base $2
            group.long 0x00++0x03
                line.long 0x00 "PWM_CSR,PWM Control Status Register"
                    bitfld.long 0x00 29. "PWM_EOF_MASK,Mask bit for external EOF triggers during staircase mode" "0: Allows external EOF triggers,1: Blocks external EOF triggers"
                    newline
                    bitfld.long 0x00 28. "PWM_EOC_MASK,Mask bit for external EOC triggers during staircase mode" "0: Allows external EOC triggers,1: Blocks external EOC triggers"
                    newline
                    bitfld.long 0x00 24.--25. "PWM_PRESCALER_SEL,PWM Prescaler i.e" "0: Divide by 1,1: Divide by 2,2: Divide by 4,3: Divide by 8"
                    newline
                    hexmask.long.byte 0x00 16.--23. 1. "STAIRCASE_EOC,During Staircase Period Mode this register value contains counts of PWM sequences after which PWM needs to jump to next Period based on slope step size"
                    newline
                    bitfld.long 0x00 8. "STAIRCASE_EOC_ENA,Register to enable staircase eoc counts to cause spread spectrum behavior when PWM used in Staircase Mode" "0: Staircase eoc count feature disabled,1: Staircase eoc count feature enabled"
                    newline
                    bitfld.long 0x00 2. "PWM_STAIRCASE_MODE_ENA,Register to configure PWM in Staircase Period Mode" "0: PWM is unconfigured to run in Staircase..,1: PWM is configured to run in Staircase Period.."
                    newline
                    bitfld.long 0x00 1. "PWM_CONTINUOUS_MODE_ENA,Register to configure PWM in Continuous Period Mode" "0: PWM is unconfigured to run in Continuous..,1: PWM is configured to run in Continuous Period.."
                    newline
                    bitfld.long 0x00 0. "PWM_ENABLE,Enable PWM" "0: PWM is disabled,1: PWM is enabled"
            group.long 0x04++0x03
                line.long 0x00 "PWM_SLOPE_STEP,PWM Slope Step Register"
                    hexmask.long.word 0x00 0.--15. 1. "SLOPE_STEP,Slope Step Size for continuous/Staircase Period Mode"
            group.long 0x08++0x03
                line.long 0x00 "DITHER_CTRL,Dither Control Register"
                    bitfld.long 0x00 4.--7. "DITHER_STEP,When dithering enabled low time of pwm is dithered randomly by this number of configured steps else these register values are ignored" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
                    newline
                    bitfld.long 0x00 0. "DITHER_ENA,Dithering control capability on PWMs" "0: Dithering on PWM outputs disabled,1: Dithering on PWM outputs enabled"
            group.long 0x0C++0x03
                line.long 0x00 "NOMINAL_PERIOD,Nominal Period Register"
                    hexmask.long.word 0x00 16.--31. 1. "HIGH_TIME,High Time count for PWM nominal Period"
                    newline
                    hexmask.long.word 0x00 0.--15. 1. "LOW_TIME,Low Time count for PWM nominal Period"
            group.long 0x10++0x03
                line.long 0x00 "MIN_PERIOD,Minimum Period Register"
                    hexmask.long.tbyte 0x00 0.--16. 1. "MIN_PERIOD,Minimum count for PWM to achieve Maximum PWM frequency"
            group.long 0x14++0x03
                line.long 0x00 "MAX_PERIOD,Maximum Period Register"
                    hexmask.long.tbyte 0x00 0.--16. 1. "MAX_PERIOD,Maximum count for PWM to achieve Minimum PWM frequency"

            rgroup.long 0x18++0x03
                line.long 0x00 "PWM_OPERATING_STS,PWM State Register"
                    bitfld.long 0x00 8. "PWM_DIRECTION,This register is helpful in continuous pwm mode indication whether PWM period is increasing or decreasing" "0: PWM period is decreasing and the slope of..,1: PWM period is increasing and the slope of.."
                    newline
                    bitfld.long 0x00 0.--5. "PWM_STATE,Register providing current operating status of PWM" "?,1: PWM is in Inactive state,2: PWM is servicing High time of PWM pulse,?,4: PWM is servicing Low time of PWM pulse,?,?,?,8: PWM is undergoing Inspection to check for any..,?,?,?,?,?,?,?,16: PWM is stepping down/up for next cycle of..,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,32: PWM is applying dithering to PWM period,?..."

            group.long 0x1C++0x03
                line.long 0x00 "CTL_LOCK,Lock control"
                    hexmask.long 0x00 0.--31. 1. "CTL_PWM_LOCK_KEY,Write 0x8664C3FE to allow write access to this SFR bank"

            rgroup.long 0x20++0x03
                line.long 0x00 "STS_LOCK,Lock status"
                    bitfld.long 0x00 0. "STS_PWM_LOCK_N,Lock status for this SFR bank" "0,1"
        tree.end
    repeat.end
tree.end

tree "QSPI_FLASH ()"
    base ad:0x91900000
    group.long 0x00++0x03
        line.long 0x00 "CTRLR0,This register controls the serial data transfer"
            rbitfld.long 0x00 31. "SSI_IS_MST,This field selects if DWC_ssi is working in Controller or Target mode" "0: DWC_ssi is Target,1: DWC_ssi is Controller"
            newline
            rbitfld.long 0x00 27.--30. "RSVD_CTRLR0_27_30,Reserved bits - read as zero" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 26. "CLK_LOOP_EN,Clock loop back enable bit" "0: Disable Clock Loop Back,1: Enable Clock Loop Back"
            newline
            rbitfld.long 0x00 25. "SPI_DWS_EN,Enable Dynamic wait states in SPI mode of operation" "0: Disable SPI Dynamic Wait State,1: Enable SPI Dynamic Wait State"
            newline
            rbitfld.long 0x00 24. "SPI_HYPERBUS_EN,SPI Hyperbus Frame format enable" "0: Disable Hyperbus Format,1: Enable Hyperbus Format"
            newline
            bitfld.long 0x00 22.--23. "SPI_FRF,SPI Frame Format Selects data frame format for Transmitting/Receiving the data" "0: Standard SPI Format,1: Dual SPI Format,2: Quad SPI Format,3: Octal SPI Format"
            newline
            rbitfld.long 0x00 20.--21. "RSVD_CTRLR0_20_21,Reserved bits - read as zero" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--19. "CFS,Control Frame Size" "0: 01-bit Control Word,1: 02-bit Control Word,2: 03-bit Control Word,3: 04-bit Control Word,4: 05-bit Control Word,5: 06-bit Control Word,6: 07-bit Control Word,7: 08-bit Control Word,8: 09-bit Control Word,9: 10-bit Control Word,10: 11-bit Control Word,11: 12-bit Control Word,12: 13-bit Control Word,13: 14-bit Control Word,14: 15-bit Control Word,15: 16-bit Control Word"
            newline
            rbitfld.long 0x00 15. "RSVD_CTRLR0_15,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 14. "SSTE,Target Select Toggle Enable" "0: ss_*_n will stay low and sclk will run..,1: ss_*_n line will toggle between consecutive.."
            newline
            bitfld.long 0x00 13. "SRL,Shift Register Loop" "0: Normal mode operation,1: Test Mode Operation"
            newline
            bitfld.long 0x00 12. "SLV_OE,Target Output Enable" "0: Target Output is enabled,1: Target Output is disabled"
            newline
            bitfld.long 0x00 10.--11. "TMOD,Transfer Mode" "0: Transmit & Receive Not Applicable in enhanced..,1: Transmit only mode Or Write in enhanced SPI..,2: Receive only mode Or Read in enhanced SPI..,3: EEPROM Read mode Not Applicable in enhanced.."
            newline
            bitfld.long 0x00 9. "SCPOL,Serial Clock Polarity" "0: Inactive state of serial clock is low,1: Inactive state of serial clock is high"
            newline
            bitfld.long 0x00 8. "SCPH,Serial Clock Phase" "0: Serial clock toggles in middle of first bit,1: Serial clock toggles at start of first bit"
            newline
            bitfld.long 0x00 6.--7. "FRF,Frame Format" "0: Motorola SPI Frame Format,1: Texas Instruments SSP Frame Format,2: National Semiconductors Microwire Frame Format,?..."
            newline
            rbitfld.long 0x00 5. "RSVD_CTRLR0_5,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 0.--4. "DFS,Data Frame Size" "?,?,?,3: 04-bit serial data transfer,4: 05-bit serial data transfer,5: 06-bit serial data transfer,6: 07-bit serial data transfer,7: 08-bit serial data transfer,8: 09-bit serial data transfer,9: 10-bit serial data transfer,10: 11-bit serial data transfer,11: 12-bit serial data transfer,12: 13-bit serial data transfer,13: 14-bit serial data transfer,14: 15-bit serial data transfer,15: 16-bit serial data transfer,16: 17-bit serial data transfer,17: 18-bit serial data transfer,18: 19-bit serial data transfer,19: 20-bit serial data transfer,20: 21-bit serial data transfer,21: 22-bit serial data transfer,22: 23-bit serial data transfer,23: 24-bit serial data transfer,24: 25-bit serial data transfer,25: 26-bit serial data transfer,26: 27-bit serial data transfer,27: 28-bit serial data transfer,28: 29-bit serial data transfer,29: 30-bit serial data transfer,30: 31-bit serial data transfer,31: 32-bit serial data transfer"
    group.long 0x04++0x03
        line.long 0x00 "CTRLR1,This register exists only when the DWC_ssi is configured as a controller device"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_CTRLR1,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 0.--15. 1. "NDF,Number of Data Frames"
    group.long 0x08++0x03
        line.long 0x00 "SSIENR,This register enables and disables the DWC_ssi"
            hexmask.long 0x00 1.--31. 1. "RSVD_SSIENR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "SSIC_EN,SSI Enable" "0: Disables DWC_ssi,1: Enables DWC_ssi"
    group.long 0x0C++0x03
        line.long 0x00 "MWCR,This register controls the direction of the data word for the half-duplex Microwire serial protocol"
            hexmask.long 0x00 3.--31. 1. "RSVD_MWCR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 2. "MHS,Microwire Handshaking" "0: handshaking interface is disabled,1: handshaking interface is enabled"
            newline
            bitfld.long 0x00 1. "MDD,Microwire Control" "0: SSI receives data,1: SSI transmits data"
            newline
            bitfld.long 0x00 0. "MWMOD,Microwire Transfer Mode" "0: Non-Sequential Transfer,1: Sequential Transfer"
    group.long 0x10++0x03
        line.long 0x00 "SER,This register is valid only when the DWC_ssi is configured as a controller device"
            hexmask.long 0x00 1.--31. 1. "RSVD_SER,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "SER,Chip Select Enable Flag" "0,1"
    group.long 0x14++0x03
        line.long 0x00 "BAUDR,This register is valid only when the DWC_ssi is configured as a controller device"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_BAUDR_16_31,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 1.--15. 1. "SCKDV,SSI Clock Divider"
            newline
            rbitfld.long 0x00 0. "RSVD_BAUDR_0,Reserved bits - read as zero" "0,1"
    group.long 0x18++0x03
        line.long 0x00 "TXFTLR,This register controls the threshold value for the transmit FIFO memory"
            hexmask.long.word 0x00 23.--31. 1. "RSVD_TXFTHR,Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 16.--22. 1. "TXFTHR,Transfer start FIFO level"
            newline
            hexmask.long.word 0x00 4.--15. 1. "RSVD_TXFTLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--3. "TFT,Transmit FIFO Threshold" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x1C++0x03
        line.long 0x00 "RXFTLR,This register controls the threshold value for the receive FIFO memory"
            hexmask.long 0x00 4.--31. 1. "RSVD_RXFTLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--3. "RFT,Receive FIFO Threshold" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x20++0x03
        line.long 0x00 "TXFLR,This register contains the number of valid data entries in the transmit FIFO memory"
            hexmask.long 0x00 5.--31. 1. "RSVD_TXFLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--4. "TXTFL,Transmit FIFO Level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    rgroup.long 0x24++0x03
        line.long 0x00 "RXFLR,This register contains the number of valid data entries in the receive FIFO memory"
            hexmask.long 0x00 5.--31. 1. "RSVD_RXFLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--4. "RXTFL,Receive FIFO Level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    rgroup.long 0x28++0x03
        line.long 0x00 "SR,This is a read-only register used to indicate the current transfer status FIFO status and any transmission/reception errors that may have occurred"
            hexmask.long.tbyte 0x00 15.--31. 1. "CMPLTD_DF,Completed Data frames This field indicates total data frames transferred in the previous internal DMA transfer"
            newline
            hexmask.long.byte 0x00 7.--14. 1. "RSVD_SR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 6. "DCOL,Data Collision Error" "0: NO_ERROR_CONDITION,1: Transmit Data Collision Error"
            newline
            bitfld.long 0x00 5. "TXE,Transmission Error" "0: NO_ERROR,1: Transmission Error"
            newline
            bitfld.long 0x00 4. "RFF,Receive FIFO Full" "0: Receive FIFO is not full,1: Receive FIFO is full"
            newline
            bitfld.long 0x00 3. "RFNE,Receive FIFO Not Empty" "0: Receive FIFO is empty,1: Receive FIFO is not empty"
            newline
            bitfld.long 0x00 2. "TFE,Transmit FIFO Empty" "0: Transmit FIFO is not empty,1: Transmit FIFO is empty"
            newline
            bitfld.long 0x00 1. "TFNF,Transmit FIFO Not Full" "0: Tx FIFO is full,1: Tx FIFO is not Full"
            newline
            bitfld.long 0x00 0. "BUSY,SSI Busy Flag" "0: DWC_ssi is idle or disabled,1: DWC_ssi is actively transferring data"

    group.long 0x2C++0x03
        line.long 0x00 "IMR,This read/write register masks or enables all interrupts generated by the DWC_ssi"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_12_31_IMR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 11. "DONEM,SSI Done Interrupt Mask" "0: ssi_done_intr interrupt is masked,1: ssi_done_intr interrupt is not masked"
            newline
            rbitfld.long 0x00 10. "SPITEM,SPI Transmit Error Interrupt Mask" "0: ssi_spite_intr interrupt is masked,1: ssi_spite_intr interrupt is not masked"
            newline
            rbitfld.long 0x00 9. "RSVD_9_IMR,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 8. "AXIEM,AXI Error Interrupt Mask" "0: ssi_axie_intr interrupt is masked,1: ssi_axie_intr interrupt is not masked"
            newline
            bitfld.long 0x00 7. "TXUIM,Transmit FIFO Underflow Interrupt Mask" "0: ssi_txu_intr interrupt is masked,1: ssi_txu_intr interrupt is not masked"
            newline
            rbitfld.long 0x00 6. "XRXOIM,XIP Receive FIFO Overflow Interrupt Mask" "0: ssi_xrxo_intr interrupt is masked,1: ssi_xrxo_intr interrupt is not masked"
            newline
            bitfld.long 0x00 5. "MSTIM,Multi-Controller Contention Interrupt Mask" "0: ssi_mst_intr interrupt is masked,1: ssi_mst_intr interrupt is not masked"
            newline
            bitfld.long 0x00 4. "RXFIM,Receive FIFO Full Interrupt Mask" "0: ssi_rxf_intr interrupt is masked,1: ssi_rxf_intr interrupt is not masked"
            newline
            bitfld.long 0x00 3. "RXOIM,Receive FIFO Overflow Interrupt Mask" "0: ssi_rxo_intr interrupt is masked,1: ssi_rxo_intr interrupt is not masked"
            newline
            bitfld.long 0x00 2. "RXUIM,Receive FIFO Underflow Interrupt Mask" "0: ssi_rxu_intr interrupt is masked,1: ssi_rxu_intr interrupt is not masked"
            newline
            bitfld.long 0x00 1. "TXOIM,Transmit FIFO Overflow Interrupt Mask" "0: ssi_txo_intr interrupt is masked,1: ssi_txo_intr interrupt is not masked"
            newline
            bitfld.long 0x00 0. "TXEIM,Transmit FIFO Empty Interrupt Mask" "0: ssi_txe_intr interrupt is masked,1: ssi_txe_intr interrupt is not masked"

    rgroup.long 0x30++0x03
        line.long 0x00 "ISR,This register reports the status of the DWC_ssi interrupts after they have been masked"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_12_31_RISR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 11. "DONES,SSI Done Interrupt Status" "0: ssi_done_intr interrupt is not active after..,1: ssi_done_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 10. "SPITES,SPI Transmit Error Interrupt" "0: ssi_spite_intr interrupt is not active after..,1: ssi_spite_intr interrupt is active after.."
            newline
            bitfld.long 0x00 9. "RSVD_9_RISR,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 8. "AXIES,AXI Error Interrupt Status" "0: ssi_axie_intr interrupt is not active after..,1: ssi_axie_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 7. "TXUIS,Transmit FIFO Underflow Interrupt Status" "0: ssi_txu_intr interrupt is not active after..,1: ssi_txu_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 6. "XRXOIS,XIP Receive FIFO Overflow Interrupt Status" "0: ssi_xrxo_intr interrupt is not active after..,1: ssi_xrxo_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 5. "MSTIS,Multi-Controller Contention Interrupt Status" "0: ssi_mst_intr interrupt is not active after..,1: ssi_mst_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 4. "RXFIS,Receive FIFO Full Interrupt Status" "0: ssi_rxf_intr interrupt is not active after..,1: ssi_rxf_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 3. "RXOIS,Receive FIFO Overflow Interrupt Status" "0: ssi_rxo_intr interrupt is not active after..,1: ssi_rxo_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 2. "RXUIS,Receive FIFO Underflow Interrupt Status" "0: ssi_rxu_intr interrupt is not active after..,1: ssi_rxu_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 1. "TXOIS,Transmit FIFO Overflow Interrupt Status" "0: ssi_txo_intr interrupt is not active after..,1: ssi_txo_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 0. "TXEIS,Transmit FIFO Empty Interrupt Status" "0: ssi_txe_intr interrupt is not active after..,1: ssi_txe_intr interrupt is active after masking"
    rgroup.long 0x34++0x03
        line.long 0x00 "RISR,Raw Interrupt Status Register"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_12_31_RISR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 11. "DONER,SSI Done Interrupt Raw Status" "0: ssi_done_intr interrupt is not active prior..,1: ssi_done_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 10. "SPITER,SPI Transmit Error Interrupt status" "0: ssi_spite_intr interrupt is not active prior..,1: ssi_spite_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 9. "RSVD_9_RISR,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 8. "AXIER,AXI Error Interrupt Raw Status" "0: ssi_axie_intr interrupt is not active prior..,1: ssi_axie_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 7. "TXUIR,Transmit FIFO Underflow Interrupt Raw Status" "0: ssi_txu_intr interrupt is not active prior..,1: ssi_txu_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 6. "XRXOIR,XIP Receive FIFO Overflow Raw Interrupt Status" "0: ssi_xrxo_intr interrupt is not active prior..,1: ssi_xrxo_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 5. "MSTIR,Multi-Controller Contention Raw Interrupt Status" "0: ssi_mst_intr interrupt is not active prior..,1: ssi_mst_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 4. "RXFIR,Receive FIFO Full Raw Interrupt Status" "0: ssi_rxf_intr interrupt is not active prior..,1: ssi_rxf_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 3. "RXOIR,Receive FIFO Overflow Raw Interrupt Status" "0: ssi_rxo_intr interrupt is not active prior..,1: ssi_rxo_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 2. "RXUIR,Receive FIFO Underflow Raw Interrupt Status" "0: ssi_rxu_intr interrupt is not active prior..,1: ssi_rxu_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 1. "TXOIR,Transmit FIFO Overflow Raw Interrupt Status" "0: ssi_txo_intr interrupt is not active prior..,1: ssi_txo_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 0. "TXEIR,Transmit FIFO Empty Raw Interrupt Status" "0: ssi_txe_intr interrupt is not active prior..,1: ssi_txe_intr interrupt is active prior to.."
    rgroup.long 0x38++0x03
        line.long 0x00 "TXEICR,Transmit FIFO Error Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_TXEICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "TXEICR,Clear Transmit FIFO Overflow/Underflow Interrupt" "0,1"
    rgroup.long 0x3C++0x03
        line.long 0x00 "RXOICR,Receive FIFO Overflow Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_RXOICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "RXOICR,Clear Receive FIFO Overflow Interrupt" "0,1"
    rgroup.long 0x40++0x03
        line.long 0x00 "RXUICR,Receive FIFO Underflow Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_RXUICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "RXUICR,Clear Receive FIFO Underflow Interrupt" "0,1"
    rgroup.long 0x44++0x03
        line.long 0x00 "MSTICR,Multi-Controller Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_MSTICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "MSTICR,Clear Multi-Controller Contention Interrupt" "0,1"
    rgroup.long 0x48++0x03
        line.long 0x00 "ICR,Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_ICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "ICR,Clear Interrupts" "0,1"

    group.long 0x4C++0x03
        line.long 0x00 "DMACR,DMA Control Register"
            hexmask.long.word 0x00 21.--31. 1. "RSVD_DMACR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 15.--20. "AID,AXI awid/arid signal value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 12.--14. "APROT,AXI arprot/awprot signal value" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 8.--11. "ACACHE,AXI arcache/awcache signal value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 7. "RSVD_DMACR7,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 6. "AINC,Address Increment" "0: No Change,1: Increment"
            newline
            rbitfld.long 0x00 5. "RSVD_DMACR5,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 3.--4. "ATW,AXI transfer width for DMA transfers mapped to arsize/awsize" "0: 1 byte,1: 2 bytes,2: 4 bytes,3: 8 bytes"
            newline
            bitfld.long 0x00 2. "IDMAE,Internal DMA Enable" "0,1"
            newline
            rbitfld.long 0x00 1. "TDMAE,Transmit DMA Enable" "0: Transmit DMA disabled,1: Transmit DMA enabled"
            newline
            rbitfld.long 0x00 0. "RDMAE,Receive DMA Enable" "0: Receive DMA disabled,1: Receive DMA enabled"
    group.long 0x50++0x03
        line.long 0x00 "AXIAWLEN,Destination Burst Length"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_AXIAWLEN2,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 8.--11. "AWLEN,Destination Burst Length" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "RSVD_AXIAWLEN,Reserved bits - read as zero"
    group.long 0x54++0x03
        line.long 0x00 "AXIARLEN,Source Burst Length"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_AXIARLEN2,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 8.--11. "ARLEN,Source Burst Length" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "RSVD_AXIARLEN,Reserved bits - read as zero"

    rgroup.long 0x58++0x03
        line.long 0x00 "IDR,This register contains the peripherals identification code which is written into the register at configuration time using coreConsultant"
            hexmask.long 0x00 0.--31. 1. "IDCODE,Identification code"
    rgroup.long 0x5C++0x03
        line.long 0x00 "SSIC_VERSION_ID,This read-only register stores the specific DWC_ssi component version"
            hexmask.long 0x00 0.--31. 1. "SSIC_COMP_VERSION,Contains the hex representation of the Synopsys component version"

    repeat 16. (strings "0" "1" "2" "3" "4" "5" "6" "7" "8" "9" "10" "11" "12" "13" "14" "15" )(list 0x0 0x4 0x8 0xC 0x10 0x14 0x18 0x1C 0x20 0x24 0x28 0x2C 0x30 0x34 0x38 0x3C )
        group.long ($2+0x60)++0x03
            line.long 0x00 "DR$1,The DWC_ssi data register is a 32-bit read/write buffer for the transmit/receive FIFOs"
                hexmask.long 0x00 0.--31. 1. "DR,Data Register"
    repeat.end
    repeat 16. (strings "16" "17" "18" "19" "20" "21" "22" "23" "24" "25" "26" "27" "28" "29" "30" "31" )(list 0x0 0x4 0x8 0xC 0x10 0x14 0x18 0x1C 0x20 0x24 0x28 0x2C 0x30 0x34 0x38 0x3C )
        group.long ($2+0xA0)++0x03
            line.long 0x00 "DR$1,The DWC_ssi data register is a 32-bit read/write buffer for the transmit/receive FIFOs"
                hexmask.long 0x00 0.--31. 1. "DR,Data Register"
    repeat.end
    repeat 4. (strings "32" "33" "34" "35" )(list 0x0 0x4 0x8 0xC )
        group.long ($2+0xE0)++0x03
            line.long 0x00 "DR$1,The DWC_ssi data register is a 32-bit read/write buffer for the transmit/receive FIFOs"
                hexmask.long 0x00 0.--31. 1. "DR,Data Register"
    repeat.end

    group.long 0xF0++0x03
        line.long 0x00 "RX_SAMPLE_DELAY,This register is only valid when the DWC_ssi is configured with rxd sample delay logic (SSIC_HAS_RX_SAMPLE_DELAY!=0)"
            hexmask.long.word 0x00 17.--31. 1. "RSVD1_RX_SAMPLE_DELAY,Reserved bits - read as zero"
            newline
            rbitfld.long 0x00 16. "SE,Receive Data (rxd) Sampling Edge" "0,1"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "RSVD0_RX_SAMPLE_DELAY,Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "RSD,Receive Data (rxd) Sample Delay"
    group.long 0xF4++0x03
        line.long 0x00 "SPI_CTRLR0,This register is used to control the serial data transfer in enhanced SPI mode of operation"
            rbitfld.long 0x00 31. "RSVD_SPI_CTRLR0,Reserved bits - read as zero" "0,1"
            newline
            rbitfld.long 0x00 30. "CLK_STRETCH_EN,Enables clock stretching capability in SPI transfers" "0,1"
            newline
            rbitfld.long 0x00 29. "XIP_PREFETCH_EN,Enables XIP pre-fetch functionality in DWC_ssi" "0,1"
            newline
            rbitfld.long 0x00 28. "RSVD_SPI_CTRLR0_28,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 26.--27. "XIP_MBL,XIP Mode bits length" "0: Mode bits length equal to 2,1: Mode bits length equal to 4,2: Mode bits length equal to 8,3: Mode bits length equal to 16"
            newline
            rbitfld.long 0x00 25. "SPI_RXDS_SIG_EN,Enable rxds signaling during address and command phase of Hyperbus transfer" "0,1"
            newline
            rbitfld.long 0x00 24. "SPI_DM_EN,SPI data mask enable bit" "0,1"
            newline
            rbitfld.long 0x00 23. "RXDS_VL_EN,RXDS variable latency enable bit" "0,1"
            newline
            rbitfld.long 0x00 22. "RSVD_SPI_CTRLR0_22,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 21. "SSIC_XIP_CONT_XFER_EN,Enable continuous transfer in XIP mode" "0,1"
            newline
            bitfld.long 0x00 20. "XIP_INST_EN,XIP instruction enable bit" "0,1"
            newline
            bitfld.long 0x00 19. "XIP_DFS_HC,Fix DFS for XIP transfers" "0,1"
            newline
            rbitfld.long 0x00 18. "SPI_RXDS_EN,Read data strobe enable bit" "0,1"
            newline
            rbitfld.long 0x00 17. "INST_DDR_EN,Instruction DDR Enable bit" "0,1"
            newline
            rbitfld.long 0x00 16. "SPI_DDR_EN,SPI DDR Enable bit" "0,1"
            newline
            bitfld.long 0x00 11.--15. "WAIT_CYCLES,Wait cycles in Enhanced SPI mode between control frames transmit and data reception" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            rbitfld.long 0x00 10. "RSVD_SPI_CTRLR0_10,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 8.--9. "INST_L,Enhanced SPI mode instruction length in bits" "0: No Instruction,1: 4 bit Instruction length,2: 8 bit Instruction length,3: 16 bit Instruction length"
            newline
            bitfld.long 0x00 7. "XIP_MD_BIT_EN,Mode bits enable in XIP mode" "0,1"
            newline
            rbitfld.long 0x00 6. "RSVD_SPI_CTRLR0_6,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 2.--5. "ADDR_L,This bit defines Length of Address to be transmitted" "0: No Address,1: 4 bit Address length,2: 8 bit Address length,3: 12 bit Address length,4: 16 bit Address length,5: 20 bit Address length,6: 24 bit Address length,7: 28 bit Address length,8: 32 bit Address length,9: 36 bit Address length,10: 40 bit Address length,11: 44 bit Address length,12: 48 bit Address length,13: 52 bit Address length,14: 56 bit Address length,15: 60 bit Address length"
            newline
            bitfld.long 0x00 0.--1. "TRANS_TYPE,Address and instruction transfer format" "0: Instruction and Address will be sent in..,1: Instruction will be sent in Standard SPI Mode..,2: Both Instruction and Address will be sent in..,3: Dual Octal mode the address and instruction.."
    group.long 0xFC++0x03
        line.long 0x00 "XIP_MODE_BITS,This register carries the mode bits which are sent in the XIP mode of operation after address phase"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_XIP_MD_BITS,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 0.--15. 1. "XIP_MD_BITS,XIP mode bits to be sent after address phase of XIP transfer"
    group.long 0x100++0x03
        line.long 0x00 "XIP_INCR_INST,This Register is valid only when SSIC_XIP_EN is equal to 1"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_INCR_INST,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 0.--15. 1. "INCR_INST,XIP INCR transfer opcode"
    group.long 0x104++0x03
        line.long 0x00 "XIP_WRAP_INST,This Register is valid only when SSIC_XIP_EN is equal to 1"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_WRAP_INST,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 0.--15. 1. "WRAP_INST,XIP WRAP transfer opcode"
    group.long 0x118++0x03
        line.long 0x00 "SPI_CTRLR1,SPI Control register 1 is used to control serial transfers in SPI mode of operation"
            hexmask.long.word 0x00 20.--31. 1. "RSVD_SPI_CTRLR1_20_31,Reserved bits - Read Only"
            newline
            bitfld.long 0x00 16.--19. "CS_MIN_HIGH,Chip-Select Minimum HIGH period" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 12.--15. "RSVD_SPI_CTRLR1_12_15,Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 8.--11. "MAX_WS,Maximum wait cycles allowed per transaction" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 3.--7. "RSVD_SPI_CTRLR1_3_7,Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 0.--2. "DYN_WS,SPI Dynamic Wait states field" "0,1,2,3,4,5,6,7"
    group.long 0x120++0x03
        line.long 0x00 "SPIDR,SPI Device Register"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_SPIDR,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 0.--15. 1. "SPI_INST,SPI Instruction code"
    group.long 0x124++0x03
        line.long 0x00 "SPIAR,SPI Device Address Register"
            hexmask.long 0x00 0.--31. 1. "SDAR,SPI Device Address Register"
    group.long 0x128++0x03
        line.long 0x00 "AXIAR0,AXI Address Register 0"
            hexmask.long 0x00 0.--31. 1. "AXIAR_0_31,LSB for AXI address for DMA operation"

    rgroup.long 0x130++0x03
        line.long 0x00 "AXIECR,AXI Manager Error Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_AXIECR,Reserved bit"
            newline
            bitfld.long 0x00 0. "AXIECR,Clear AXI Error Interrupt" "0,1"
    rgroup.long 0x134++0x03
        line.long 0x00 "DONECR,Transfer Done Clear Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_DONECR,Reserved bit"
            newline
            bitfld.long 0x00 0. "DONECR,Clear Transfer Done Interrupt" "0,1"
tree.end

tree "QSPI_GP ()"
    base ad:0x91000000
    group.long 0x00++0x03
        line.long 0x00 "CTRLR0,This register controls the serial data transfer"
            bitfld.long 0x00 31. "SSI_IS_MST,This field selects if DWC_ssi is working in Master or Slave mode" "0: DWC_ssi is Slave,1: DWC_ssi is Master"
            newline
            rbitfld.long 0x00 26.--30. "RSVD_CTRLR0_26_31,Reserved bits - read as zero" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            rbitfld.long 0x00 25. "SPI_DWS_EN,Enable Dynamic wait states in SPI mode of operation" "0: Disable SPI Dynamic Wait State,1: Enable SPI Dynamic Wait State"
            newline
            rbitfld.long 0x00 24. "SPI_HYPERBUS_EN,SPI Hyperbus Frame format enable" "0: Disable Hyperbus Format,1: Enable Hyperbus Format"
            newline
            bitfld.long 0x00 22.--23. "SPI_FRF,SPI Frame Format Selects data frame format for Transmitting/Receiving the data" "0: Standard SPI Format,1: Dual SPI Format,2: Quad SPI Format,3: Octal SPI Format"
            newline
            rbitfld.long 0x00 20.--21. "RSVD_CTRLR0_20_21,Reserved bits - read as zero" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--19. "CFS,Control Frame Size" "0: 01-bit Control Word,1: 02-bit Control Word,2: 03-bit Control Word,3: 04-bit Control Word,4: 05-bit Control Word,5: 06-bit Control Word,6: 07-bit Control Word,7: 08-bit Control Word,8: 09-bit Control Word,9: 10-bit Control Word,10: 11-bit Control Word,11: 12-bit Control Word,12: 13-bit Control Word,13: 14-bit Control Word,14: 15-bit Control Word,15: 16-bit Control Word"
            newline
            rbitfld.long 0x00 15. "RSVD_CTRLR0_15,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 14. "SSTE,Slave Select Toggle Enable" "0: ss_*_n will stay low and sclk will run..,1: ss_*_n line will toggle between consecutive.."
            newline
            bitfld.long 0x00 13. "SRL,Shift Register Loop" "0: Normal mode operation,1: Test Mode Operation"
            newline
            bitfld.long 0x00 12. "SLV_OE,Slave Output Enable" "0: Slave Output is enabled,1: Slave Output is disabled"
            newline
            bitfld.long 0x00 10.--11. "TMOD,Transfer Mode" "0: Transmit & Receive Not Applicable in enhanced..,1: Transmit only mode Or Write in enhanced SPI..,2: Receive only mode Or Read in enhanced SPI..,3: EEPROM Read mode Not Applicable in enhanced.."
            newline
            bitfld.long 0x00 9. "SCPOL,Serial Clock Polarity" "0: Inactive state of serial clock is low,1: Inactive state of serial clock is high"
            newline
            bitfld.long 0x00 8. "SCPH,Serial Clock Phase" "0: Serial clock toggles in middle of first bit,1: Serial clock toggles at start of first bit"
            newline
            bitfld.long 0x00 6.--7. "FRF,Frame Format" "0: Motorola SPI Frame Format,1: Texas Instruments SSP Frame Format,2: National Semiconductors Microwire Frame Format,?..."
            newline
            rbitfld.long 0x00 5. "RSVD_CTRLR0_5,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 0.--4. "DFS,Data Frame Size" "?,?,?,3: 04-bit serial data transfer,4: 05-bit serial data transfer,5: 06-bit serial data transfer,6: 07-bit serial data transfer,7: 08-bit serial data transfer,8: 09-bit serial data transfer,9: 10-bit serial data transfer,10: 11-bit serial data transfer,11: 12-bit serial data transfer,12: 13-bit serial data transfer,13: 14-bit serial data transfer,14: 15-bit serial data transfer,15: 16-bit serial data transfer,16: 17-bit serial data transfer,17: 18-bit serial data transfer,18: 19-bit serial data transfer,19: 20-bit serial data transfer,20: 21-bit serial data transfer,21: 22-bit serial data transfer,22: 23-bit serial data transfer,23: 24-bit serial data transfer,24: 25-bit serial data transfer,25: 26-bit serial data transfer,26: 27-bit serial data transfer,27: 28-bit serial data transfer,28: 29-bit serial data transfer,29: 30-bit serial data transfer,30: 31-bit serial data transfer,31: 32-bit serial data transfer"
    group.long 0x04++0x03
        line.long 0x00 "CTRLR1,This register exists only when the DWC_ssi is configured as a master device"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_CTRLR1,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 0.--15. 1. "NDF,Number of Data Frames"
    group.long 0x08++0x03
        line.long 0x00 "SSIENR,This register enables and disables the DWC_ssi"
            hexmask.long 0x00 1.--31. 1. "RSVD_SSIENR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "SSIC_EN,SSI Enable" "0: Disables DWC_ssi,1: Enables DWC_ssi"
    group.long 0x0C++0x03
        line.long 0x00 "MWCR,This register controls the direction of the data word for the half-duplex Microwire serial protocol"
            hexmask.long 0x00 3.--31. 1. "RSVD_MWCR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 2. "MHS,Microwire Handshaking" "0: handshaking interface is disabled,1: handshaking interface is enabled"
            newline
            bitfld.long 0x00 1. "MDD,Microwire Control" "0: SSI receives data,1: SSI transmits data"
            newline
            bitfld.long 0x00 0. "MWMOD,Microwire Transfer Mode" "0: Non-Sequential Transfer,1: Sequential Transfer"
    group.long 0x10++0x03
        line.long 0x00 "SER,This register is valid only when the DWC_ssi is configured as a master device"
            hexmask.long 0x00 2.--31. 1. "RSVD_SER,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--1. "SER,Slave Select Enable Flag" "0,1,2,3"
    group.long 0x14++0x03
        line.long 0x00 "BAUDR,This register is valid only when the DWC_ssi is configured as a master device"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_BAUDR_16_31,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 1.--15. 1. "SCKDV,SSI Clock Divider"
            newline
            rbitfld.long 0x00 0. "RSVD_BAUDR_0,Reserved bits - read as zero" "0,1"
    group.long 0x18++0x03
        line.long 0x00 "TXFTLR,This register controls the threshold value for the transmit FIFO memory"
            hexmask.long.word 0x00 19.--31. 1. "RSVD_TXFTHR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 16.--18. "TXFTHR,Transfer start FIFO level" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long.word 0x00 3.--15. 1. "RSVD_TXFTLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--2. "TFT,Transmit FIFO Threshold" "0,1,2,3,4,5,6,7"
    group.long 0x1C++0x03
        line.long 0x00 "RXFTLR,This register controls the threshold value for the receive FIFO memory"
            hexmask.long 0x00 3.--31. 1. "RSVD_RXFTLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--2. "RFT,Receive FIFO Threshold" "0,1,2,3,4,5,6,7"

    rgroup.long 0x20++0x03
        line.long 0x00 "TXFLR,This register contains the number of valid data entries in the transmit FIFO memory"
            hexmask.long 0x00 4.--31. 1. "RSVD_TXFLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--3. "TXTFL,Transmit FIFO Level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    rgroup.long 0x24++0x03
        line.long 0x00 "RXFLR,This register contains the number of valid data entries in the receive FIFO memory"
            hexmask.long 0x00 4.--31. 1. "RSVD_RXFLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--3. "RXTFL,Receive FIFO Level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    rgroup.long 0x28++0x03
        line.long 0x00 "SR,This is a read-only register used to indicate the current transfer status FIFO status and any transmission/reception errors that may have occurred"
            hexmask.long.tbyte 0x00 15.--31. 1. "CMPLTD_DF,Completed Data frames This field indicates total data frames transferred in the previous internal DMA transfer"
            newline
            hexmask.long.byte 0x00 7.--14. 1. "RSVD_SR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 6. "DCOL,Data Collision Error" "0: NO_ERROR_CONDITION,1: Transmit Data Collision Error"
            newline
            bitfld.long 0x00 5. "TXE,Transmission Error" "0: NO_ERROR,1: Transmission Error"
            newline
            bitfld.long 0x00 4. "RFF,Receive FIFO Full" "0: Receive FIFO is not full,1: Receive FIFO is full"
            newline
            bitfld.long 0x00 3. "RFNE,Receive FIFO Not Empty" "0: Receive FIFO is empty,1: Receive FIFO is not empty"
            newline
            bitfld.long 0x00 2. "TFE,Transmit FIFO Empty" "0: Transmit FIFO is not empty,1: Transmit FIFO is empty"
            newline
            bitfld.long 0x00 1. "TFNF,Transmit FIFO Not Full" "0: Tx FIFO is full,1: Tx FIFO is not Full"
            newline
            bitfld.long 0x00 0. "BUSY,SSI Busy Flag" "0: DWC_ssi is idle or disabled,1: DWC_ssi is actively transferring data"

    group.long 0x2C++0x03
        line.long 0x00 "IMR,This read/write register masks or enables all interrupts generated by the DWC_ssi"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_12_32_IMR,Reserved bits - read as zero"
            newline
            rbitfld.long 0x00 11. "DONEM,SSI Done Interrupt Mask" "0: ssi_done_intr interrupt is masked,1: ssi_done_intr interrupt is not masked"
            newline
            rbitfld.long 0x00 10. "SPITEM,SPI Transmit Error Interrupt Mask" "0: ssi_spite_intr interrupt is masked,1: ssi_spite_intr interrupt is not masked"
            newline
            rbitfld.long 0x00 9. "RSVD_9_IMR,Reserved bits - read as zero" "0,1"
            newline
            rbitfld.long 0x00 8. "AXIEM,AXI Error Interrupt Mask" "0: ssi_axie_intr interrupt is masked,1: ssi_axie_intr interrupt is not masked"
            newline
            rbitfld.long 0x00 7. "TXUIM,Transmit FIFO Underflow Interrupt Mask" "0: ssi_txu_intr interrupt is masked,1: ssi_txu_intr interrupt is not masked"
            newline
            rbitfld.long 0x00 6. "XRXOIM,XIP Receive FIFO Overflow Interrupt Mask" "0: ssi_xrxo_intr interrupt is masked,1: ssi_xrxo_intr interrupt is not masked"
            newline
            bitfld.long 0x00 5. "MSTIM,Multi-Master Contention Interrupt Mask" "0: ssi_mst_intr interrupt is masked,1: ssi_mst_intr interrupt is not masked"
            newline
            bitfld.long 0x00 4. "RXFIM,Receive FIFO Full Interrupt Mask" "0: ssi_rxf_intr interrupt is masked,1: ssi_rxf_intr interrupt is not masked"
            newline
            bitfld.long 0x00 3. "RXOIM,Receive FIFO Overflow Interrupt Mask" "0: ssi_rxo_intr interrupt is masked,1: ssi_rxo_intr interrupt is not masked"
            newline
            bitfld.long 0x00 2. "RXUIM,Receive FIFO Underflow Interrupt Mask" "0: ssi_rxu_intr interrupt is masked,1: ssi_rxu_intr interrupt is not masked"
            newline
            bitfld.long 0x00 1. "TXOIM,Transmit FIFO Overflow Interrupt Mask" "0: ssi_txo_intr interrupt is masked,1: ssi_txo_intr interrupt is not masked"
            newline
            bitfld.long 0x00 0. "TXEIM,Transmit FIFO Empty Interrupt Mask" "0: ssi_txe_intr interrupt is masked,1: ssi_txe_intr interrupt is not masked"

    rgroup.long 0x30++0x03
        line.long 0x00 "ISR,This register reports the status of the DWC_ssi interrupts after they have been masked"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_12_32_RISR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 11. "DONES,SSI Done Interrupt Status" "0: ssi_done_intr interrupt is not active after..,1: ssi_done_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 10. "SPITES,SPI Transmit Error Interrupt" "0: ssi_spite_intr interrupt is not active after..,1: ssi_spite_intr interrupt is active after.."
            newline
            bitfld.long 0x00 9. "RSVD_9_RISR,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 8. "AXIES,AXI Error Interrupt Status" "0: ssi_axie_intr interrupt is not active after..,1: ssi_axie_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 7. "TXUIS,Transmit FIFO Underflow Interrupt Status" "0: ssi_txu_intr interrupt is not active after..,1: ssi_txu_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 6. "XRXOIS,XIP Receive FIFO Overflow Interrupt Status" "0: ssi_xrxo_intr interrupt is not active after..,1: ssi_xrxo_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 5. "MSTIS,Multi-Master Contention Interrupt Status" "0: ssi_mst_intr interrupt is not active after..,1: ssi_mst_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 4. "RXFIS,Receive FIFO Full Interrupt Status" "0: ssi_rxf_intr interrupt is not active after..,1: ssi_rxf_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 3. "RXOIS,Receive FIFO Overflow Interrupt Status" "0: ssi_rxo_intr interrupt is not active after..,1: ssi_rxo_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 2. "RXUIS,Receive FIFO Underflow Interrupt Status" "0: ssi_rxu_intr interrupt is not active after..,1: ssi_rxu_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 1. "TXOIS,Transmit FIFO Overflow Interrupt Status" "0: ssi_txo_intr interrupt is not active after..,1: ssi_txo_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 0. "TXEIS,Transmit FIFO Empty Interrupt Status" "0: ssi_txe_intr interrupt is not active after..,1: ssi_txe_intr interrupt is active after masking"
    rgroup.long 0x34++0x03
        line.long 0x00 "RISR,Raw Interrupt Status Register"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_12_32_RISR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 11. "DONER,SSI Done Interrupt Raw Status" "0: ssi_done_intr interrupt is not active prior..,1: ssi_done_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 10. "SPITER,SPI Transmit Error Interrupt status" "0: ssi_spite_intr interrupt is not active prior..,1: ssi_spite_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 9. "RSVD_9_RISR,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 8. "AXIER,AXI Error Interrupt Raw Status" "0: ssi_axie_intr interrupt is not active prior..,1: ssi_axie_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 7. "TXUIR,Transmit FIFO Underflow Interrupt Raw Status" "0: ssi_txu_intr interrupt is not active prior..,1: ssi_txu_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 6. "XRXOIR,XIP Receive FIFO Overflow Raw Interrupt Status" "0: ssi_xrxo_intr interrupt is not active prior..,1: ssi_xrxo_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 5. "MSTIR,Multi-Master Contention Raw Interrupt Status" "0: ssi_mst_intr interrupt is not active prior..,1: ssi_mst_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 4. "RXFIR,Receive FIFO Full Raw Interrupt Status" "0: ssi_rxf_intr interrupt is not active prior..,1: ssi_rxf_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 3. "RXOIR,Receive FIFO Overflow Raw Interrupt Status" "0: ssi_rxo_intr interrupt is not active prior..,1: ssi_rxo_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 2. "RXUIR,Receive FIFO Underflow Raw Interrupt Status" "0: ssi_rxu_intr interrupt is not active prior..,1: ssi_rxu_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 1. "TXOIR,Transmit FIFO Overflow Raw Interrupt Status" "0: ssi_txo_intr interrupt is not active prior..,1: ssi_txo_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 0. "TXEIR,Transmit FIFO Empty Raw Interrupt Status" "0: ssi_txe_intr interrupt is not active prior..,1: ssi_txe_intr interrupt is active prior to.."
    rgroup.long 0x38++0x03
        line.long 0x00 "TXEICR,Transmit FIFO Error Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_TXEICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "TXEICR,Clear Transmit FIFO Overflow/Underflow Interrupt" "0,1"
    rgroup.long 0x3C++0x03
        line.long 0x00 "RXOICR,Receive FIFO Overflow Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_RXOICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "RXOICR,Clear Receive FIFO Overflow Interrupt" "0,1"
    rgroup.long 0x40++0x03
        line.long 0x00 "RXUICR,Receive FIFO Underflow Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_RXUICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "RXUICR,Clear Receive FIFO Underflow Interrupt" "0,1"
    rgroup.long 0x44++0x03
        line.long 0x00 "MSTICR,Multi-Master Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_MSTICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "MSTICR,Clear Multi-Master Contention Interrupt" "0,1"
    rgroup.long 0x48++0x03
        line.long 0x00 "ICR,Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_ICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "ICR,Clear Interrupts" "0,1"

    group.long 0x4C++0x03
        line.long 0x00 "DMACR,DMA Control Register"
            hexmask.long.word 0x00 21.--31. 1. "RSVD_DMACR,Reserved bits - read as zero"
            newline
            rbitfld.long 0x00 15.--20. "AID,AXI awid/arid signal value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            rbitfld.long 0x00 12.--14. "APROT,AXI arprot/awprot signal value" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 8.--11. "ACACHE,AXI arcache/awcache signal value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 7. "RSVD_DMACR7,Reserved bits - read as zero" "0,1"
            newline
            rbitfld.long 0x00 6. "AINC,Address Increment" "0: No Change,1: Increment"
            newline
            rbitfld.long 0x00 5. "RSVD_DMACR5,Reserved bits - read as zero" "0,1"
            newline
            rbitfld.long 0x00 3.--4. "ATW,AXI transfer width for DMA transfers mapped to arsize/awsize" "0: 1 byte,1: 2 bytes,2: 4 bytes,3: 8 bytes"
            newline
            rbitfld.long 0x00 2. "IDMAE,Internal DMA Enable" "0,1"
            newline
            bitfld.long 0x00 1. "TDMAE,Transmit DMA Enable" "0: Transmit DMA disabled,1: Transmit DMA enabled"
            newline
            bitfld.long 0x00 0. "RDMAE,Receive DMA Enable" "0: Receive DMA disabled,1: Receive DMA enabled"
    group.long 0x50++0x03
        line.long 0x00 "DMATDLR,This register is only valid when the DWC_ssi is configured with a set of DMA interface signals (SSIC_HAS_DMA = 1)"
            hexmask.long 0x00 3.--31. 1. "RSVD_DMATDLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--2. "DMATDL,Transmit Data Level" "0,1,2,3,4,5,6,7"
    group.long 0x54++0x03
        line.long 0x00 "DMARDLR,This register is only valid when DWC_ssi is configured with a set of DMA interface signals (SSIC_HAS_DMA = 1)"
            hexmask.long 0x00 3.--31. 1. "RSVD_DMARDLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--2. "DMARDL,Receive Data Level" "0,1,2,3,4,5,6,7"

    rgroup.long 0x58++0x03
        line.long 0x00 "IDR,This register contains the peripherals identification code which is written into the register at configuration time using coreConsultant"
            hexmask.long 0x00 0.--31. 1. "IDCODE,Identification code"
    rgroup.long 0x5C++0x03
        line.long 0x00 "SSIC_VERSION_ID,This read-only register stores the specific DWC_ssi component version"
            hexmask.long 0x00 0.--31. 1. "SSIC_COMP_VERSION,Contains the hex representation of the Synopsys component version"

    group.long 0xF0++0x03
        line.long 0x00 "RX_SAMPLE_DELAY,This register is only valid when the DWC_ssi is configured with rxd sample delay logic (SSIC_HAS_RX_SAMPLE_DELAY==1)"
            hexmask.long.word 0x00 17.--31. 1. "RSVD1_RX_SAMPLE_DLY,Reserved bits - read as zero"
            newline
            rbitfld.long 0x00 16. "SE,Receive Data (rxd) Sampling Edge" "0,1"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "RSVD0_RX_SAMPLE_DLY,Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "RSD,Receive Data (rxd) Sample Delay"
    group.long 0xF4++0x03
        line.long 0x00 "SPI_CTRLR0,This register is used to control the serial data transfer in enhanced SPI mode of operation"
            rbitfld.long 0x00 31. "RSVD_SPI_CTRLR0,Reserved bits - read as zero" "0,1"
            newline
            rbitfld.long 0x00 30. "CLK_STRETCH_EN,Enables clock stretching capability in SPI transfers" "0,1"
            newline
            rbitfld.long 0x00 29. "XIP_PREFETCH_EN,Enables XIP pre-fetch functionality in DWC_ssi" "0,1"
            newline
            rbitfld.long 0x00 28. "RSVD_SPI_CTRLR0_28,Reserved bits - read as zero" "0,1"
            newline
            rbitfld.long 0x00 26.--27. "XIP_MBL,XIP Mode bits length" "0: Mode bits length equal to 2,1: Mode bits length equal to 4,2: Mode bits length equal to 8,3: Mode bits length equal to 16"
            newline
            rbitfld.long 0x00 25. "SPI_RXDS_SIG_EN,Enable rxds signaling during address and command phase of Hypebus transfer" "0,1"
            newline
            rbitfld.long 0x00 24. "SPI_DM_EN,SPI data mask enable bit" "0,1"
            newline
            rbitfld.long 0x00 22.--23. "RSVD_SPI_CTRLR0_22_23,Reserved bits - read as zero" "0,1,2,3"
            newline
            rbitfld.long 0x00 21. "SSIC_XIP_CONT_XFER_EN,Enable continuous transfer in XIP mode" "0,1"
            newline
            rbitfld.long 0x00 20. "XIP_INST_EN,XIP instruction enable bit" "0,1"
            newline
            rbitfld.long 0x00 19. "XIP_DFS_HC,Fix DFS for XIP transfers" "0,1"
            newline
            rbitfld.long 0x00 18. "SPI_RXDS_EN,Read data strobe enable bit" "0,1"
            newline
            rbitfld.long 0x00 17. "INST_DDR_EN,Instruction DDR Enable bit" "0,1"
            newline
            rbitfld.long 0x00 16. "SPI_DDR_EN,SPI DDR Enable bit" "0,1"
            newline
            bitfld.long 0x00 11.--15. "WAIT_CYCLES,Wait cycles in Dual/Quad/Octal mode between control frames transmit and data reception" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            rbitfld.long 0x00 10. "RSVD_SPI_CTRLR0_10,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 8.--9. "INST_L,Dual/Quad/Octal mode instruction length in bits" "0: No Instruction,1: 4 bit Instruction length,2: 8 bit Instruction length,3: 16 bit Instruction length"
            newline
            rbitfld.long 0x00 7. "XIP_MD_BIT_EN,Mode bits enable in XIP mode" "0,1"
            newline
            rbitfld.long 0x00 6. "RSVD_SPI_CTRLR0_6,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 2.--5. "ADDR_L,This bit defines Length of Address to be transmitted" "0: No Address,1: 4 bit Address length,2: 8 bit Address length,3: 12 bit Address length,4: 16 bit Address length,5: 20 bit Address length,6: 24 bit Address length,7: 28 bit Address length,8: 32 bit Address length,9: 36 bit Address length,10: 40 bit Address length,11: 44 bit Address length,12: 48 bit Address length,13: 52 bit Address length,14: 56 bit Address length,15: 60 bit Address length"
            newline
            bitfld.long 0x00 0.--1. "TRANS_TYPE,Address and instruction transfer format" "0: Instruction and Address will be sent in..,1: Instruction will be sent in Standard SPI Mode..,2: Both Instruction and Address will be sent in..,3: Reserved"
tree.end

tree "QSPI_MMIC ()"
    base ad:0x88000000
    group.long 0x00++0x03
        line.long 0x00 "CTRLR0,This register controls the serial data transfer"
            rbitfld.long 0x00 31. "SSI_IS_MST,This field selects if DWC_ssi is working in Controller or Target mode" "0: DWC_ssi is Target,1: DWC_ssi is Controller"
            newline
            rbitfld.long 0x00 27.--30. "RSVD_CTRLR0_27_30,Reserved bits - read as zero" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 26. "CLK_LOOP_EN,Clock loop back enable bit" "0: Disable Clock Loop Back,1: Enable Clock Loop Back"
            newline
            rbitfld.long 0x00 25. "SPI_DWS_EN,Enable Dynamic wait states in SPI mode of operation" "0: Disable SPI Dynamic Wait State,1: Enable SPI Dynamic Wait State"
            newline
            rbitfld.long 0x00 24. "SPI_HYPERBUS_EN,SPI Hyperbus Frame format enable" "0: Disable Hyperbus Format,1: Enable Hyperbus Format"
            newline
            bitfld.long 0x00 22.--23. "SPI_FRF,SPI Frame Format Selects data frame format for Transmitting/Receiving the data" "0: Standard SPI Format,1: Dual SPI Format,2: Quad SPI Format,3: Octal SPI Format"
            newline
            rbitfld.long 0x00 20.--21. "RSVD_CTRLR0_20_21,Reserved bits - read as zero" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--19. "CFS,Control Frame Size" "0: 01-bit Control Word,1: 02-bit Control Word,2: 03-bit Control Word,3: 04-bit Control Word,4: 05-bit Control Word,5: 06-bit Control Word,6: 07-bit Control Word,7: 08-bit Control Word,8: 09-bit Control Word,9: 10-bit Control Word,10: 11-bit Control Word,11: 12-bit Control Word,12: 13-bit Control Word,13: 14-bit Control Word,14: 15-bit Control Word,15: 16-bit Control Word"
            newline
            rbitfld.long 0x00 15. "RSVD_CTRLR0_15,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 14. "SSTE,Target Select Toggle Enable" "0: ss_*_n will stay low and sclk will run..,1: ss_*_n line will toggle between consecutive.."
            newline
            bitfld.long 0x00 13. "SRL,Shift Register Loop" "0: Normal mode operation,1: Test Mode Operation"
            newline
            bitfld.long 0x00 12. "SLV_OE,Target Output Enable" "0: Target Output is enabled,1: Target Output is disabled"
            newline
            bitfld.long 0x00 10.--11. "TMOD,Transfer Mode" "0: Transmit & Receive Not Applicable in enhanced..,1: Transmit only mode Or Write in enhanced SPI..,2: Receive only mode Or Read in enhanced SPI..,3: EEPROM Read mode Not Applicable in enhanced.."
            newline
            bitfld.long 0x00 9. "SCPOL,Serial Clock Polarity" "0: Inactive state of serial clock is low,1: Inactive state of serial clock is high"
            newline
            bitfld.long 0x00 8. "SCPH,Serial Clock Phase" "0: Serial clock toggles in middle of first bit,1: Serial clock toggles at start of first bit"
            newline
            bitfld.long 0x00 6.--7. "FRF,Frame Format" "0: Motorola SPI Frame Format,1: Texas Instruments SSP Frame Format,2: National Semiconductors Microwire Frame Format,?..."
            newline
            rbitfld.long 0x00 5. "RSVD_CTRLR0_5,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 0.--4. "DFS,Data Frame Size" "?,?,?,3: 04-bit serial data transfer,4: 05-bit serial data transfer,5: 06-bit serial data transfer,6: 07-bit serial data transfer,7: 08-bit serial data transfer,8: 09-bit serial data transfer,9: 10-bit serial data transfer,10: 11-bit serial data transfer,11: 12-bit serial data transfer,12: 13-bit serial data transfer,13: 14-bit serial data transfer,14: 15-bit serial data transfer,15: 16-bit serial data transfer,16: 17-bit serial data transfer,17: 18-bit serial data transfer,18: 19-bit serial data transfer,19: 20-bit serial data transfer,20: 21-bit serial data transfer,21: 22-bit serial data transfer,22: 23-bit serial data transfer,23: 24-bit serial data transfer,24: 25-bit serial data transfer,25: 26-bit serial data transfer,26: 27-bit serial data transfer,27: 28-bit serial data transfer,28: 29-bit serial data transfer,29: 30-bit serial data transfer,30: 31-bit serial data transfer,31: 32-bit serial data transfer"
    group.long 0x04++0x03
        line.long 0x00 "CTRLR1,This register exists only when the DWC_ssi is configured as a controller device"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_CTRLR1,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 0.--15. 1. "NDF,Number of Data Frames"
    group.long 0x08++0x03
        line.long 0x00 "SSIENR,This register enables and disables the DWC_ssi"
            hexmask.long 0x00 1.--31. 1. "RSVD_SSIENR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "SSIC_EN,SSI Enable" "0: Disables DWC_ssi,1: Enables DWC_ssi"
    group.long 0x0C++0x03
        line.long 0x00 "MWCR,This register controls the direction of the data word for the half-duplex Microwire serial protocol"
            hexmask.long 0x00 3.--31. 1. "RSVD_MWCR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 2. "MHS,Microwire Handshaking" "0: handshaking interface is disabled,1: handshaking interface is enabled"
            newline
            bitfld.long 0x00 1. "MDD,Microwire Control" "0: SSI receives data,1: SSI transmits data"
            newline
            bitfld.long 0x00 0. "MWMOD,Microwire Transfer Mode" "0: Non-Sequential Transfer,1: Sequential Transfer"
    group.long 0x10++0x03
        line.long 0x00 "SER,This register is valid only when the DWC_ssi is configured as a controller device"
            hexmask.long 0x00 1.--31. 1. "RSVD_SER,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "SER,Chip Select Enable Flag" "0,1"
    group.long 0x14++0x03
        line.long 0x00 "BAUDR,This register is valid only when the DWC_ssi is configured as a controller device"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_BAUDR_16_31,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 1.--15. 1. "SCKDV,SSI Clock Divider"
            newline
            rbitfld.long 0x00 0. "RSVD_BAUDR_0,Reserved bits - read as zero" "0,1"
    group.long 0x18++0x03
        line.long 0x00 "TXFTLR,This register controls the threshold value for the transmit FIFO memory"
            hexmask.long.word 0x00 23.--31. 1. "RSVD_TXFTHR,Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 16.--22. 1. "TXFTHR,Transfer start FIFO level"
            newline
            hexmask.long.word 0x00 4.--15. 1. "RSVD_TXFTLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--3. "TFT,Transmit FIFO Threshold" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x1C++0x03
        line.long 0x00 "RXFTLR,This register controls the threshold value for the receive FIFO memory"
            hexmask.long 0x00 4.--31. 1. "RSVD_RXFTLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--3. "RFT,Receive FIFO Threshold" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x20++0x03
        line.long 0x00 "TXFLR,This register contains the number of valid data entries in the transmit FIFO memory"
            hexmask.long 0x00 5.--31. 1. "RSVD_TXFLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--4. "TXTFL,Transmit FIFO Level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    rgroup.long 0x24++0x03
        line.long 0x00 "RXFLR,This register contains the number of valid data entries in the receive FIFO memory"
            hexmask.long 0x00 5.--31. 1. "RSVD_RXFLR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0.--4. "RXTFL,Receive FIFO Level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    rgroup.long 0x28++0x03
        line.long 0x00 "SR,This is a read-only register used to indicate the current transfer status FIFO status and any transmission/reception errors that may have occurred"
            hexmask.long.tbyte 0x00 15.--31. 1. "CMPLTD_DF,Completed Data frames This field indicates total data frames transferred in the previous internal DMA transfer"
            newline
            hexmask.long.byte 0x00 7.--14. 1. "RSVD_SR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 6. "DCOL,Data Collision Error" "0: NO_ERROR_CONDITION,1: Transmit Data Collision Error"
            newline
            bitfld.long 0x00 5. "TXE,Transmission Error" "0: NO_ERROR,1: Transmission Error"
            newline
            bitfld.long 0x00 4. "RFF,Receive FIFO Full" "0: Receive FIFO is not full,1: Receive FIFO is full"
            newline
            bitfld.long 0x00 3. "RFNE,Receive FIFO Not Empty" "0: Receive FIFO is empty,1: Receive FIFO is not empty"
            newline
            bitfld.long 0x00 2. "TFE,Transmit FIFO Empty" "0: Transmit FIFO is not empty,1: Transmit FIFO is empty"
            newline
            bitfld.long 0x00 1. "TFNF,Transmit FIFO Not Full" "0: Tx FIFO is full,1: Tx FIFO is not Full"
            newline
            bitfld.long 0x00 0. "BUSY,SSI Busy Flag" "0: DWC_ssi is idle or disabled,1: DWC_ssi is actively transferring data"

    group.long 0x2C++0x03
        line.long 0x00 "IMR,This read/write register masks or enables all interrupts generated by the DWC_ssi"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_12_31_IMR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 11. "DONEM,SSI Done Interrupt Mask" "0: ssi_done_intr interrupt is masked,1: ssi_done_intr interrupt is not masked"
            newline
            rbitfld.long 0x00 10. "SPITEM,SPI Transmit Error Interrupt Mask" "0: ssi_spite_intr interrupt is masked,1: ssi_spite_intr interrupt is not masked"
            newline
            rbitfld.long 0x00 9. "RSVD_9_IMR,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 8. "AXIEM,AXI Error Interrupt Mask" "0: ssi_axie_intr interrupt is masked,1: ssi_axie_intr interrupt is not masked"
            newline
            bitfld.long 0x00 7. "TXUIM,Transmit FIFO Underflow Interrupt Mask" "0: ssi_txu_intr interrupt is masked,1: ssi_txu_intr interrupt is not masked"
            newline
            rbitfld.long 0x00 6. "XRXOIM,XIP Receive FIFO Overflow Interrupt Mask" "0: ssi_xrxo_intr interrupt is masked,1: ssi_xrxo_intr interrupt is not masked"
            newline
            bitfld.long 0x00 5. "MSTIM,Multi-Controller Contention Interrupt Mask" "0: ssi_mst_intr interrupt is masked,1: ssi_mst_intr interrupt is not masked"
            newline
            bitfld.long 0x00 4. "RXFIM,Receive FIFO Full Interrupt Mask" "0: ssi_rxf_intr interrupt is masked,1: ssi_rxf_intr interrupt is not masked"
            newline
            bitfld.long 0x00 3. "RXOIM,Receive FIFO Overflow Interrupt Mask" "0: ssi_rxo_intr interrupt is masked,1: ssi_rxo_intr interrupt is not masked"
            newline
            bitfld.long 0x00 2. "RXUIM,Receive FIFO Underflow Interrupt Mask" "0: ssi_rxu_intr interrupt is masked,1: ssi_rxu_intr interrupt is not masked"
            newline
            bitfld.long 0x00 1. "TXOIM,Transmit FIFO Overflow Interrupt Mask" "0: ssi_txo_intr interrupt is masked,1: ssi_txo_intr interrupt is not masked"
            newline
            bitfld.long 0x00 0. "TXEIM,Transmit FIFO Empty Interrupt Mask" "0: ssi_txe_intr interrupt is masked,1: ssi_txe_intr interrupt is not masked"

    rgroup.long 0x30++0x03
        line.long 0x00 "ISR,This register reports the status of the DWC_ssi interrupts after they have been masked"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_12_31_RISR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 11. "DONES,SSI Done Interrupt Status" "0: ssi_done_intr interrupt is not active after..,1: ssi_done_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 10. "SPITES,SPI Transmit Error Interrupt" "0: ssi_spite_intr interrupt is not active after..,1: ssi_spite_intr interrupt is active after.."
            newline
            bitfld.long 0x00 9. "RSVD_9_RISR,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 8. "AXIES,AXI Error Interrupt Status" "0: ssi_axie_intr interrupt is not active after..,1: ssi_axie_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 7. "TXUIS,Transmit FIFO Underflow Interrupt Status" "0: ssi_txu_intr interrupt is not active after..,1: ssi_txu_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 6. "XRXOIS,XIP Receive FIFO Overflow Interrupt Status" "0: ssi_xrxo_intr interrupt is not active after..,1: ssi_xrxo_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 5. "MSTIS,Multi-Controller Contention Interrupt Status" "0: ssi_mst_intr interrupt is not active after..,1: ssi_mst_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 4. "RXFIS,Receive FIFO Full Interrupt Status" "0: ssi_rxf_intr interrupt is not active after..,1: ssi_rxf_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 3. "RXOIS,Receive FIFO Overflow Interrupt Status" "0: ssi_rxo_intr interrupt is not active after..,1: ssi_rxo_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 2. "RXUIS,Receive FIFO Underflow Interrupt Status" "0: ssi_rxu_intr interrupt is not active after..,1: ssi_rxu_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 1. "TXOIS,Transmit FIFO Overflow Interrupt Status" "0: ssi_txo_intr interrupt is not active after..,1: ssi_txo_intr interrupt is active after masking"
            newline
            bitfld.long 0x00 0. "TXEIS,Transmit FIFO Empty Interrupt Status" "0: ssi_txe_intr interrupt is not active after..,1: ssi_txe_intr interrupt is active after masking"
    rgroup.long 0x34++0x03
        line.long 0x00 "RISR,Raw Interrupt Status Register"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_12_31_RISR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 11. "DONER,SSI Done Interrupt Raw Status" "0: ssi_done_intr interrupt is not active prior..,1: ssi_done_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 10. "SPITER,SPI Transmit Error Interrupt status" "0: ssi_spite_intr interrupt is not active prior..,1: ssi_spite_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 9. "RSVD_9_RISR,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 8. "AXIER,AXI Error Interrupt Raw Status" "0: ssi_axie_intr interrupt is not active prior..,1: ssi_axie_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 7. "TXUIR,Transmit FIFO Underflow Interrupt Raw Status" "0: ssi_txu_intr interrupt is not active prior..,1: ssi_txu_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 6. "XRXOIR,XIP Receive FIFO Overflow Raw Interrupt Status" "0: ssi_xrxo_intr interrupt is not active prior..,1: ssi_xrxo_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 5. "MSTIR,Multi-Controller Contention Raw Interrupt Status" "0: ssi_mst_intr interrupt is not active prior..,1: ssi_mst_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 4. "RXFIR,Receive FIFO Full Raw Interrupt Status" "0: ssi_rxf_intr interrupt is not active prior..,1: ssi_rxf_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 3. "RXOIR,Receive FIFO Overflow Raw Interrupt Status" "0: ssi_rxo_intr interrupt is not active prior..,1: ssi_rxo_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 2. "RXUIR,Receive FIFO Underflow Raw Interrupt Status" "0: ssi_rxu_intr interrupt is not active prior..,1: ssi_rxu_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 1. "TXOIR,Transmit FIFO Overflow Raw Interrupt Status" "0: ssi_txo_intr interrupt is not active prior..,1: ssi_txo_intr interrupt is active prior to.."
            newline
            bitfld.long 0x00 0. "TXEIR,Transmit FIFO Empty Raw Interrupt Status" "0: ssi_txe_intr interrupt is not active prior..,1: ssi_txe_intr interrupt is active prior to.."
    rgroup.long 0x38++0x03
        line.long 0x00 "TXEICR,Transmit FIFO Error Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_TXEICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "TXEICR,Clear Transmit FIFO Overflow/Underflow Interrupt" "0,1"
    rgroup.long 0x3C++0x03
        line.long 0x00 "RXOICR,Receive FIFO Overflow Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_RXOICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "RXOICR,Clear Receive FIFO Overflow Interrupt" "0,1"
    rgroup.long 0x40++0x03
        line.long 0x00 "RXUICR,Receive FIFO Underflow Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_RXUICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "RXUICR,Clear Receive FIFO Underflow Interrupt" "0,1"
    rgroup.long 0x44++0x03
        line.long 0x00 "MSTICR,Multi-Controller Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_MSTICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "MSTICR,Clear Multi-Controller Contention Interrupt" "0,1"
    rgroup.long 0x48++0x03
        line.long 0x00 "ICR,Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_ICR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 0. "ICR,Clear Interrupts" "0,1"

    group.long 0x4C++0x03
        line.long 0x00 "DMACR,DMA Control Register"
            hexmask.long.word 0x00 21.--31. 1. "RSVD_DMACR,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 15.--20. "AID,AXI awid/arid signal value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 12.--14. "APROT,AXI arprot/awprot signal value" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 8.--11. "ACACHE,AXI arcache/awcache signal value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 7. "RSVD_DMACR7,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 6. "AINC,Address Increment" "0: No Change,1: Increment"
            newline
            rbitfld.long 0x00 5. "RSVD_DMACR5,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 3.--4. "ATW,AXI transfer width for DMA transfers mapped to arsize/awsize" "0: 1 byte,1: 2 bytes,2: 4 bytes,3: 8 bytes"
            newline
            bitfld.long 0x00 2. "IDMAE,Internal DMA Enable" "0,1"
            newline
            rbitfld.long 0x00 1. "TDMAE,Transmit DMA Enable" "0: Transmit DMA disabled,1: Transmit DMA enabled"
            newline
            rbitfld.long 0x00 0. "RDMAE,Receive DMA Enable" "0: Receive DMA disabled,1: Receive DMA enabled"
    group.long 0x50++0x03
        line.long 0x00 "AXIAWLEN,Destination Burst Length"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_AXIAWLEN2,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 8.--11. "AWLEN,Destination Burst Length" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "RSVD_AXIAWLEN,Reserved bits - read as zero"
    group.long 0x54++0x03
        line.long 0x00 "AXIARLEN,Source Burst Length"
            hexmask.long.tbyte 0x00 12.--31. 1. "RSVD_AXIARLEN2,Reserved bits - read as zero"
            newline
            bitfld.long 0x00 8.--11. "ARLEN,Source Burst Length" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "RSVD_AXIARLEN,Reserved bits - read as zero"

    rgroup.long 0x58++0x03
        line.long 0x00 "IDR,This register contains the peripherals identification code which is written into the register at configuration time using coreConsultant"
            hexmask.long 0x00 0.--31. 1. "IDCODE,Identification code"
    rgroup.long 0x5C++0x03
        line.long 0x00 "SSIC_VERSION_ID,This read-only register stores the specific DWC_ssi component version"
            hexmask.long 0x00 0.--31. 1. "SSIC_COMP_VERSION,Contains the hex representation of the Synopsys component version"

    group.long 0xF0++0x03
        line.long 0x00 "RX_SAMPLE_DELAY,This register is only valid when the DWC_ssi is configured with rxd sample delay logic (SSIC_HAS_RX_SAMPLE_DELAY!=0)"
            hexmask.long.word 0x00 17.--31. 1. "RSVD1_RX_SAMPLE_DELAY,Reserved bits - read as zero"
            newline
            rbitfld.long 0x00 16. "SE,Receive Data (rxd) Sampling Edge" "0,1"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "RSVD0_RX_SAMPLE_DELAY,Reserved bits - read as zero"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "RSD,Receive Data (rxd) Sample Delay"
    group.long 0xF4++0x03
        line.long 0x00 "SPI_CTRLR0,This register is used to control the serial data transfer in enhanced SPI mode of operation"
            rbitfld.long 0x00 31. "RSVD_SPI_CTRLR0,Reserved bits - read as zero" "0,1"
            newline
            rbitfld.long 0x00 30. "CLK_STRETCH_EN,Enables clock stretching capability in SPI transfers" "0,1"
            newline
            rbitfld.long 0x00 29. "XIP_PREFETCH_EN,Enables XIP pre-fetch functionality in DWC_ssi" "0,1"
            newline
            rbitfld.long 0x00 28. "RSVD_SPI_CTRLR0_28,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 26.--27. "XIP_MBL,XIP Mode bits length" "0: Mode bits length equal to 2,1: Mode bits length equal to 4,2: Mode bits length equal to 8,3: Mode bits length equal to 16"
            newline
            rbitfld.long 0x00 25. "SPI_RXDS_SIG_EN,Enable rxds signaling during address and command phase of Hyperbus transfer" "0,1"
            newline
            rbitfld.long 0x00 24. "SPI_DM_EN,SPI data mask enable bit" "0,1"
            newline
            rbitfld.long 0x00 23. "RXDS_VL_EN,RXDS variable latency enable bit" "0,1"
            newline
            rbitfld.long 0x00 22. "RSVD_SPI_CTRLR0_22,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 21. "SSIC_XIP_CONT_XFER_EN,Enable continuous transfer in XIP mode" "0,1"
            newline
            bitfld.long 0x00 20. "XIP_INST_EN,XIP instruction enable bit" "0,1"
            newline
            bitfld.long 0x00 19. "XIP_DFS_HC,Fix DFS for XIP transfers" "0,1"
            newline
            rbitfld.long 0x00 18. "SPI_RXDS_EN,Read data strobe enable bit" "0,1"
            newline
            rbitfld.long 0x00 17. "INST_DDR_EN,Instruction DDR Enable bit" "0,1"
            newline
            rbitfld.long 0x00 16. "SPI_DDR_EN,SPI DDR Enable bit" "0,1"
            newline
            bitfld.long 0x00 11.--15. "WAIT_CYCLES,Wait cycles in Enhanced SPI mode between control frames transmit and data reception" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            rbitfld.long 0x00 10. "RSVD_SPI_CTRLR0_10,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 8.--9. "INST_L,Enhanced SPI mode instruction length in bits" "0: No Instruction,1: 4 bit Instruction length,2: 8 bit Instruction length,3: 16 bit Instruction length"
            newline
            bitfld.long 0x00 7. "XIP_MD_BIT_EN,Mode bits enable in XIP mode" "0,1"
            newline
            rbitfld.long 0x00 6. "RSVD_SPI_CTRLR0_6,Reserved bits - read as zero" "0,1"
            newline
            bitfld.long 0x00 2.--5. "ADDR_L,This bit defines Length of Address to be transmitted" "0: No Address,1: 4 bit Address length,2: 8 bit Address length,3: 12 bit Address length,4: 16 bit Address length,5: 20 bit Address length,6: 24 bit Address length,7: 28 bit Address length,8: 32 bit Address length,9: 36 bit Address length,10: 40 bit Address length,11: 44 bit Address length,12: 48 bit Address length,13: 52 bit Address length,14: 56 bit Address length,15: 60 bit Address length"
            newline
            bitfld.long 0x00 0.--1. "TRANS_TYPE,Address and instruction transfer format" "0: Instruction and Address will be sent in..,1: Instruction will be sent in Standard SPI Mode..,2: Both Instruction and Address will be sent in..,3: Dual Octal mode the address and instruction.."
    group.long 0xFC++0x03
        line.long 0x00 "XIP_MODE_BITS,This register carries the mode bits which are sent in the XIP mode of operation after address phase"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_XIP_MD_BITS,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 0.--15. 1. "XIP_MD_BITS,XIP mode bits to be sent after address phase of XIP transfer"
    group.long 0x100++0x03
        line.long 0x00 "XIP_INCR_INST,This Register is valid only when SSIC_XIP_EN is equal to 1"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_INCR_INST,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 0.--15. 1. "INCR_INST,XIP INCR transfer opcode"
    group.long 0x104++0x03
        line.long 0x00 "XIP_WRAP_INST,This Register is valid only when SSIC_XIP_EN is equal to 1"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_WRAP_INST,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 0.--15. 1. "WRAP_INST,XIP WRAP transfer opcode"
    group.long 0x118++0x03
        line.long 0x00 "SPI_CTRLR1,SPI Control register 1 is used to control serial transfers in SPI mode of operation"
            hexmask.long.word 0x00 20.--31. 1. "RSVD_SPI_CTRLR1_20_31,Reserved bits - Read Only"
            newline
            bitfld.long 0x00 16.--19. "CS_MIN_HIGH,Chip-Select Minimum HIGH period" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 12.--15. "RSVD_SPI_CTRLR1_12_15,Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 8.--11. "MAX_WS,Maximum wait cycles allowed per transaction" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 3.--7. "RSVD_SPI_CTRLR1_3_7,Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 0.--2. "DYN_WS,SPI Dynamic Wait states field" "0,1,2,3,4,5,6,7"
    group.long 0x120++0x03
        line.long 0x00 "SPIDR,SPI Device Register"
            hexmask.long.word 0x00 16.--31. 1. "RSVD_SPIDR,Reserved bits - read as zero"
            newline
            hexmask.long.word 0x00 0.--15. 1. "SPI_INST,SPI Instruction code"
    group.long 0x124++0x03
        line.long 0x00 "SPIAR,SPI Device Address Register"
            hexmask.long 0x00 0.--31. 1. "SDAR,SPI Device Address Register"
    group.long 0x128++0x03
        line.long 0x00 "AXIAR0,AXI Address Register 0"
            hexmask.long 0x00 0.--31. 1. "AXIAR_0_31,LSB for AXI address for DMA operation"

    rgroup.long 0x130++0x03
        line.long 0x00 "AXIECR,AXI Manager Error Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_AXIECR,Reserved bit"
            newline
            bitfld.long 0x00 0. "AXIECR,Clear AXI Error Interrupt" "0,1"
    rgroup.long 0x134++0x03
        line.long 0x00 "DONECR,Transfer Done Clear Interrupt Clear Register"
            hexmask.long 0x00 1.--31. 1. "RSVD_DONECR,Reserved bit"
            newline
            bitfld.long 0x00 0. "DONECR,Clear Transfer Done Interrupt" "0,1"
tree.end

tree "RA ()"
    base ad:0x844C0000
    rgroup.long 0x00++0x03
        line.long 0x00 "ID_VERSION,RA IP Version"
            hexmask.long.byte 0x00 16.--23. 1. "ID_VERSION_MAJOR,RA IP version Major number"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "ID_VERSION_MINOR,RA IP version Minor number"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "ID_VERSION_PATCH,RA IP version Patch number"

    group.long 0x04++0x03
        line.long 0x00 "CONTROL,Control register"
            bitfld.long 0x00 28. "CMD_B2B_MODE_ENA,Enables back to back commands execution in the processing stage" "0,1"
            newline
            bitfld.long 0x00 27. "FORCE_CIMEM4_AHB,Force the CI coefficients memory 4 access via ahb even if the RA is reading from it" "0,1"
            newline
            bitfld.long 0x00 26. "FORCE_CIMEM3_AHB,Force the CI coefficients memory 3 access via ahb even if the RA is reading from it" "0,1"
            newline
            bitfld.long 0x00 25. "FORCE_CIMEM2_AHB,Force the CI coefficients memory 2 access via ahb even if the RA is reading from it" "0,1"
            newline
            bitfld.long 0x00 24. "FORCE_CIMEM1_AHB,Force the CI coefficients memory 1 access via ahb even if the RA is reading from it" "0,1"
            newline
            bitfld.long 0x00 23. "FORCE_ESTMEM_4_AHB,Force the estimator 4 memory access via ahb even if the RA is reading from it" "0,1"
            newline
            bitfld.long 0x00 22. "FORCE_ESTMEM_3_AHB,Force the estimator 3 memory access via ahb even if the RA is reading from it" "0,1"
            newline
            bitfld.long 0x00 21. "FORCE_ESTMEM_2_AHB,Force the estimator 2 memory access via ahb even if the RA is reading from it" "0,1"
            newline
            bitfld.long 0x00 20. "FORCE_ESTMEM_1_AHB,Force the estimator 1 memory access via ahb even if the RA is reading from it" "0,1"
            newline
            bitfld.long 0x00 19. "FORCE_PHMEM_AHB,Force the preposprocessor phase memory access via ahb even if the RA is reading from it" "0,1"
            newline
            bitfld.long 0x00 18. "FORCE_IDXMEM_AHB,Force the preposprocessor index memory access via ahb even if the RA is reading from it" "0,1"
            newline
            bitfld.long 0x00 17. "FORCE_WCMEM_AHB,Force the window coefficients memory access via ahb even if the RA is reading from it" "0,1"
            newline
            bitfld.long 0x00 16. "FORCE_CQMEM_AHB,Force the command queue memory access via ahb even if the RA is reading from it" "0,1"
            newline
            bitfld.long 0x00 14. "SW_TRIG,Trigger RA execution" "0,1"
            newline
            bitfld.long 0x00 3. "QUEUE_RESET,Reset the FIFO pointers and sets the FIFO to empty state" "0,1"
            newline
            bitfld.long 0x00 2. "QUEUE_BYPASS,Puts the cmd memory read pointer to location zero and asserts the command valid bit" "0,1"
            newline
            bitfld.long 0x00 1. "QUEUE_DIS,Disable command queue operation" "0,1"
            newline
            bitfld.long 0x00 0. "ENA,Enable/disable the accelerator data processing" "0,1"
    group.long 0x08++0x03
        line.long 0x00 "CMD_PUSH,Command push register"
            bitfld.long 0x00 8.--13. "CMD_IDX,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x0C++0x03
        line.long 0x00 "CMD_PUSH_1,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_1,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_1,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x10++0x03
        line.long 0x00 "CMD_PUSH_2,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_2,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_2,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x14++0x03
        line.long 0x00 "CMD_PUSH_3,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_3,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_3,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x18++0x03
        line.long 0x00 "CMD_PUSH_4,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_4,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_4,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1C++0x03
        line.long 0x00 "CMD_PUSH_5,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_5,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_5,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x20++0x03
        line.long 0x00 "CMD_PUSH_6,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_6,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_6,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x24++0x03
        line.long 0x00 "CMD_PUSH_7,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_7,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_7,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x28++0x03
        line.long 0x00 "CMD_PUSH_8,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_8,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_8,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x2C++0x03
        line.long 0x00 "CMD_PUSH_9,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_9,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_9,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x30++0x03
        line.long 0x00 "CMD_PUSH_10,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_10,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_10,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x34++0x03
        line.long 0x00 "CMD_PUSH_11,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_11,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_11,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x38++0x03
        line.long 0x00 "CMD_PUSH_12,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_12,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_12,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x3C++0x03
        line.long 0x00 "CMD_PUSH_13,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_13,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_13,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x40++0x03
        line.long 0x00 "CMD_PUSH_14,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_14,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_14,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x44++0x03
        line.long 0x00 "CMD_PUSH_15,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_15,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_15,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x48++0x03
        line.long 0x00 "CMD_PUSH_16,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_16,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_16,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x4C++0x03
        line.long 0x00 "CMD_PUSH_17,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_17,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_17,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x50++0x03
        line.long 0x00 "CMD_PUSH_18,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_18,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_18,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x54++0x03
        line.long 0x00 "CMD_PUSH_19,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_19,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_19,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x58++0x03
        line.long 0x00 "CMD_PUSH_20,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_20,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_20,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x5C++0x03
        line.long 0x00 "CMD_PUSH_21,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_21,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_21,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x60++0x03
        line.long 0x00 "CMD_PUSH_22,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_22,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_22,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x64++0x03
        line.long 0x00 "CMD_PUSH_23,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_23,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_23,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x68++0x03
        line.long 0x00 "CMD_PUSH_24,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_24,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_24,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x6C++0x03
        line.long 0x00 "CMD_PUSH_25,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_25,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_25,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x70++0x03
        line.long 0x00 "CMD_PUSH_26,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_26,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_26,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x74++0x03
        line.long 0x00 "CMD_PUSH_27,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_27,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_27,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x78++0x03
        line.long 0x00 "CMD_PUSH_28,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_28,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_28,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x7C++0x03
        line.long 0x00 "CMD_PUSH_29,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_29,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_29,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x80++0x03
        line.long 0x00 "CMD_PUSH_30,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_30,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_30,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x84++0x03
        line.long 0x00 "CMD_PUSH_31,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_31,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_31,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x88++0x03
        line.long 0x00 "CMD_PUSH_32,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_32,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_32,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x8C++0x03
        line.long 0x00 "CMD_PUSH_33,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_33,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_33,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x90++0x03
        line.long 0x00 "CMD_PUSH_34,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_34,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_34,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x94++0x03
        line.long 0x00 "CMD_PUSH_35,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_35,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_35,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x98++0x03
        line.long 0x00 "CMD_PUSH_36,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_36,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_36,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x9C++0x03
        line.long 0x00 "CMD_PUSH_37,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_37,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_37,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xA0++0x03
        line.long 0x00 "CMD_PUSH_38,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_38,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_38,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xA4++0x03
        line.long 0x00 "CMD_PUSH_39,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_39,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_39,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xA8++0x03
        line.long 0x00 "CMD_PUSH_40,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_40,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_40,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xAC++0x03
        line.long 0x00 "CMD_PUSH_41,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_41,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_41,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xB0++0x03
        line.long 0x00 "CMD_PUSH_42,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_42,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_42,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xB4++0x03
        line.long 0x00 "CMD_PUSH_43,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_43,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_43,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xB8++0x03
        line.long 0x00 "CMD_PUSH_44,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_44,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_44,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xBC++0x03
        line.long 0x00 "CMD_PUSH_45,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_45,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_45,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xC0++0x03
        line.long 0x00 "CMD_PUSH_46,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_46,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_46,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xC4++0x03
        line.long 0x00 "CMD_PUSH_47,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_47,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_47,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xC8++0x03
        line.long 0x00 "CMD_PUSH_48,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_48,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_48,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xCC++0x03
        line.long 0x00 "CMD_PUSH_49,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_49,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_49,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xD0++0x03
        line.long 0x00 "CMD_PUSH_50,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_50,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_50,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xD4++0x03
        line.long 0x00 "CMD_PUSH_51,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_51,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_51,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xD8++0x03
        line.long 0x00 "CMD_PUSH_52,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_52,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_52,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xDC++0x03
        line.long 0x00 "CMD_PUSH_53,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_53,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_53,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xE0++0x03
        line.long 0x00 "CMD_PUSH_54,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_54,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_54,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xE4++0x03
        line.long 0x00 "CMD_PUSH_55,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_55,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_55,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xE8++0x03
        line.long 0x00 "CMD_PUSH_56,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_56,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_56,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xEC++0x03
        line.long 0x00 "CMD_PUSH_57,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_57,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_57,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xF0++0x03
        line.long 0x00 "CMD_PUSH_58,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_58,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_58,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xF4++0x03
        line.long 0x00 "CMD_PUSH_59,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_59,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_59,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xF8++0x03
        line.long 0x00 "CMD_PUSH_60,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_60,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_60,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0xFC++0x03
        line.long 0x00 "CMD_PUSH_61,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_61,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_61,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x100++0x03
        line.long 0x00 "CMD_PUSH_62,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_62,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_62,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x104++0x03
        line.long 0x00 "CMD_PUSH_63,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_63,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_63,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x108++0x03
        line.long 0x00 "CMD_PUSH_64,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_64,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_64,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x10C++0x03
        line.long 0x00 "CMD_PUSH_65,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_65,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_65,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x110++0x03
        line.long 0x00 "CMD_PUSH_66,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_66,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_66,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x114++0x03
        line.long 0x00 "CMD_PUSH_67,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_67,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_67,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x118++0x03
        line.long 0x00 "CMD_PUSH_68,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_68,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_68,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x11C++0x03
        line.long 0x00 "CMD_PUSH_69,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_69,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_69,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x120++0x03
        line.long 0x00 "CMD_PUSH_70,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_70,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_70,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x124++0x03
        line.long 0x00 "CMD_PUSH_71,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_71,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_71,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x128++0x03
        line.long 0x00 "CMD_PUSH_72,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_72,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_72,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x12C++0x03
        line.long 0x00 "CMD_PUSH_73,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_73,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_73,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x130++0x03
        line.long 0x00 "CMD_PUSH_74,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_74,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_74,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x134++0x03
        line.long 0x00 "CMD_PUSH_75,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_75,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_75,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x138++0x03
        line.long 0x00 "CMD_PUSH_76,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_76,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_76,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x13C++0x03
        line.long 0x00 "CMD_PUSH_77,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_77,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_77,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x140++0x03
        line.long 0x00 "CMD_PUSH_78,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_78,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_78,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x144++0x03
        line.long 0x00 "CMD_PUSH_79,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_79,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_79,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x148++0x03
        line.long 0x00 "CMD_PUSH_80,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_80,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_80,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x14C++0x03
        line.long 0x00 "CMD_PUSH_81,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_81,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_81,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x150++0x03
        line.long 0x00 "CMD_PUSH_82,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_82,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_82,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x154++0x03
        line.long 0x00 "CMD_PUSH_83,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_83,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_83,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x158++0x03
        line.long 0x00 "CMD_PUSH_84,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_84,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_84,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x15C++0x03
        line.long 0x00 "CMD_PUSH_85,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_85,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_85,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x160++0x03
        line.long 0x00 "CMD_PUSH_86,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_86,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_86,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x164++0x03
        line.long 0x00 "CMD_PUSH_87,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_87,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_87,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x168++0x03
        line.long 0x00 "CMD_PUSH_88,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_88,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_88,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x16C++0x03
        line.long 0x00 "CMD_PUSH_89,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_89,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_89,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x170++0x03
        line.long 0x00 "CMD_PUSH_90,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_90,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_90,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x174++0x03
        line.long 0x00 "CMD_PUSH_91,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_91,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_91,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x178++0x03
        line.long 0x00 "CMD_PUSH_92,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_92,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_92,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x17C++0x03
        line.long 0x00 "CMD_PUSH_93,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_93,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_93,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x180++0x03
        line.long 0x00 "CMD_PUSH_94,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_94,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_94,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x184++0x03
        line.long 0x00 "CMD_PUSH_95,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_95,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_95,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x188++0x03
        line.long 0x00 "CMD_PUSH_96,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_96,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_96,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x18C++0x03
        line.long 0x00 "CMD_PUSH_97,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_97,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_97,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x190++0x03
        line.long 0x00 "CMD_PUSH_98,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_98,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_98,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x194++0x03
        line.long 0x00 "CMD_PUSH_99,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_99,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_99,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x198++0x03
        line.long 0x00 "CMD_PUSH_100,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_100,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_100,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x19C++0x03
        line.long 0x00 "CMD_PUSH_101,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_101,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_101,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1A0++0x03
        line.long 0x00 "CMD_PUSH_102,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_102,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_102,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1A4++0x03
        line.long 0x00 "CMD_PUSH_103,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_103,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_103,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1A8++0x03
        line.long 0x00 "CMD_PUSH_104,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_104,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_104,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1AC++0x03
        line.long 0x00 "CMD_PUSH_105,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_105,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_105,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1B0++0x03
        line.long 0x00 "CMD_PUSH_106,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_106,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_106,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1B4++0x03
        line.long 0x00 "CMD_PUSH_107,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_107,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_107,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1B8++0x03
        line.long 0x00 "CMD_PUSH_108,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_108,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_108,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1BC++0x03
        line.long 0x00 "CMD_PUSH_109,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_109,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_109,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1C0++0x03
        line.long 0x00 "CMD_PUSH_110,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_110,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_110,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1C4++0x03
        line.long 0x00 "CMD_PUSH_111,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_111,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_111,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1C8++0x03
        line.long 0x00 "CMD_PUSH_112,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_112,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_112,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1CC++0x03
        line.long 0x00 "CMD_PUSH_113,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_113,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_113,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1D0++0x03
        line.long 0x00 "CMD_PUSH_114,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_114,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_114,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1D4++0x03
        line.long 0x00 "CMD_PUSH_115,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_115,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_115,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1D8++0x03
        line.long 0x00 "CMD_PUSH_116,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_116,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_116,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1DC++0x03
        line.long 0x00 "CMD_PUSH_117,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_117,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_117,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1E0++0x03
        line.long 0x00 "CMD_PUSH_118,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_118,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_118,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1E4++0x03
        line.long 0x00 "CMD_PUSH_119,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_119,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_119,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1E8++0x03
        line.long 0x00 "CMD_PUSH_120,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_120,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_120,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1EC++0x03
        line.long 0x00 "CMD_PUSH_121,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_121,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_121,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1F0++0x03
        line.long 0x00 "CMD_PUSH_122,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_122,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_122,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1F4++0x03
        line.long 0x00 "CMD_PUSH_123,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_123,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_123,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1F8++0x03
        line.long 0x00 "CMD_PUSH_124,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_124,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_124,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x1FC++0x03
        line.long 0x00 "CMD_PUSH_125,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_125,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_125,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x200++0x03
        line.long 0x00 "CMD_PUSH_126,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_126,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_126,Push the command indicated by CMD_IDX to the queue" "0,1"
    group.long 0x204++0x03
        line.long 0x00 "CMD_PUSH_127,Command push register virtual extension"
            bitfld.long 0x00 8.--13. "CMD_IDX_127,New command memory index to push to the queue" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0. "CMD_PUSH_127,Push the command indicated by CMD_IDX to the queue" "0,1"

    rgroup.long 0x208++0x03
        line.long 0x00 "CQ_STATUS,CQ Status Register"
            bitfld.long 0x00 31. "CQ_EXTERNALLY_HELD,Goes high while the input ext_cq_hold is asserted" "0,1"
            newline
            hexmask.long.byte 0x00 24.--30. 1. "CMD_DONE_ID,ID number of the last completed command (CMD_ID)"
            newline
            bitfld.long 0x00 16.--21. "CU_CMD,Current command index in execution at the input stage the index is the position of the command in the CQMEM" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 15. "FIFO_FULL,Command queue full condition" "0,1"
            newline
            hexmask.long.byte 0x00 8.--14. 1. "WR_PTR,Command queue current write location"
            newline
            bitfld.long 0x00 7. "FIFO_EMPTY,Command queue empty condition" "0,1"
            newline
            hexmask.long.byte 0x00 0.--6. 1. "RD_PTR,Command queue current read location"
    rgroup.long 0x20C++0x03
        line.long 0x00 "RA_STATUS,RA Engine Status Register"
            hexmask.long.byte 0x00 24.--31. 1. "CQ_COUNTER,Counter of the number of commands stored in the queue"
            newline
            bitfld.long 0x00 15. "POSP_BUSY,Indicates the pre-processor block is processing data" "0,1"
            newline
            bitfld.long 0x00 14. "PREP_BUSY,Indicates the pre-processor block is processing data" "0,1"
            newline
            bitfld.long 0x00 13. "FFT_CORE_BUSY,Indicates the fft_core is processing" "0,1"
            newline
            bitfld.long 0x00 7. "OM_FSM_BUSY,Goes high whe the state machine of the output manager is busy (reading from memory)" "0,1"
            newline
            bitfld.long 0x00 6. "PROC_OM_FSM_BUSY,Goes high whe the state machine of the processing output manager is busy (writing to memory)" "0,1"
            newline
            bitfld.long 0x00 5. "PROC_IM_FSM_BUSY,Goes high whe the state machine of the processing input manager is busy (reading from memory)" "0,1"
            newline
            bitfld.long 0x00 4. "IM_FSM_BUSY,Goes high whe the state machine of the input manager is busy (writing to memory)" "0,1"
            newline
            bitfld.long 0x00 3. "PS3_BUSY,The Pipe Stage 3 is active" "0,1"
            newline
            bitfld.long 0x00 2. "PS2_BUSY,The Pipe Stage 2 is active" "0,1"
            newline
            bitfld.long 0x00 1. "PS1_BUSY,The Pipe Stage 1 is active" "0,1"
            newline
            bitfld.long 0x00 0. "RA_BUSY,The RA engine is active processing descriptors and performing FFTs" "0,1"

    group.long 0x210++0x03
        line.long 0x00 "BBE32_IRQ_ENA,BBE 32 interrupt enable register"
            bitfld.long 0x00 4. "CMD_DONE_IRQ_BBE_ENA,Command completed IRQ enable for BBE32" "0,1"
            newline
            bitfld.long 0x00 3. "OUT_CMD_IRQ_BBE_ENA,Output stage command completed IRQ enable for BBE32" "0,1"
            newline
            bitfld.long 0x00 2. "PROC_CMD_IRQ_BBE_ENA,Processing stage command completed IRQ enable for BBE32" "0,1"
            newline
            bitfld.long 0x00 1. "LOAD_CMD_IRQ_BBE_ENA,Input stage command completed IRQ enable for BBE32" "0,1"
            newline
            bitfld.long 0x00 0. "CQ_REFILL_REQ_IRQ_BBE_ENA,CQ re-fill request IRQ enable for BBE32" "0,1"
    group.long 0x214++0x03
        line.long 0x00 "BBE32_IRQ_FLAG,Status and clear flag"
            bitfld.long 0x00 4. "CMD_DONE_IRQ_BBE_FLAG,Informs when the last active stage of the RA completes the execution of a command" "0,1"
            newline
            bitfld.long 0x00 3. "OUT_CMD_IRQ_BBE_FLAG,Informs when the output stage of the RA completes the execution of a command" "0,1"
            newline
            bitfld.long 0x00 2. "PROC_CMD_IRQ_BBE_FLAG,Informs when the processing stage of the RA completes the execution of a command" "0,1"
            newline
            bitfld.long 0x00 1. "LOAD_CMD_IRQ_BBE_FLAG,Informs when the input stage of the RA completes the execution of a command" "0,1"
            newline
            bitfld.long 0x00 0. "CQ_REFILL_REQ_IRQ_BBE_FLAG,Asserts when the number of commands in the queue is equal or below the threshold" "0,1"
    group.long 0x218++0x03
        line.long 0x00 "R52_FUNC_IRQ_ENA,R52 Functional interrupts enable register"
            bitfld.long 0x00 4. "CMD_DONE_IRQ_R52_FUNC_ENA,Command completed IRQ enable for R52" "0,1"
            newline
            bitfld.long 0x00 3. "OUT_CMD_IRQ_R52_FUNC_ENA,Output stage command completed IRQ enable for R52" "0,1"
            newline
            bitfld.long 0x00 2. "PROC_CMD_IRQ_R52_FUNC_ENA,Processing stage command completed IRQ enable for R52" "0,1"
            newline
            bitfld.long 0x00 1. "LOAD_CMD_IRQ_R52_FUNC_ENA,Input stage command completed IRQ enable for R52" "0,1"
            newline
            bitfld.long 0x00 0. "CQ_REFILL_REQ_IRQ_R52_FUNC_ENA,CQ re-fill request IRQ enable for R52" "0,1"
    group.long 0x21C++0x03
        line.long 0x00 "R52_FUNC_IRQ_FLAG,Status and clear flag"
            bitfld.long 0x00 4. "CMD_DONE_IRQ_R52_FUNC_FLAG,Informs when the last active stage of the RA completes the execution of a command" "0,1"
            newline
            bitfld.long 0x00 3. "OUT_CMD_IRQ_R52_FUNC_FLAG,Informs when the output stage of the RA completes the execution of a command" "0,1"
            newline
            bitfld.long 0x00 2. "PROC_CMD_IRQ_R52_FUNC_FLAG,Informs when the processing stage of the RA completes the execution of a command" "0,1"
            newline
            bitfld.long 0x00 1. "LOAD_CMD_IRQ_R52_FUNC_FLAG,Informs when the input stage of the RA completes the execution of a command" "0,1"
            newline
            bitfld.long 0x00 0. "CQ_REFILL_REQ_IRQ_R52_FUNC_FLAG,Asserts when the number of commands in the queue is equal or below the threshold" "0,1"
    group.long 0x220++0x03
        line.long 0x00 "R52_ERR_IRQ_ENA_1,R52 Error interrupts enable register 1"
            bitfld.long 0x00 30. "CIMEM_MUX_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 29. "REAL_FFT_OVF_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 28. "OM_SSL_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 27. "OM_SSS_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 26. "POSPROC_OVF_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 25. "FFT_CORE_OVF_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 24. "PREPROC_OVF_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 23. "DECOMP_OVF_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 22. "DPMEM_MUX_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 21. "CIMEM4_AHB_ERR_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the AHB access to CIMEM" "0,1"
            newline
            bitfld.long 0x00 20. "CIMEM3_AHB_ERR_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the AHB access to CIMEM" "0,1"
            newline
            bitfld.long 0x00 19. "CIMEM2_AHB_ERR_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the AHB access to CIMEM" "0,1"
            newline
            bitfld.long 0x00 18. "CIMEM1_AHB_ERR_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the AHB access to CIMEM" "0,1"
            newline
            bitfld.long 0x00 17. "ESTMEM_4_AHB_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 16. "ESTMEM_3_AHB_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 15. "ESTMEM_2_AHB_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 14. "ESTMEM_1_AHB_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 13. "PHMEM_BUSY_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 12. "PHMEM_AHB_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 11. "IDXMEM_BUSY_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 10. "IDXMEM_AHB_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 9. "WCMEM_BUSY_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 8. "WCMEM_AHB_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 7. "CQMEM_AHB_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 6. "AXI_OUT_RESP_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 5. "AXI_IN_RESP_ERR_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 4. "CQ_OVF_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 3. "OUT_STAGE_WDT_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 2. "PROC_STAGE_WDT_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 1. "IN_STAGE_WDT_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
            newline
            bitfld.long 0x00 0. "INVALID_CONFIG_IRQ_R52_ERR_ENA,Enables the IRQ" "0,1"
    group.long 0x224++0x03
        line.long 0x00 "R52_ERR_IRQ_ENA_2,R52 Error interrupts enable register 2"
            bitfld.long 0x00 14. "OUT_ADDR_RANGE_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an invalid output address range" "0,1"
            newline
            bitfld.long 0x00 13. "POSP_DIVIDER_ERR_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the post-processor divider" "0,1"
            newline
            bitfld.long 0x00 12. "POSP_OFFSET_OVF_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an overflow in the post-processor offset input" "0,1"
            newline
            bitfld.long 0x00 11. "POSP_SUM_OVF_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an overflow in the post-processor sum input" "0,1"
            newline
            bitfld.long 0x00 10. "PREP_DIVIDER_ERR_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the pre-processor divider" "0,1"
            newline
            bitfld.long 0x00 9. "PREP_OFFSET_OVF_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an overflow in the pre-processor offset input" "0,1"
            newline
            bitfld.long 0x00 8. "PREP_SUM_OVF_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an overflow in the pre-processor sum input" "0,1"
            newline
            bitfld.long 0x00 7. "EST_4_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the estimator 4" "0,1"
            newline
            bitfld.long 0x00 6. "EST_3_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the estimator 3" "0,1"
            newline
            bitfld.long 0x00 5. "EST_2_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the estimator 2" "0,1"
            newline
            bitfld.long 0x00 4. "EST_1_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the estimator 1" "0,1"
            newline
            bitfld.long 0x00 3. "EST_MUX_4_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the configuration of the estimator 4" "0,1"
            newline
            bitfld.long 0x00 2. "EST_MUX_3_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the configuration of the estimator 3" "0,1"
            newline
            bitfld.long 0x00 1. "EST_MUX_2_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the configuration of the estimator 2" "0,1"
            newline
            bitfld.long 0x00 0. "EST_MUX_1_IRQ_R52_ERR_ENA,Enables the R52_error interrupt activation due to an error in the configuration of the estimator 1" "0,1"
    group.long 0x228++0x03
        line.long 0x00 "R52_ERR_IRQ_FLAG_1,Status and clear flag"
            bitfld.long 0x00 30. "CIMEM_MUX_ERR_IRQ_R52_ERR_FLAG,Flags an error when more than one estimators try to access the same CIMEM at the same time" "0,1"
            newline
            bitfld.long 0x00 29. "REAL_FFT_OVF_IRQ_R52_ERR_FLAG,Asserts when there is an overflow in the real_fft_gen block" "0,1"
            newline
            bitfld.long 0x00 28. "OM_SSL_IRQ_R52_ERR_FLAG,Asserts if tlast signal doesn't go high when it's expected based on the transfer size" "0,1"
            newline
            bitfld.long 0x00 27. "OM_SSS_IRQ_R52_ERR_FLAG,Asserts if tlast signal goes high before than expected based on the transfer size" "0,1"
            newline
            bitfld.long 0x00 26. "POSPROC_OVF_IRQ_R52_ERR_FLAG,Asserts when there is an overflow in the post-processor block" "0,1"
            newline
            bitfld.long 0x00 25. "FFT_CORE_OVF_IRQ_R52_ERR_FLAG,Asserts when there is an overflow in any of the stages of the FFT Core block" "0,1"
            newline
            bitfld.long 0x00 24. "PREPROC_OVF_IRQ_R52_ERR_FLAG,Asserts when there is an overflow in the pre-processor block" "0,1"
            newline
            bitfld.long 0x00 23. "DECOMP_OVF_IRQ_R52_ERR_FLAG,Asserts when there is an overflow in the decompression block" "0,1"
            newline
            bitfld.long 0x00 22. "DPMEM_MUX_ERR_IRQ_R52_ERR_FLAG,Flags an error when two stages try to access the same memory bank at the same time" "0,1"
            newline
            bitfld.long 0x00 21. "CIMEM4_AHB_ERR_IRQ_R52_ERR_FLAG,Asserts when an ahb access to memory is performed but ra_engine is active and the access is not forced" "0,1"
            newline
            bitfld.long 0x00 20. "CIMEM3_AHB_ERR_IRQ_R52_ERR_FLAG,Asserts when an ahb access to memory is performed but ra_engine is active and the access is not forced" "0,1"
            newline
            bitfld.long 0x00 19. "CIMEM2_AHB_ERR_IRQ_R52_ERR_FLAG,Asserts when an ahb access to memory is performed but ra_engine is active and the access is not forced" "0,1"
            newline
            bitfld.long 0x00 18. "CIMEM1_AHB_ERR_IRQ_R52_ERR_FLAG,Asserts when an ahb access to memory is performed but ra_engine is active and the access is not forced" "0,1"
            newline
            bitfld.long 0x00 17. "ESTMEM_4_AHB_ERR_IRQ_R52_ERR_FLAG,Asserts when an ahb access to memory is performed but ra_engine is active and the access is not forced" "0,1"
            newline
            bitfld.long 0x00 16. "ESTMEM_3_AHB_ERR_IRQ_R52_ERR_FLAG,Asserts when an ahb access to memory is performed but ra_engine is active and the access is not forced" "0,1"
            newline
            bitfld.long 0x00 15. "ESTMEM_2_AHB_ERR_IRQ_R52_ERR_FLAG,Asserts when an ahb access to memory is performed but ra_engine is active and the access is not forced" "0,1"
            newline
            bitfld.long 0x00 14. "ESTMEM_1_AHB_ERR_IRQ_R52_ERR_FLAG,Asserts when an ahb access to memory is performed but ra_engine is active and the access is not forced" "0,1"
            newline
            bitfld.long 0x00 13. "PHMEM_BUSY_ERR_IRQ_R52_ERR_FLAG,Goes high when the pos-processor tries to access this memory while it's being used by the pre-processor or viceversa" "0,1"
            newline
            bitfld.long 0x00 12. "PHMEM_AHB_ERR_IRQ_R52_ERR_FLAG,Asserts when an ahb access to memory is performed but ra_engine is active and the access is not forced" "0,1"
            newline
            bitfld.long 0x00 11. "IDXMEM_BUSY_ERR_IRQ_R52_ERR_FLAG,Goes high when the pos-processor tries to access this memory while it's being used by the pre-processor or viceversa" "0,1"
            newline
            bitfld.long 0x00 10. "IDXMEM_AHB_ERR_IRQ_R52_ERR_FLAG,Asserts when an ahb access to memory is performed but ra_engine is active and the access is not forced" "0,1"
            newline
            bitfld.long 0x00 9. "WCMEM_BUSY_ERR_IRQ_R52_ERR_FLAG,Goes high when the pos-processor tries to access this memory while it's being used by the pre-processor or viceversa" "0,1"
            newline
            bitfld.long 0x00 8. "WCMEM_AHB_ERR_IRQ_R52_ERR_FLAG,Asserts when an ahb access to memory is performed but ra_engine is active and the access is not forced" "0,1"
            newline
            bitfld.long 0x00 7. "CQMEM_AHB_ERR_IRQ_R52_ERR_FLAG,Asserts when an ahb access to memory is performed but ra_engine is active and the access is not forced" "0,1"
            newline
            bitfld.long 0x00 6. "AXI_OUT_RESP_ERR_IRQ_R52_ERR_FLAG,Asserts when the slave responds with error to a write transaction" "0,1"
            newline
            bitfld.long 0x00 5. "AXI_IN_RESP_ERR_IRQ_R52_ERR_FLAG,Asserts when the slave responds with error to a read transaction" "0,1"
            newline
            bitfld.long 0x00 4. "CQ_OVF_IRQ_R52_ERR_FLAG,Asserts when the command queue is full and a new command is pushed" "0,1"
            newline
            bitfld.long 0x00 3. "OUT_STAGE_WDT_IRQ_R52_ERR_FLAG,The monitor starts running when the command is loaded and clear when the command is done if the stage is stalled the IRQ raises" "0,1"
            newline
            bitfld.long 0x00 2. "PROC_STAGE_WDT_IRQ_R52_ERR_FLAG,The monitor starts running when the command is loaded and clear when the command is done if the stage is stalled the IRQ raises" "0,1"
            newline
            bitfld.long 0x00 1. "IN_STAGE_WDT_IRQ_R52_ERR_FLAG,The monitor starts running when the command is loaded and clear when the command is done if the stage is stalled the IRQ raises" "0,1"
            newline
            bitfld.long 0x00 0. "INVALID_CONFIG_IRQ_R52_ERR_FLAG,Signalizes an invalid combination of commands/registers" "0,1"
    group.long 0x22C++0x03
        line.long 0x00 "R52_ERR_IRQ_FLAG_2,Status and clear flag"
            bitfld.long 0x00 14. "OUT_ADDR_RANGE_IRQ_R52_ERR_FLAG,Goes high if OUT_ADDR_ACTIVE_REGIONS is greater than 0 and the AXI output address is ont inside of any ot the valid ranges" "0,1"
            newline
            bitfld.long 0x00 13. "POSP_DIVIDER_ERR_IRQ_R52_ERR_FLAG,Indicates an error in the post-processor divider" "0,1"
            newline
            bitfld.long 0x00 12. "POSP_OFFSET_OVF_IRQ_R52_ERR_FLAG,Indicates an overflow in the value read from the estimators for the offset operation" "0,1"
            newline
            bitfld.long 0x00 11. "POSP_SUM_OVF_IRQ_R52_ERR_FLAG,Indicates an overflow in the value read from the estimators for the sum operation" "0,1"
            newline
            bitfld.long 0x00 10. "PREP_DIVIDER_ERR_IRQ_R52_ERR_FLAG,Indicates an error in the pre-processor divider" "0,1"
            newline
            bitfld.long 0x00 9. "PREP_OFFSET_OVF_IRQ_R52_ERR_FLAG,Indicates an overflow in the value read from the estimators for the offset operation" "0,1"
            newline
            bitfld.long 0x00 8. "PREP_SUM_OVF_IRQ_R52_ERR_FLAG,Indicates an overflow in the value read from the estimators for the sum operation" "0,1"
            newline
            bitfld.long 0x00 7. "EST_4_IRQ_R52_ERR_FLAG,Goes high when there is an error in the estimator 4" "0,1"
            newline
            bitfld.long 0x00 6. "EST_3_IRQ_R52_ERR_FLAG,Goes high when there is an error in the estimator 3" "0,1"
            newline
            bitfld.long 0x00 5. "EST_2_IRQ_R52_ERR_FLAG,Goes high when there is an error in the estimator 2" "0,1"
            newline
            bitfld.long 0x00 4. "EST_1_IRQ_R52_ERR_FLAG,Goes high when there is an error in the estimator 1" "0,1"
            newline
            bitfld.long 0x00 3. "EST_MUX_4_IRQ_R52_ERR_FLAG,Goes high when there is an error in the configuration of the estimator 4" "0,1"
            newline
            bitfld.long 0x00 2. "EST_MUX_3_IRQ_R52_ERR_FLAG,Goes high when there is an error in the configuration of the estimator 3" "0,1"
            newline
            bitfld.long 0x00 1. "EST_MUX_2_IRQ_R52_ERR_FLAG,Goes high when there is an error in the configuration of the estimator 2" "0,1"
            newline
            bitfld.long 0x00 0. "EST_MUX_1_IRQ_R52_ERR_FLAG,Goes high when there is an error in the configuration of the estimator 1" "0,1"
    group.long 0x230++0x03
        line.long 0x00 "R52_FUSA_IRQ_ENA,R52 FuSa interrupts enable register"
            bitfld.long 0x00 26. "FSM_ERR_IRQ_R52_FUSA_ENA,Enable for the IRQ of the FSMs checker" "0,1"
            newline
            bitfld.long 0x00 25. "AXI_OUT_PARITY_CHK_IRQ_R52_FUSA_ENA,Enable for the IRQ of partity check in AXI egress interface" "0,1"
            newline
            bitfld.long 0x00 24. "AXI_IN_PARITY_CHK_IRQ_R52_FUSA_ENA,Enable for the IRQ of partity check in AXI ingress interface" "0,1"
            newline
            bitfld.long 0x00 23. "ECC_SEC_CNT_DPMEM_3_IRQ_R52_FUSA_ENA,Enable for the IRQ of Single Error Corrected counter in DPMEM_3's ECC" "0,1"
            newline
            bitfld.long 0x00 22. "ECC_DED_DPMEM_3_IRQ_R52_FUSA_ENA,Enable for the IRQ of Double Error Detected in DPMEM_3's ECC" "0,1"
            newline
            bitfld.long 0x00 21. "ECC_SEC_CNT_DPMEM_2_IRQ_R52_FUSA_ENA,Enable for the IRQ of Single Error Corrected counter in DPMEM_2's ECC" "0,1"
            newline
            bitfld.long 0x00 20. "ECC_DED_DPMEM_2_IRQ_R52_FUSA_ENA,Enable for the IRQ of Double Error Detected in DPMEM_2's ECC" "0,1"
            newline
            bitfld.long 0x00 19. "ECC_SEC_CNT_DPMEM_1_IRQ_R52_FUSA_ENA,Enable for the IRQ of Single Error Corrected counter in DPMEM_1's ECC" "0,1"
            newline
            bitfld.long 0x00 18. "ECC_DED_DPMEM_1_IRQ_R52_FUSA_ENA,Enable for the IRQ of Double Error Detected in DPMEM_1's ECC" "0,1"
            newline
            bitfld.long 0x00 17. "ECC_SEC_CNT_DPMEM_0_IRQ_R52_FUSA_ENA,Enable for the IRQ of Single Error Corrected counter in DPMEM_0's ECC" "0,1"
            newline
            bitfld.long 0x00 16. "ECC_DED_DPMEM_0_IRQ_R52_FUSA_ENA,Enable for the IRQ of Double Error Detected in DPMEM_0's ECC" "0,1"
            newline
            bitfld.long 0x00 15. "ECC_SEC_CNT_ESTMEM_4_IRQ_R52_FUSA_ENA,Enable for the IRQ of Single Error Corrected counter in ESTMEM_4's ECC" "0,1"
            newline
            bitfld.long 0x00 14. "ECC_DED_ESTMEM_4_IRQ_R52_FUSA_ENA,Enable for the IRQ of Double Error Detected in ESTMEM_4's ECC" "0,1"
            newline
            bitfld.long 0x00 13. "ECC_SEC_CNT_ESTMEM_3_IRQ_R52_FUSA_ENA,Enable for the IRQ of Single Error Corrected counter in ESTMEM_3's ECC" "0,1"
            newline
            bitfld.long 0x00 12. "ECC_DED_ESTMEM_3_IRQ_R52_FUSA_ENA,Enable for the IRQ of Double Error Detected in ESTMEM_3's ECC" "0,1"
            newline
            bitfld.long 0x00 11. "ECC_SEC_CNT_ESTMEM_2_IRQ_R52_FUSA_ENA,Enable for the IRQ of Single Error Corrected counter in ESTMEM_2's ECC" "0,1"
            newline
            bitfld.long 0x00 10. "ECC_DED_ESTMEM_2_IRQ_R52_FUSA_ENA,Enable for the IRQ of Double Error Detected in ESTMEM_2's ECC" "0,1"
            newline
            bitfld.long 0x00 9. "ECC_SEC_CNT_ESTMEM_1_IRQ_R52_FUSA_ENA,Enable for the IRQ of Single Error Corrected counter in ESTMEM_1's ECC" "0,1"
            newline
            bitfld.long 0x00 8. "ECC_DED_ESTMEM_1_IRQ_R52_FUSA_ENA,Enable for the IRQ of Double Error Detected in ESTMEM_1's ECC" "0,1"
            newline
            bitfld.long 0x00 7. "ECC_SEC_CNT_PHMEM_IRQ_R52_FUSA_ENA,Enable for the IRQ of Single Error Corrected counter in PHMEM's ECC" "0,1"
            newline
            bitfld.long 0x00 6. "ECC_DED_PHMEM_IRQ_R52_FUSA_ENA,Enable for the IRQ of Double Error Detected in PHMEM's ECC" "0,1"
            newline
            bitfld.long 0x00 5. "ECC_SEC_CNT_IDXMEM_IRQ_R52_FUSA_ENA,Enable for the IRQ of Single Error Corrected counter in IDXMEM's ECC" "0,1"
            newline
            bitfld.long 0x00 4. "ECC_DED_IDXMEM_IRQ_R52_FUSA_ENA,Enable for the IRQ of Double Error Detected in IDXMEM's ECC" "0,1"
            newline
            bitfld.long 0x00 3. "ECC_SEC_CNT_WCMEM_IRQ_R52_FUSA_ENA,Enable for the IRQ of Single Error Corrected counter in WCMEM's ECC" "0,1"
            newline
            bitfld.long 0x00 2. "ECC_DED_WCMEM_IRQ_R52_FUSA_ENA,Enable for the IRQ of Double Error Detected in WCMEM's ECC" "0,1"
            newline
            bitfld.long 0x00 1. "ECC_SEC_CNT_CQMEM_IRQ_R52_FUSA_ENA,Enable for the IRQ of Single Error Corrected counter in CQMEM's ECC" "0,1"
            newline
            bitfld.long 0x00 0. "ECC_DED_CQMEM_IRQ_R52_FUSA_ENA,Enable for the IRQ of Double Error Detected in CQMEM's ECC" "0,1"
    group.long 0x234++0x03
        line.long 0x00 "R52_FUSA_IRQ_FLAG,Status and clear flag"
            bitfld.long 0x00 26. "FSM_ERR_IRQ_R52_FUSA_FLAG,Status flag for the IRQ of the FSMs checker it asserts if any of the FSMs of the RA reaches an invalid state" "0,1"
            newline
            bitfld.long 0x00 25. "AXI_OUT_PARITY_CHK_IRQ_R52_FUSA_FLAG,Status flag for the IRQ of partity check in AXI egress interface" "0,1"
            newline
            bitfld.long 0x00 24. "AXI_IN_PARITY_CHK_IRQ_R52_FUSA_FLAG,Status flag for the IRQ of partity check in AXI ingress interface" "0,1"
            newline
            bitfld.long 0x00 23. "ECC_SEC_CNT_DPMEM_3_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 22. "ECC_DED_DPMEM_3_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 21. "ECC_SEC_CNT_DPMEM_2_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 20. "ECC_DED_DPMEM_2_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 19. "ECC_SEC_CNT_DPMEM_1_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 18. "ECC_DED_DPMEM_1_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 17. "ECC_SEC_CNT_DPMEM_0_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 16. "ECC_DED_DPMEM_0_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 15. "ECC_SEC_CNT_ESTMEM_4_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 14. "ECC_DED_ESTMEM_4_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 13. "ECC_SEC_CNT_ESTMEM_3_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 12. "ECC_DED_ESTMEM_3_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 11. "ECC_SEC_CNT_ESTMEM_2_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 10. "ECC_DED_ESTMEM_2_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 9. "ECC_SEC_CNT_ESTMEM_1_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 8. "ECC_DED_ESTMEM_1_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 7. "ECC_SEC_CNT_PHMEM_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 6. "ECC_DED_PHMEM_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 5. "ECC_SEC_CNT_IDXMEM_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 4. "ECC_DED_IDXMEM_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 3. "ECC_SEC_CNT_WCMEM_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 2. "ECC_DED_WCMEM_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 1. "ECC_SEC_CNT_CQMEM_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
            newline
            bitfld.long 0x00 0. "ECC_DED_CQMEM_IRQ_R52_FUSA_FLAG,Write to this bit clears the IRQ" "0,1"
    group.long 0x238++0x03
        line.long 0x00 "GEN_CONFIG,General configuration register"
            hexmask.long.byte 0x00 24.--30. 1. "CQ_REFILL_IRQ_THR,Sets the threshold for the re-fill IRQ of the command queue"
            newline
            bitfld.long 0x00 23. "ESTIMATORS_FLIP_BEXP,Selects the way to output the block exponent from the 3 estimators" "0: 63-bexp,1: bexp"
            newline
            bitfld.long 0x00 20.--21. "COMP_BUF_THRESHOLD_SEL,When the compressor buffer reaches the threshold buf_full_flag is raised" "0,1,2,3"
            newline
            bitfld.long 0x00 18. "DECOMP_PRBS_SEED_SET,It forces the PRBS status to prbs seeds registers values" "0,1"
            newline
            bitfld.long 0x00 16.--17. "DECOMP_ROUND_SEL,Decompression round configuration: 'd0->none 'd1->round 'd2->random 'd3->random" "0,1,2,3"
            newline
            bitfld.long 0x00 13. "COMP_PRBS_SEED_SET,It forces the PRBS status to prbs seeds registers values" "0,1"
            newline
            bitfld.long 0x00 8.--12. "COMP_MIN_SHIFT_SET_VAL,Value to set to min_shift" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 6. "COMP_SAT_MODE,Compression saturation mode: 'd0->saturate 'd1->no saturate" "0,1"
            newline
            bitfld.long 0x00 4.--5. "COMP_ROUND_SEL,Compression round configuration: 'd0->truncation 'd1->round 'd2->random 'd3->random" "0,1,2,3"
            newline
            bitfld.long 0x00 3. "N_TX_ANTENNAS,0 means 2 active Tx Antenna 1 means 4 active Tx Antennas" "0,1"
            newline
            bitfld.long 0x00 1. "N_RX_ANTENNAS,0 means 2 active Rx Antenna 1 means 4 active Rx Antennas" "0,1"
    group.long 0x23C++0x03
        line.long 0x00 "AUTOSCALE_REG,Configure and show the status of the autoscaling features"
            rbitfld.long 0x00 12.--14. "MAGSQ_BLOCK_EXP,This value is calculated in the proc_out_manager when writing to the DPMEM and applied to data in the output_manager when reading" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 8.--10. "IM_BLOCK_EXP_IMAG,This value is calculated in the Input Manager when writing to the DPMEM and applied to data in the proc_in_manager when reading" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 4.--6. "IM_BLOCK_EXP_REAL,This value is calculated in the Input Manager when writing to the DPMEM and applied to data in the proc_in_manager when reading" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 1. "MAGSQ_AUTOSCALE_ENA,Enables the autoscaling feature in the magnitude squared calculation it uses the block exponent method" "0,1"
            newline
            bitfld.long 0x00 0. "IM_AUTOSCALE_ENA,Enables the autoscaling feature in the input manager it uses the block exponent method" "0,1"
    group.long 0x240++0x03
        line.long 0x00 "COMP_PRBS_1,Compressor PRBS_1 seed set"
            hexmask.long 0x00 0.--30. 1. "COMP_PRBS_1_SEED,PRBS_1 seed it can't be 0x0"
    group.long 0x244++0x03
        line.long 0x00 "COMP_PRBS_2,Compressor PRBS_2 seed set"
            hexmask.long 0x00 0.--30. 1. "COMP_PRBS_2_SEED,PRBS_2 seed it can't be 0x0"
    group.long 0x248++0x03
        line.long 0x00 "DECOMP_PRBS_1,Decompressor PRBS_1 seed set"
            hexmask.long 0x00 0.--30. 1. "DECOMP_PRBS_1_SEED,PRBS_1 seed it can't be 0x0"
    group.long 0x24C++0x03
        line.long 0x00 "DECOMP_PRBS_2,Decompressor PRBS_2 seed set"
            hexmask.long 0x00 0.--30. 1. "DECOMP_PRBS_2_SEED,PRBS_2 seed it can't be 0x0"

    rgroup.long 0x250++0x03
        line.long 0x00 "COMPRESSOR_MIN_SHIFT,Value and status of the min_shift generated by the compressor block"
            bitfld.long 0x00 15. "MIN_SHIFT_RD_POINTER,0 means that ping buffer is being read 1 means pong buffer is being" "0,1"
            newline
            bitfld.long 0x00 8.--12. "MIN_SHIFT_PONG,Minimum shift stored in the PONG buffer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 7. "MIN_SHIFT_WR_POINTER,0 means that ping buffer is being written 1 means pong buffer is being written" "0,1"
            newline
            bitfld.long 0x00 0.--4. "MIN_SHIFT_PING,Minimum shift stored in the PING buffer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

    group.long 0x254++0x03
        line.long 0x00 "PREP_SW_CMP_TH,Preprocessor comparator threshold registers"
            hexmask.long 0x00 0.--31. 1. "PREP_SW_CMP_TH,Preprocessor comparator threshold by software"
    group.long 0x258++0x03
        line.long 0x00 "PREP_CMP_SCALE,Preprocessor comparator threshold scale"
            hexmask.long.word 0x00 0.--15. 1. "PREP_CMP_SCALE,Comparator scale constant u16.10 used in the pre-processor"
    group.long 0x25C++0x03
        line.long 0x00 "PREP_CMP_OFFSET,Preprocessor comparator threshold offset"
            hexmask.long.tbyte 0x00 0.--23. 1. "PREP_CMP_OFFSET,Comparator offset constant s24.23 used in the pre-processor"
    group.long 0x260++0x03
        line.long 0x00 "PREP_SW_OFFSET_REAL,Preprocessor offset real part and enable registers"
            bitfld.long 0x00 24. "PREP_SW_OFFSET_ENA,If 1 the software offset is used in the preprocessor instead of the offset the one claculated in the estimators" "0,1"
            newline
            hexmask.long.tbyte 0x00 0.--23. 1. "PREP_SW_OFFSET_REAL,Preprocessor offset real part by software"
    group.long 0x264++0x03
        line.long 0x00 "PREP_SW_OFFSET_IMAG,Preprocessor offset imaginary part registers"
            hexmask.long.tbyte 0x00 0.--23. 1. "PREP_SW_OFFSET_IMAG,Preprocessor offset imaginary part by software"
    group.long 0x268++0x03
        line.long 0x00 "POSP_SW_CMP_TH,Posprocessor comparator threshold registers"
            hexmask.long 0x00 0.--31. 1. "POSP_SW_CMP_TH,Posprocessor comparator threshold by software"
    group.long 0x26C++0x03
        line.long 0x00 "POSP_CMP_SCALE,Postprocessor comparator threshold scale"
            hexmask.long.word 0x00 0.--15. 1. "POSP_CMP_SCALE,Comparator scale constant u16.10 used in the post-processor"
    group.long 0x270++0x03
        line.long 0x00 "POSP_CMP_OFFSET,Postprocessor comparator threshold offset"
            hexmask.long.tbyte 0x00 0.--23. 1. "POSP_CMP_OFFSET,Comparator offset constant s24.23 used in the post-processor"
    group.long 0x274++0x03
        line.long 0x00 "POSP_SW_OFFSET_REAL,Posprocessor offset real part and enable registers"
            bitfld.long 0x00 24. "POSP_SW_OFFSET_ENA,If 1 the software offset is used in the posprocessor instead of the offset the one claculated in the estimators" "0,1"
            newline
            hexmask.long.tbyte 0x00 0.--23. 1. "POSP_SW_OFFSET_REAL,Posprocessor offset real part by software"
    group.long 0x278++0x03
        line.long 0x00 "POSP_SW_OFFSET_IMAG,Posprocessor offset imaginary part registers"
            hexmask.long.tbyte 0x00 0.--23. 1. "POSP_SW_OFFSET_IMAG,Posprocessor offset imaginary part by software"
    group.long 0x27C++0x03
        line.long 0x00 "DDM_OFFSET_TABLE_1,DDM offset table part 1"
            hexmask.long.byte 0x00 24.--31. 1. "DDM_OFFSET_3,DDM offset between channels is expressed in (samples * 4)"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "DDM_OFFSET_2,DDM offset between channels is expressed in (samples * 4)"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "DDM_OFFSET_1,DDM offset between channels is expressed in (samples * 4)"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "DDM_OFFSET_0,DDM offset between channels is expressed in (samples * 4)"
    group.long 0x280++0x03
        line.long 0x00 "DDM_OFFSET_TABLE_2,DDM offset table part 2"
            hexmask.long.byte 0x00 24.--31. 1. "DDM_OFFSET_7,DDM offset between channels is expressed in (samples * 4)"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "DDM_OFFSET_6,DDM offset between channels is expressed in (samples * 4)"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "DDM_OFFSET_5,DDM offset between channels is expressed in (samples * 4)"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "DDM_OFFSET_4,DDM offset between channels is expressed in (samples * 4)"
    group.long 0x284++0x03
        line.long 0x00 "DDM_OFFSET_TABLE_3,DDM offset table part 3"
            hexmask.long.byte 0x00 24.--31. 1. "DDM_OFFSET_11,DDM offset between channels is expressed in (samples * 4)"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "DDM_OFFSET_10,DDM offset between channels is expressed in (samples * 4)"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "DDM_OFFSET_9,DDM offset between channels is expressed in (samples * 4)"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "DDM_OFFSET_8,DDM offset between channels is expressed in (samples * 4)"
    group.long 0x288++0x03
        line.long 0x00 "DDM_OFFSET_TABLE_4,DDM offset table part 4"
            hexmask.long.byte 0x00 24.--31. 1. "DDM_OFFSET_15,DDM offset between channels is expressed in (samples * 4)"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "DDM_OFFSET_14,DDM offset between channels is expressed in (samples * 4)"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "DDM_OFFSET_13,DDM offset between channels is expressed in (samples * 4)"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "DDM_OFFSET_12,DDM offset between channels is expressed in (samples * 4)"
    group.long 0x28C++0x03
        line.long 0x00 "PREP_POSP_DIVIDER,Pre- and post-processor divider register"
            hexmask.long.word 0x00 16.--26. 1. "POSP_DIVIDER_NON_ZP_LEN,Non-zero padded size of the packets processed by the divider of the post-processor"
            newline
            hexmask.long.word 0x00 0.--10. 1. "PREP_DIVIDER_NON_ZP_LEN,Non-zero padded size of the packets processed by the divider of the pre-processor"

    rgroup.long 0x290++0x03
        line.long 0x00 "IN_STAGE_COUNTERS,Counters of input stage"
            hexmask.long.word 0x00 16.--25. 1. "GEN_B_COUNTER_IN,Value of generic B counter of input stage"
            newline
            bitfld.long 0x00 12.--14. "ITER_COUNTER_IN,Value of iteration counter of input stage" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long.word 0x00 0.--9. 1. "GEN_A_COUNTER_IN,Value of generic A counter of input stage"
    rgroup.long 0x294++0x03
        line.long 0x00 "PROC_STAGE_COUNTERS,Counters of processing stage"
            hexmask.long.word 0x00 16.--25. 1. "GEN_B_COUNTER_PROC,Value of generic B counter of processing stage"
            newline
            bitfld.long 0x00 12.--14. "ITER_COUNTER_PROC,Value of iteration counter of processing stage" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long.word 0x00 0.--9. 1. "GEN_A_COUNTER_PROC,Value of generic A counter of processing stage"
    rgroup.long 0x298++0x03
        line.long 0x00 "OUT_STAGE_COUNTERS,Counters of output stage"
            hexmask.long.word 0x00 16.--25. 1. "GEN_B_COUNTER_OUT,Value of generic B counter of output stage"
            newline
            bitfld.long 0x00 12.--14. "ITER_COUNTER_OUT,Value of iteration counter of output stage" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long.word 0x00 0.--9. 1. "GEN_A_COUNTER_OUT,Value of generic A counter of output stage"
    rgroup.long 0x29C++0x03
        line.long 0x00 "EST_BEXP,Estimators block exponent values"
            bitfld.long 0x00 24.--29. "EST_4_BLOCK_EXPONENT,Block exponent from estimator 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--21. "EST_3_BLOCK_EXPONENT,Block exponent from estimator 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 8.--13. "EST_2_BLOCK_EXPONENT,Block exponent from estimator 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 0.--5. "EST_1_BLOCK_EXPONENT,Block exponent from estimator 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"

    group.long 0x2A0++0x03
        line.long 0x00 "MON_TIMER_IN_CTRL,Monitor Timer control for input stage"
            bitfld.long 0x00 31. "MON_TMR_IN_ENA,Input stage monitor timer enable it's enable by default" "0,1"
            newline
            hexmask.long 0x00 0.--30. 1. "MON_TMR_IN_TIMEOUT_SEL,Input stage monitor timer timeout selection default is 1ms (500MHz)"

    rgroup.long 0x2A4++0x03
        line.long 0x00 "MON_TIMER_IN_STAT,Monitor Timer control for input stage"
            bitfld.long 0x00 31. "MON_TMR_IN_RUNNING,Input stage monitor timer running flag" "0,1"
            newline
            hexmask.long 0x00 0.--30. 1. "MON_TMR_IN_TIMER_VAL,Input stage monitor timer timer counter current value"

    group.long 0x2A8++0x03
        line.long 0x00 "MON_TIMER_PROC_CTRL,Monitor Timer control for processing stage"
            bitfld.long 0x00 31. "MON_TMR_PROC_ENA,Processing stage monitor timer enable it's enable by default" "0,1"
            newline
            hexmask.long 0x00 0.--30. 1. "MON_TMR_PROC_TIMEOUT_SEL,Processing stage monitor timer timeout selection default is 1ms (500MHz)"

    rgroup.long 0x2AC++0x03
        line.long 0x00 "MON_TIMER_PROC_STAT,Monitor Timer control for processing stage"
            bitfld.long 0x00 31. "MON_TMR_PROC_RUNNING,Processing stage monitor timer running flag" "0,1"
            newline
            hexmask.long 0x00 0.--30. 1. "MON_TMR_PROC_TIMER_VAL,Processing stage monitor timer timer counter current value"

    group.long 0x2B0++0x03
        line.long 0x00 "MON_TIMER_OUT_CTRL,Monitor Timer control for output stage"
            bitfld.long 0x00 31. "MON_TMR_OUT_ENA,Output stage monitor timer enable it's enable by default" "0,1"
            newline
            hexmask.long 0x00 0.--30. 1. "MON_TMR_OUT_TIMEOUT_SEL,Output stage monitor timer timeout selection default is 1ms (500MHz)"

    rgroup.long 0x2B4++0x03
        line.long 0x00 "MON_TIMER_OUT_STAT,Monitor Timer control for output stage"
            bitfld.long 0x00 31. "MON_TMR_OUT_RUNNING,Output stage monitor timer running flag" "0,1"
            newline
            hexmask.long 0x00 0.--30. 1. "MON_TMR_OUT_TIMER_VAL,Output stage monitor timer timer counter current value"
    rgroup.long 0x2B8++0x03
        line.long 0x00 "DEBUG_REG_1,Debug register"
            bitfld.long 0x00 30. "AXI_M_OUT_WR_BUSY,Indicates if a write operation is in progress" "0,1"
            newline
            bitfld.long 0x00 28.--29. "AXI_M_OUT_WR_INT,Bit 0 indicates if it's busy bit 1 if an error happened" "0,1,2,3"
            newline
            bitfld.long 0x00 26. "AXI_M_IN_RD_BUSY,Indicates if a read operation is in progress" "0,1"
            newline
            bitfld.long 0x00 24.--25. "AXI_M_IN_RD_INT,Bit 0 indicates if it's busy bit 1 if an error happened" "0,1,2,3"
            newline
            bitfld.long 0x00 22.--23. "OUT_RD_MEM_FSM_STATE," "0,1,2,3"
            newline
            bitfld.long 0x00 20.--21. "PROC_RD_MEM_FSM_STATE," "0,1,2,3"
            newline
            bitfld.long 0x00 16.--18. "PROC_WR_MEM_FSM_STATE," "?,?,2: PROCESSING,?,4: WAITING_SYNC other values,?..."
            newline
            bitfld.long 0x00 12.--14. "IN_WR_MEM_FSM_STATE," "?,?,2: PROCESSING,?,4: WAITING_SYNC other values,?..."
            newline
            bitfld.long 0x00 8.--10. "OUT_STAGE_FSM_STATE," "?,1: ST_LOAD_NEW_CMD,2: ST_STAGE_NOP,3: ST_BUSY,4: ST_WAIT_NXT_STAGE,5: ST_FINISH_CMD,6: ST_EMPTY_DPATH,7: ST_EMPTY_PIPE"
            newline
            bitfld.long 0x00 4.--6. "PROC_STAGE_FSM_STATE," "?,1: ST_LOAD_NEW_CMD,2: ST_STAGE_NOP,3: ST_BUSY,4: ST_WAIT_NXT_STAGE,5: ST_FINISH_CMD,6: ST_EMPTY_DPATH,7: ST_EMPTY_PIPE"
            newline
            bitfld.long 0x00 3. "WAITING_FETCH_TRIGGER,Indicates if the input stage is waiting for the fetch trigger" "0,1"
            newline
            bitfld.long 0x00 0.--2. "IN_STAGE_FSM_STATE," "?,1: ST_LOAD_NEW_CMD,2: ST_STAGE_NOP,3: ST_BUSY,4: ST_WAIT_NXT_STAGE,5: ST_FINISH_CMD,6: ST_EMPTY_DPATH,7: ST_EMPTY_PIPE"
    rgroup.long 0x2BC++0x03
        line.long 0x00 "DEBUG_REG_2,Debug register"
            bitfld.long 0x00 28. "DDM_READ_MODE_ERR,It is asserted if the DDM mode is enabled and the input_manager is bypassed or a non-power of 2 size is used" "0,1"
            newline
            bitfld.long 0x00 27. "REAL_TO_COMPLEX_MODE_ERR,It is asserted under two condition: If IN_FETCH_MODE is set to 6 and a real FFT type is set or If IN_FETCH_MODE is set to 6 and the IN_SIZE is bigger than 127" "0,1"
            newline
            bitfld.long 0x00 26. "EST_READ_SIZE_ERR,It is asserted when a read with reorder is commanded from the output stage to any estimator and the IN_SIZE is not a power of 2 minus 1" "0,1"
            newline
            bitfld.long 0x00 25. "EST_3_OUTPUT_FORMAT_ERR,It is asserted if output from the estimator 3 is enabled and output format is not set to 1" "0,1"
            newline
            bitfld.long 0x00 24. "EST_2_OUTPUT_FORMAT_ERR,It is asserted if output from the estimator 2 is enabled and output format is not set to 1" "0,1"
            newline
            bitfld.long 0x00 23. "EST_1_OUTPUT_FORMAT_ERR,It is asserted if output from the estimator 1 is enabled and output format is not set to 1" "0,1"
            newline
            bitfld.long 0x00 22. "EST_OUTPUT_READ_ERR,It is asserted if output from estimators is enabled and the processing stage is active or the output stage is inactive or if read from any estimator is not enabled" "0,1"
            newline
            bitfld.long 0x00 21. "ALTERNATE_BANKS_ERR,If dpmem access is used and alterante_dpmem_banks is active one of the generic counters must be in use" "0,1"
            newline
            bitfld.long 0x00 20. "POSP_INVALID_SIZE_ERR,Post-processor invalid size error is asserted when the block is active (processing stage enabled and post-processor not bypassed) and one of the following conditions is met: - FFT core is not bypassed and PREP_BLOCK_SIZE !=.." "0,1"
            newline
            bitfld.long 0x00 19. "PREP_INVALID_SIZE_ERR,Pre-processor invalid size error is asserted when the block is active (processing stage enabled and pre-processor not bypassed) and one of the following conditions is met: - FFT core is not bypassed and PREP_BLOCK_SIZE !=.." "0,1"
            newline
            bitfld.long 0x00 18. "IN_SIZE_DATA_REORDER_ERR,It is triggered if zero padding is not requested (FFT_TYPE==3 and FORCE_ZERO_PAD!=0) but the IN_SIZE is not power of 2 and the input_manager or output_manager blocks are configured for data reordering" "0,1"
            newline
            bitfld.long 0x00 17. "IN_SIZE_UNCOMP_ERR,If input stage is enable decompressor is bypassed and fetch_mode!=2 in_size shall be odd" "0,1"
            newline
            bitfld.long 0x00 16. "COMP_NO_ITER_ERR,It is asserted if the output stage is active the iteration mode is 0 and the compressor level is not 0" "0,1"
            newline
            bitfld.long 0x00 15. "DECOMP_NO_ITER_ERR,It is asserted if the input stage is active the iteration mode is 0 and the decompressor level is not 0 and the IN_FETCH_MODE is not 2" "0,1"
            newline
            bitfld.long 0x00 14. "FFT_REAL_ERR,It is asserted if FFT_TYPE is 1 or 2 (real modes) the output stage is enabled and the OUTPUT_MNGR_MODE!=0" "0,1"
            newline
            bitfld.long 0x00 13. "FFT_SIZE_ERR,Is asserted if FFT_TYPE!=3 and IN_SIZE is not a power of 2 minus 1 and INPUT_MNGR_MODE==3 (bypass)" "0,1"
            newline
            bitfld.long 0x00 12. "FETCH_MODE_MIPI_ADDR_ERR,It's asserted if IN_FETCH_MODE==2 and input stage is enabled and IN_ADDR_START is different from the MIPI's address" "0,1"
            newline
            bitfld.long 0x00 11. "FETCH_MODE_MIPI_FFT_ERR,It's asserted if IN_FETCH_MODE==2 and input stage is enabled and FFT_TYPE is different from 2 (Real 2N) or 3 (bypass)" "0,1"
            newline
            bitfld.long 0x00 10. "OUT_MNGR_MODE_2_ERR,It's asserted if OUTPUT_MNGR_MODE==2 (bypass) and any of the following conditions happen: - PROC_OP_SET and OUT_OP_SET aren't either both 1 or both" "0,1"
            newline
            bitfld.long 0x00 9. "IN_MNGR_MODE_3_ERR,It is asserted in two conditions: - If the input manager is bypassed and IN_OP_SET and PROC_OP_SET are neither both 1 nor both 0" "0,1"
            newline
            bitfld.long 0x00 8. "IN_MNGR_MODE_1_ERR,It is asserted if INPUT_MNGR_MODE=1 and IN_OP_SET=1 or IN_SIZE is different from 31 63 127 or 255 (zero padding is needed)" "0,1"
            newline
            hexmask.long.byte 0x00 0.--6. 1. "INVALID_CMD_ID,CMD_ID of the last invalid command"

    group.long 0x2C0++0x03
        line.long 0x00 "DEBUG_REG_3,Debug register"
            bitfld.long 0x00 0.--4. "TESTMUX_SEL,See the RA specification" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    group.long 0x2C4++0x03
        line.long 0x00 "IDMA_TRIGGER_ENA,BBE32 iDMA interaction enable"
            bitfld.long 0x00 4. "CMD_DONE_IDMA_TRIG_ENA,iDMA trigger enable for last stage cmd_done event" "0,1"
            newline
            bitfld.long 0x00 3. "OUT_CMD_IDMA_TRIG_ENA,iDMA trigger enable for output stage cmd_done event" "0,1"
            newline
            bitfld.long 0x00 2. "PROC_CMD_IDMA_TRIG_ENA,iDMA trigger enable for processing stage cmd_done event" "0,1"
            newline
            bitfld.long 0x00 1. "LOAD_CMD_IDMA_TRIG_ENA,iDMA trigger enable for input stage cmd_done event" "0,1"
            newline
            bitfld.long 0x00 0. "CQ_REFILL_REQ_IDMA_TRIG_ENA,iDMA trigger enable for CQ re-fill request" "0,1"

    rgroup.long 0x2C8++0x03
        line.long 0x00 "IDMA_TRIGGER_FLAG,BBE32 iDMA interaction status"
            bitfld.long 0x00 4. "CMD_DONE_IDMA_TRIG_FLAG,iDMA trigger flag for last stage cmd_done event" "0,1"
            newline
            bitfld.long 0x00 3. "OUT_CMD_IDMA_TRIG_FLAG,iDMA trigger flag for output stage cmd_done event" "0,1"
            newline
            bitfld.long 0x00 2. "PROC_CMD_IDMA_TRIG_FLAG,iDMA trigger flag for processing stage cmd_done event" "0,1"
            newline
            bitfld.long 0x00 1. "LOAD_CMD_IDMA_TRIG_FLAG,iDMA trigger flag for input stage cmd_done event" "0,1"
            newline
            bitfld.long 0x00 0. "CQ_REFILL_REQ_IDMA_TRIG_FLAG,iDMA trigger flag for CQ re-fill request" "0,1"

    group.long 0x2CC++0x03
        line.long 0x00 "CQMEM_ECC_CONTROL,Control registers for CQMEM ECC Engine"
            hexmask.long.word 0x00 16.--31. 1. "CQMEM_ECC_SEC_CNT_THR,When the ECC SEC counter reach this value an IRQ is raised"
            newline
            bitfld.long 0x00 2. "CQMEM_ECC_SEC_CNT_CLR,Toggle to '1' to clear CQMEM SEC counter" "0,1"
            newline
            bitfld.long 0x00 1. "CQMEM_ECC_DEC_BYPASS,ECC decoder bypass for Command Queue memory" "0,1"
            newline
            bitfld.long 0x00 0. "CQMEM_ECC_ENC_BYPASS,ECC encoder bypass for Command Queue memory" "0,1"

    rgroup.long 0x2D0++0x03
        line.long 0x00 "CQMEM_ECC_STATUS,Status registers for CQMEM ECC Engine"
            hexmask.long.word 0x00 0.--15. 1. "CQMEM_ECC_SEC_CNT,Counts the amount of SEC in the CQMEM"

    group.long 0x2D4++0x03
        line.long 0x00 "WCMEM_ECC_CONTROL,Control registers for WCMEM ECC Engine"
            hexmask.long.word 0x00 16.--31. 1. "WCMEM_ECC_SEC_CNT_THR,When the ECC SEC counter reach this value an IRQ is raised"
            newline
            bitfld.long 0x00 2. "WCMEM_ECC_SEC_CNT_CLR,Toggle to '1' to clear WCMEM SEC counter" "0,1"
            newline
            bitfld.long 0x00 1. "WCMEM_ECC_DEC_BYPASS,ECC decoder bypass for Command Queue memory" "0,1"
            newline
            bitfld.long 0x00 0. "WCMEM_ECC_ENC_BYPASS,ECC encoder bypass for Command Queue memory" "0,1"

    rgroup.long 0x2D8++0x03
        line.long 0x00 "WCMEM_ECC_STATUS,Status registers for WCMEM ECC Engine"
            hexmask.long.word 0x00 0.--15. 1. "WCMEM_ECC_SEC_CNT,Counts the amount of SEC in the WCMEM"

    group.long 0x2DC++0x03
        line.long 0x00 "IDXMEM_ECC_CONTROL,Control registers for IDXMEM ECC Engine"
            hexmask.long.word 0x00 16.--31. 1. "IDXMEM_ECC_SEC_CNT_THR,When the ECC SEC counter reach this value an IRQ is raised"
            newline
            bitfld.long 0x00 2. "IDXMEM_ECC_SEC_CNT_CLR,Toggle to '1' to clear IDXMEM SEC counter" "0,1"
            newline
            bitfld.long 0x00 1. "IDXMEM_ECC_DEC_BYPASS,ECC decoder bypass for Command Queue memory" "0,1"
            newline
            bitfld.long 0x00 0. "IDXMEM_ECC_ENC_BYPASS,ECC encoder bypass for Command Queue memory" "0,1"

    rgroup.long 0x2E0++0x03
        line.long 0x00 "IDXMEM_ECC_STATUS,Status registers for IDXMEM ECC Engine"
            hexmask.long.word 0x00 0.--15. 1. "IDXMEM_ECC_SEC_CNT,Counts the amount of SEC in the IDXMEM"

    group.long 0x2E4++0x03
        line.long 0x00 "PHMEM_ECC_CONTROL,Control registers for PHMEM ECC Engine"
            hexmask.long.word 0x00 16.--31. 1. "PHMEM_ECC_SEC_CNT_THR,When the ECC SEC counter reach this value an IRQ is raised"
            newline
            bitfld.long 0x00 2. "PHMEM_ECC_SEC_CNT_CLR,Toggle to '1' to clear PHMEM SEC counter" "0,1"
            newline
            bitfld.long 0x00 1. "PHMEM_ECC_DEC_BYPASS,ECC decoder bypass for Command Queue memory" "0,1"
            newline
            bitfld.long 0x00 0. "PHMEM_ECC_ENC_BYPASS,ECC encoder bypass for Command Queue memory" "0,1"

    rgroup.long 0x2E8++0x03
        line.long 0x00 "PHMEM_ECC_STATUS,Status registers for PHMEM ECC Engine"
            hexmask.long.word 0x00 0.--15. 1. "PHMEM_ECC_SEC_CNT,Counts the amount of SEC in the PHMEM"

    group.long 0x2EC++0x03
        line.long 0x00 "ESTMEM_1_ECC_CONTROL,Control registers for ESTMEM_1 ECC Engine"
            hexmask.long.word 0x00 16.--31. 1. "ESTMEM_1_ECC_SEC_CNT_THR,When the ECC SEC counter reach this value an IRQ is raised"
            newline
            bitfld.long 0x00 2. "ESTMEM_1_ECC_SEC_CNT_CLR,Toggle to '1' to clear ESTMEM_1 SEC counter" "0,1"
            newline
            bitfld.long 0x00 1. "ESTMEM_1_ECC_DEC_BYPASS,ECC decoder bypass for Command Queue memory" "0,1"
            newline
            bitfld.long 0x00 0. "ESTMEM_1_ECC_ENC_BYPASS,ECC encoder bypass for Command Queue memory" "0,1"

    rgroup.long 0x2F0++0x03
        line.long 0x00 "ESTMEM_1_ECC_STATUS,Status registers for ESTMEM_1 ECC Engine"
            hexmask.long.word 0x00 0.--15. 1. "ESTMEM_1_ECC_SEC_CNT,Counts the amount of SEC in the ESTMEM_1"

    group.long 0x2F4++0x03
        line.long 0x00 "ESTMEM_2_ECC_CONTROL,Control registers for ESTMEM_2 ECC Engine"
            hexmask.long.word 0x00 16.--31. 1. "ESTMEM_2_ECC_SEC_CNT_THR,When the ECC SEC counter reach this value an IRQ is raised"
            newline
            bitfld.long 0x00 2. "ESTMEM_2_ECC_SEC_CNT_CLR,Toggle to '1' to clear ESTMEM_2 SEC counter" "0,1"
            newline
            bitfld.long 0x00 1. "ESTMEM_2_ECC_DEC_BYPASS,ECC decoder bypass for Command Queue memory" "0,1"
            newline
            bitfld.long 0x00 0. "ESTMEM_2_ECC_ENC_BYPASS,ECC encoder bypass for Command Queue memory" "0,1"

    rgroup.long 0x2F8++0x03
        line.long 0x00 "ESTMEM_2_ECC_STATUS,Status registers for ESTMEM_2 ECC Engine"
            hexmask.long.word 0x00 0.--15. 1. "ESTMEM_2_ECC_SEC_CNT,Counts the amount of SEC in the ESTMEM_2"

    group.long 0x2FC++0x03
        line.long 0x00 "ESTMEM_3_ECC_CONTROL,Control registers for ESTMEM_3 ECC Engine"
            hexmask.long.word 0x00 16.--31. 1. "ESTMEM_3_ECC_SEC_CNT_THR,When the ECC SEC counter reach this value an IRQ is raised"
            newline
            bitfld.long 0x00 2. "ESTMEM_3_ECC_SEC_CNT_CLR,Toggle to '1' to clear ESTMEM_3 SEC counter" "0,1"
            newline
            bitfld.long 0x00 1. "ESTMEM_3_ECC_DEC_BYPASS,ECC decoder bypass for Command Queue memory" "0,1"
            newline
            bitfld.long 0x00 0. "ESTMEM_3_ECC_ENC_BYPASS,ECC encoder bypass for Command Queue memory" "0,1"

    rgroup.long 0x300++0x03
        line.long 0x00 "ESTMEM_3_ECC_STATUS,Status registers for ESTMEM_3 ECC Engine"
            hexmask.long.word 0x00 0.--15. 1. "ESTMEM_3_ECC_SEC_CNT,Counts the amount of SEC in the ESTMEM_3"

    group.long 0x304++0x03
        line.long 0x00 "ESTMEM_4_ECC_CONTROL,Control registers for ESTMEM_4 ECC Engine"
            hexmask.long.word 0x00 16.--31. 1. "ESTMEM_4_ECC_SEC_CNT_THR,When the ECC SEC counter reach this value an IRQ is raised"
            newline
            bitfld.long 0x00 2. "ESTMEM_4_ECC_SEC_CNT_CLR,Toggle to '1' to clear ESTMEM_4 SEC counter" "0,1"
            newline
            bitfld.long 0x00 1. "ESTMEM_4_ECC_DEC_BYPASS,ECC decoder bypass for Command Queue memory" "0,1"
            newline
            bitfld.long 0x00 0. "ESTMEM_4_ECC_ENC_BYPASS,ECC encoder bypass for Command Queue memory" "0,1"

    rgroup.long 0x308++0x03
        line.long 0x00 "ESTMEM_4_ECC_STATUS,Status registers for ESTMEM_4 ECC Engine"
            hexmask.long.word 0x00 0.--15. 1. "ESTMEM_4_ECC_SEC_CNT,Counts the amount of SEC in the ESTMEM_4"

    group.long 0x30C++0x03
        line.long 0x00 "DPMEM_0_ECC_CONTROL,Control registers for DPMEM_0 ECC Engine"
            hexmask.long.word 0x00 16.--31. 1. "DPMEM_0_ECC_SEC_CNT_THR,When the ECC SEC counter reach this value an IRQ is raised"
            newline
            bitfld.long 0x00 2. "DPMEM_0_ECC_SEC_CNT_CLR,Toggle to '1' to clear DPMEM_0 SEC counter" "0,1"
            newline
            bitfld.long 0x00 1. "DPMEM_0_ECC_DEC_BYPASS,ECC decoder bypass for Command Queue memory" "0,1"
            newline
            bitfld.long 0x00 0. "DPMEM_0_ECC_ENC_BYPASS,ECC encoder bypass for Command Queue memory" "0,1"

    rgroup.long 0x310++0x03
        line.long 0x00 "DPMEM_0_ECC_STATUS,Status registers for DPMEM_0 ECC Engine"
            hexmask.long.word 0x00 0.--15. 1. "DPMEM_0_ECC_SEC_CNT,Counts the amount of SEC in the DPMEM_0"

    group.long 0x314++0x03
        line.long 0x00 "DPMEM_1_ECC_CONTROL,Control registers for DPMEM_1 ECC Engine"
            hexmask.long.word 0x00 16.--31. 1. "DPMEM_1_ECC_SEC_CNT_THR,When the ECC SEC counter reach this value an IRQ is raised"
            newline
            bitfld.long 0x00 2. "DPMEM_1_ECC_SEC_CNT_CLR,Toggle to '1' to clear DPMEM_1 SEC counter" "0,1"
            newline
            bitfld.long 0x00 1. "DPMEM_1_ECC_DEC_BYPASS,ECC decoder bypass for Command Queue memory" "0,1"
            newline
            bitfld.long 0x00 0. "DPMEM_1_ECC_ENC_BYPASS,ECC encoder bypass for Command Queue memory" "0,1"

    rgroup.long 0x318++0x03
        line.long 0x00 "DPMEM_1_ECC_STATUS,Status registers for DPMEM_1 ECC Engine"
            hexmask.long.word 0x00 0.--15. 1. "DPMEM_1_ECC_SEC_CNT,Counts the amount of SEC in the DPMEM_1"

    group.long 0x31C++0x03
        line.long 0x00 "DPMEM_2_ECC_CONTROL,Control registers for DPMEM_2 ECC Engine"
            hexmask.long.word 0x00 16.--31. 1. "DPMEM_2_ECC_SEC_CNT_THR,When the ECC SEC counter reach this value an IRQ is raised"
            newline
            bitfld.long 0x00 2. "DPMEM_2_ECC_SEC_CNT_CLR,Toggle to '1' to clear DPMEM_2 SEC counter" "0,1"
            newline
            bitfld.long 0x00 1. "DPMEM_2_ECC_DEC_BYPASS,ECC decoder bypass for Command Queue memory" "0,1"
            newline
            bitfld.long 0x00 0. "DPMEM_2_ECC_ENC_BYPASS,ECC encoder bypass for Command Queue memory" "0,1"

    rgroup.long 0x320++0x03
        line.long 0x00 "DPMEM_2_ECC_STATUS,Status registers for DPMEM_2 ECC Engine"
            hexmask.long.word 0x00 0.--15. 1. "DPMEM_2_ECC_SEC_CNT,Counts the amount of SEC in the DPMEM_2"

    group.long 0x324++0x03
        line.long 0x00 "DPMEM_3_ECC_CONTROL,Control registers for DPMEM_3 ECC Engine"
            hexmask.long.word 0x00 16.--31. 1. "DPMEM_3_ECC_SEC_CNT_THR,When the ECC SEC counter reach this value an IRQ is raised"
            newline
            bitfld.long 0x00 2. "DPMEM_3_ECC_SEC_CNT_CLR,Toggle to '1' to clear DPMEM_3 SEC counter" "0,1"
            newline
            bitfld.long 0x00 1. "DPMEM_3_ECC_DEC_BYPASS,ECC decoder bypass for Command Queue memory" "0,1"
            newline
            bitfld.long 0x00 0. "DPMEM_3_ECC_ENC_BYPASS,ECC encoder bypass for Command Queue memory" "0,1"

    rgroup.long 0x328++0x03
        line.long 0x00 "DPMEM_3_ECC_STATUS,Status registers for DPMEM_3 ECC Engine"
            hexmask.long.word 0x00 0.--15. 1. "DPMEM_3_ECC_SEC_CNT,Counts the amount of SEC in the DPMEM_3"

    group.long 0x32C++0x03
        line.long 0x00 "FUSA_TESTMODES,Testmodes for safety mechanisms"
            hexmask.long.word 0x00 16.--31. 1. "TM_FORCE_AXI_OUT_PARITY_ERR,Each bit is used to generate an error in any of the AXI-OUT signals: - TM_FORCE_AXI_OUT_PARITY_ERR[0]: axi_m_out_awaddr - TM_FORCE_AXI_OUT_PARITY_ERR[1]: control_0 signals (axi_m_out_awsize axi_m_out_awburst axi_m_out_awlock.."
            newline
            hexmask.long.word 0x00 0.--12. 1. "TM_FORCE_AXI_IN_PARITY_ERR,Each bit is used to generate an error in any of the AXI-IN signals: - TM_FORCE_AXI_IN_PARITY_ERR[0]: axi_m_in_araddr - TM_FORCE_AXI_IN_PARITY_ERR[1]: control_0 signals (axi_m_in_arsize axi_m_in_arburst axi_m_in_arlock.."
    group.long 0x330++0x03
        line.long 0x00 "OUT_ADDR_RANGE_CONTROL,Control register for output address range feature"
            bitfld.long 0x00 0.--3. "OUT_ADDR_ACTIVE_REGIONS,Number of active output address valid regions" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x334++0x03
        line.long 0x00 "OUT_ADDR_RANGE_START_REG_0,Output address range start register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_START_0,Start address for region 0"
    group.long 0x338++0x03
        line.long 0x00 "OUT_ADDR_RANGE_END_REG_0,Output address range end register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_END_0,End address for region 0"
    group.long 0x33C++0x03
        line.long 0x00 "OUT_ADDR_RANGE_START_REG_1,Output address range start register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_START_1,Start address for region 1"
    group.long 0x340++0x03
        line.long 0x00 "OUT_ADDR_RANGE_END_REG_1,Output address range end register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_END_1,End address for region 1"
    group.long 0x344++0x03
        line.long 0x00 "OUT_ADDR_RANGE_START_REG_2,Output address range start register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_START_2,Start address for region 2"
    group.long 0x348++0x03
        line.long 0x00 "OUT_ADDR_RANGE_END_REG_2,Output address range end register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_END_2,End address for region 2"
    group.long 0x34C++0x03
        line.long 0x00 "OUT_ADDR_RANGE_START_REG_3,Output address range start register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_START_3,Start address for region 3"
    group.long 0x350++0x03
        line.long 0x00 "OUT_ADDR_RANGE_END_REG_3,Output address range end register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_END_3,End address for region 3"
    group.long 0x354++0x03
        line.long 0x00 "OUT_ADDR_RANGE_START_REG_4,Output address range start register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_START_4,Start address for region 4"
    group.long 0x358++0x03
        line.long 0x00 "OUT_ADDR_RANGE_END_REG_4,Output address range end register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_END_4,End address for region 4"
    group.long 0x35C++0x03
        line.long 0x00 "OUT_ADDR_RANGE_START_REG_5,Output address range start register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_START_5,Start address for region 5"
    group.long 0x360++0x03
        line.long 0x00 "OUT_ADDR_RANGE_END_REG_5,Output address range end register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_END_5,End address for region 5"
    group.long 0x364++0x03
        line.long 0x00 "OUT_ADDR_RANGE_START_REG_6,Output address range start register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_START_6,Start address for region 6"
    group.long 0x368++0x03
        line.long 0x00 "OUT_ADDR_RANGE_END_REG_6,Output address range end register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_END_6,End address for region 6"
    group.long 0x36C++0x03
        line.long 0x00 "OUT_ADDR_RANGE_START_REG_7,Output address range start register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_START_7,Start address for region 7"
    group.long 0x370++0x03
        line.long 0x00 "OUT_ADDR_RANGE_END_REG_7,Output address range end register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_END_7,End address for region 7"
    group.long 0x374++0x03
        line.long 0x00 "OUT_ADDR_RANGE_START_REG_8,Output address range start register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_START_8,Start address for region 8"
    group.long 0x378++0x03
        line.long 0x00 "OUT_ADDR_RANGE_END_REG_8,Output address range end register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_END_8,End address for region 8"
    group.long 0x37C++0x03
        line.long 0x00 "OUT_ADDR_RANGE_START_REG_9,Output address range start register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_START_9,Start address for region 9"
    group.long 0x380++0x03
        line.long 0x00 "OUT_ADDR_RANGE_END_REG_9,Output address range end register"
            hexmask.long 0x00 0.--31. 1. "OUT_ADDR_RANGE_END_9,End address for region 9"
    group.long 0x384++0x03
        line.long 0x00 "SPARE,Spare Register"
            hexmask.long 0x00 0.--31. 1. "SPARE,Spare registers"
    group.long 0x388++0x03
        line.long 0x00 "CTL_LOCK,Lock control"
            hexmask.long 0x00 0.--31. 1. "CTL_RA_LOCK_KEY,Write 0x12A01889 to allow write access to this SFR bank"

    rgroup.long 0x38C++0x03
        line.long 0x00 "STS_LOCK,Lock status"
            bitfld.long 0x00 0. "STS_RA_LOCK_N,Lock status for this SFR bank" "0,1"
tree.end

tree "RT640 ()"
    base ad:0x91700000
    rgroup.long 0x00++0x03
        line.long 0x00 "HWC_CORE_ID,hwc_core_id"
            hexmask.long.word 0x00 16.--31. 1. "Reserved,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "NextCoreId,The first HW Core is provided with ID of 0x00"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CoreId,This field identifies an ID representing the functionality provided by the HWC"
    rgroup.long 0x04++0x03
        line.long 0x00 "HWC_CORE_INFO,DPARC Core Information"
            hexmask.long.byte 0x00 24.--31. 1. "RevisionNumber,REV1 REV2 etc"
            newline
            hexmask.long.word 0x00 8.--23. 1. "BlockId,Nonmasked masked LMDPL etc"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CoreFamily,AES DES SHA1 etc"
    rgroup.long 0x08++0x03
        line.long 0x00 "HWC_CORE_INFO_1,DPARC Core Information"
            hexmask.long.word 0x00 16.--31. 1. "SvnLastChangeRevision,svnlastchangerevision"
            newline
            hexmask.long.word 0x00 4.--15. 1. "MinorVersion,minorversion"
            newline
            bitfld.long 0x00 0.--3. "MajorVersion,majorversion" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    repeat 4. (increment 0 1) (increment 0 0x4)
        rgroup.long ($2+0x10)++0x03
            line.long 0x00 "HWC_CORE_KEY_CONTRIBUTION[$1],This 128b value is the key contribution of this Core towards the amalgamated netlist key"
                hexmask.long 0x00 0.--31. 1. "CoreKeyContribution,corekeycontribution"
    repeat.end
    rgroup.long 0x20++0x03
        line.long 0x00 "HWC_CORE_ACCESS_CONTROL,Access control for this HWC"
            hexmask.long.byte 0x00 24.--31. 1. "AllowedInternalMaster2,allowedinternalmaster2"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "AllowedInternalMaster1,allowedinternalmaster1"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "AllowedInternalMaster0,allowedinternalmaster0"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CoreKeyContributionMaster,corekeycontributionmaster"

    group.long 0x30++0x03
        line.long 0x00 "HWC_CORE_PERMISSIONS,The Machine Code or HW will write to this register when a container is loaded with a new root"
            hexmask.long 0x00 2.--31. 1. "Reserved,Reserved"
            newline
            bitfld.long 0x00 0.--1. "CoreEnable," "0,1,2,3"
    group.long 0x100++0x03
        line.long 0x00 "HWC_CORE_LOCK_MASTER,hwc_core_lock_master"
            hexmask.long.word 0x00 16.--31. 1. "Reserved_31_6,reserved_31_6"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "LockedMaster,lockedmaster"
            newline
            rbitfld.long 0x00 3.--7. "Reserved_7_3,reserved_7_3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            rbitfld.long 0x00 2. "CsbMachineLock,csbmachinelock" "0,1"
            newline
            bitfld.long 0x00 1. "CsbSupervisorLock,csbsupervisorlock" "0,1"
            newline
            bitfld.long 0x00 0. "CsbUserLock,csbuserlock" "0,1"
    group.long 0x110++0x03
        line.long 0x00 "HWC_CORE_INTERRUPT,coreInterrupt = |{CoreInterrupt & CoreInterruptMask"
            bitfld.long 0x00 31. "SocInterruptInput29,socinterruptinput29" "0,1"
            newline
            bitfld.long 0x00 30. "SocInterruptInput28,socinterruptinput28" "0,1"
            newline
            bitfld.long 0x00 29. "SocInterruptInput27,socinterruptinput27" "0,1"
            newline
            bitfld.long 0x00 28. "SocInterruptInput26,socinterruptinput26" "0,1"
            newline
            bitfld.long 0x00 27. "SocInterruptInput25,socinterruptinput25" "0,1"
            newline
            bitfld.long 0x00 26. "SocInterruptInput24,socinterruptinput24" "0,1"
            newline
            bitfld.long 0x00 25. "SocInterruptInput23,socinterruptinput23" "0,1"
            newline
            bitfld.long 0x00 24. "SocInterruptInput22,socinterruptinput22" "0,1"
            newline
            bitfld.long 0x00 23. "SocInterruptInput21,socinterruptinput21" "0,1"
            newline
            bitfld.long 0x00 22. "SocInterruptInput20,socinterruptinput20" "0,1"
            newline
            bitfld.long 0x00 21. "SocInterruptInput19,socinterruptinput19" "0,1"
            newline
            bitfld.long 0x00 20. "SocInterruptInput18,socinterruptinput18" "0,1"
            newline
            bitfld.long 0x00 19. "SocInterruptInput17,socinterruptinput17" "0,1"
            newline
            bitfld.long 0x00 18. "SocInterruptInput16,socinterruptinput16" "0,1"
            newline
            bitfld.long 0x00 17. "SocInterruptInput15,socinterruptinput15" "0,1"
            newline
            bitfld.long 0x00 16. "SocInterruptInput14,socinterruptinput14" "0,1"
            newline
            bitfld.long 0x00 15. "SocInterruptInput13,socinterruptinput13" "0,1"
            newline
            bitfld.long 0x00 14. "SocInterruptInput12,socinterruptinput12" "0,1"
            newline
            bitfld.long 0x00 13. "SocInterruptInput11,socinterruptinput11" "0,1"
            newline
            bitfld.long 0x00 12. "SocInterruptInput10,socinterruptinput10" "0,1"
            newline
            bitfld.long 0x00 11. "SocInterruptInput9,socinterruptinput9" "0,1"
            newline
            bitfld.long 0x00 10. "SocInterruptInput8,socinterruptinput8" "0,1"
            newline
            bitfld.long 0x00 9. "ESW_ESW_2_HLOS_LENGTH_RTZ,esw_esw_2_hlos_length_rtz" "0,1"
            newline
            bitfld.long 0x00 8. "ESW_HLOS_2_ESW_LENGTH_CFZ,esw_hlos_2_esw_length_cfz" "0,1"
            newline
            bitfld.long 0x00 7. "SocInterruptInput7,socinterruptinput7" "0,1"
            newline
            bitfld.long 0x00 6. "SocInterruptInput6,socinterruptinput6" "0,1"
            newline
            bitfld.long 0x00 5. "SocInterruptInput5,socinterruptinput5" "0,1"
            newline
            bitfld.long 0x00 4. "SocInterruptInput4,socinterruptinput4" "0,1"
            newline
            bitfld.long 0x00 3. "SocInterruptInput3,socinterruptinput3" "0,1"
            newline
            bitfld.long 0x00 2. "SocInterruptInput2,socinterruptinput2" "0,1"
            newline
            bitfld.long 0x00 1. "SocInterruptInput1,socinterruptinput1" "0,1"
            newline
            bitfld.long 0x00 0. "SocInterruptInput0,socinterruptinput0" "0,1"
    group.long 0x114++0x03
        line.long 0x00 "HWC_CORE_INTERRUPT_MASK,hwc_core_interrupt_mask"
            bitfld.long 0x00 31. "SocInterruptInput29Mask,socinterruptinput29mask" "0,1"
            newline
            bitfld.long 0x00 30. "SocInterruptInput28Mask,socinterruptinput28mask" "0,1"
            newline
            bitfld.long 0x00 29. "SocInterruptInput27Mask,socinterruptinput27mask" "0,1"
            newline
            bitfld.long 0x00 28. "SocInterruptInput26Mask,socinterruptinput26mask" "0,1"
            newline
            bitfld.long 0x00 27. "SocInterruptInput25Mask,socinterruptinput25mask" "0,1"
            newline
            bitfld.long 0x00 26. "SocInterruptInput24Mask,socinterruptinput24mask" "0,1"
            newline
            bitfld.long 0x00 25. "SocInterruptInput23Mask,socinterruptinput23mask" "0,1"
            newline
            bitfld.long 0x00 24. "SocInterruptInput22Mask,socinterruptinput22mask" "0,1"
            newline
            bitfld.long 0x00 23. "SocInterruptInput21Mask,socinterruptinput21mask" "0,1"
            newline
            bitfld.long 0x00 22. "SocInterruptInput20Mask,socinterruptinput20mask" "0,1"
            newline
            bitfld.long 0x00 21. "SocInterruptInput19Mask,socinterruptinput19mask" "0,1"
            newline
            bitfld.long 0x00 20. "SocInterruptInput18Mask,socinterruptinput18mask" "0,1"
            newline
            bitfld.long 0x00 19. "SocInterruptInput17Mask,socinterruptinput17mask" "0,1"
            newline
            bitfld.long 0x00 18. "SocInterruptInput16Mask,socinterruptinput16mask" "0,1"
            newline
            bitfld.long 0x00 17. "SocInterruptInput15Mask,socinterruptinput15mask" "0,1"
            newline
            bitfld.long 0x00 16. "SocInterruptInput14Mask,socinterruptinput14mask" "0,1"
            newline
            bitfld.long 0x00 15. "SocInterruptInput13Mask,socinterruptinput13mask" "0,1"
            newline
            bitfld.long 0x00 14. "SocInterruptInput12Mask,socinterruptinput12mask" "0,1"
            newline
            bitfld.long 0x00 13. "SocInterruptInput11Mask,socinterruptinput11mask" "0,1"
            newline
            bitfld.long 0x00 12. "SocInterruptInput10Mask,socinterruptinput10mask" "0,1"
            newline
            bitfld.long 0x00 11. "SocInterruptInput9Mask,socinterruptinput9mask" "0,1"
            newline
            bitfld.long 0x00 10. "SocInterruptInput8Mask,socinterruptinput8mask" "0,1"
            newline
            bitfld.long 0x00 9. "ESW_ESW_2_HLOS_LENGTH_RTZ_Mask,esw_esw_2_hlos_length_rtz_mask" "0,1"
            newline
            bitfld.long 0x00 8. "ESW_HLOS_2_ESW_LENGTH_CFZ_Mask,esw_hlos_2_esw_length_cfz_mask" "0,1"
            newline
            bitfld.long 0x00 7. "SocInterruptInput7Mask,socinterruptinput7mask" "0,1"
            newline
            bitfld.long 0x00 6. "SocInterruptInput6Mask,socinterruptinput6mask" "0,1"
            newline
            bitfld.long 0x00 5. "SocInterruptInput5Mask,socinterruptinput5mask" "0,1"
            newline
            bitfld.long 0x00 4. "SocInterruptInput4Mask,socinterruptinput4mask" "0,1"
            newline
            bitfld.long 0x00 3. "SocInterruptInput3Mask,socinterruptinput3mask" "0,1"
            newline
            bitfld.long 0x00 2. "SocInterruptInput2Mask,socinterruptinput2mask" "0,1"
            newline
            bitfld.long 0x00 1. "SocInterruptInput1Mask,socinterruptinput1mask" "0,1"
            newline
            bitfld.long 0x00 0. "SocInterruptInput0Mask,socinterruptinput0mask" "0,1"

    rgroup.long 0x120++0x03
        line.long 0x00 "SIC_STATUS,sic_status"
            hexmask.long.tbyte 0x00 8.--31. 1. "Reserved,reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SicStatus,sicstatus"

    group.long 0x124++0x03
        line.long 0x00 "BOOT_BYPASS_STATUS,This register is written before power down is allowed"
            hexmask.long 0x00 1.--31. 1. "swBypassStatus,These bits will be used by SW"
            newline
            bitfld.long 0x00 0. "cmBypass,CM Core boot completion status" "0: Full CM boot context not available and CM boot,1: Full CM boot context is available and CM bypass"
    group.long 0x128++0x03
        line.long 0x00 "BOOT_BYPASS_VECTOR,boot_bypass_vector"
            hexmask.long 0x00 0.--31. 1. "bootBypassVector,32 bit boot bypass vector written before powering down is allowed"
    group.long 0x12C++0x03
        line.long 0x00 "POWER_DOWN_ALLOWED,This register is written by eSW to allow entering low power state"
            hexmask.long 0x00 1.--31. 1. "Reserved,reserved"
            newline
            bitfld.long 0x00 0. "pdAllowed," "0,1"
    group.long 0x134++0x03
        line.long 0x00 "SIC_HWC_ABORT,This register is writable in machine mode to abort an ongoing transaction"
            hexmask.long.word 0x00 16.--31. 1. "Reserved,reserved"
            newline
            bitfld.long 0x00 15. "HC2_abort,hc2_abort" "0,1"
            newline
            bitfld.long 0x00 14. "CCP_abort,ccp_abort" "0,1"
            newline
            bitfld.long 0x00 13. "CSHC_abort,cshc_abort" "0,1"
            newline
            bitfld.long 0x00 12. "WHC_abort,whc_abort" "0,1"
            newline
            bitfld.long 0x00 11. "FMC_abort,fmc_abort" "0,1"
            newline
            bitfld.long 0x00 10. "UFC_abort,ufc_abort" "0,1"
            newline
            bitfld.long 0x00 9. "PKE_abort,pke_abort" "0,1"
            newline
            bitfld.long 0x00 8. "DMAC_abort,dmac_abort" "0,1"
            newline
            bitfld.long 0x00 7. "SAC_abort,sac_abort" "0,1"
            newline
            bitfld.long 0x00 6. "CC_abort,cc_abort" "0,1"
            newline
            bitfld.long 0x00 5. "OMC_abort,omc_abort" "0,1"
            newline
            bitfld.long 0x00 4. "KTC_abort,ktc_abort" "0,1"
            newline
            bitfld.long 0x00 3. "TMC_abort,tmc_abort" "0,1"
            newline
            bitfld.long 0x00 2. "KDC_abort,kdc_abort" "0,1"
            newline
            bitfld.long 0x00 1. "AES_abort,aes_abort" "0,1"
            newline
            bitfld.long 0x00 0. "HC_abort,hc_abort" "0,1"
    group.long 0x138++0x03
        line.long 0x00 "SIC_HWC_ABORT_DONE,Each bit in this register is updated by HW when it completed the abort request"
            hexmask.long.word 0x00 16.--31. 1. "Reserved,reserved"
            newline
            bitfld.long 0x00 15. "HC2_abort_done,hc2_abort_done" "0,1"
            newline
            bitfld.long 0x00 14. "CCP_abort_done,ccp_abort_done" "0,1"
            newline
            bitfld.long 0x00 13. "CSHC_abort_done,cshc_abort_done" "0,1"
            newline
            bitfld.long 0x00 12. "WHC_abort_done,whc_abort_done" "0,1"
            newline
            bitfld.long 0x00 11. "FMC_abort_done,fmc_abort_done" "0,1"
            newline
            bitfld.long 0x00 10. "UFC_abort_done,ufc_abort_done" "0,1"
            newline
            bitfld.long 0x00 9. "PKE_abort_done,pke_abort_done" "0,1"
            newline
            bitfld.long 0x00 8. "DMAC_abort_done,dmac_abort_done" "0,1"
            newline
            bitfld.long 0x00 7. "SAC_abort_done,sac_abort_done" "0,1"
            newline
            bitfld.long 0x00 6. "CC_abort_done,cc_abort_done" "0,1"
            newline
            bitfld.long 0x00 5. "OMC_abort_done,omc_abort_done" "0,1"
            newline
            bitfld.long 0x00 4. "KTC_abort_done,ktc_abort_done" "0,1"
            newline
            bitfld.long 0x00 3. "TMC_abort_done,tmc_abort_done" "0,1"
            newline
            bitfld.long 0x00 2. "KDC_abort_done,kdc_abort_done" "0,1"
            newline
            bitfld.long 0x00 1. "AES_abort_done,aes_abort_done" "0,1"
            newline
            bitfld.long 0x00 0. "HC_abort_done,hc_abort_done" "0,1"
    group.long 0x13C++0x03
        line.long 0x00 "SIC_HWC_CCC,This register is writable in machine mode to clear container context when unloading a container"
            hexmask.long 0x00 1.--31. 1. "Reserved,reserved"
            newline
            bitfld.long 0x00 0. "SIC_HWC_CCC,Clear Container Context when set" "0,1"
    group.long 0x140++0x03
        line.long 0x00 "SIC_HWC_CCC_DONE,Done from each core to CCC signal"
            hexmask.long 0x00 1.--31. 1. "Reserved,reserved"
            newline
            bitfld.long 0x00 0. "SIC_HWC_CCC_DONE,sic_hwc_ccc_done" "0,1"
    group.long 0x144++0x03
        line.long 0x00 "ESW_RESET,This works differently from abort"
            hexmask.long 0x00 1.--31. 1. "Reserved,reserved"
            newline
            bitfld.long 0x00 0. "ESW_RESET," "0,1"
    group.long 0x148++0x03
        line.long 0x00 "SAFETY_BIST_CONTROL,This register controls the different BISTs available within RT640"
            hexmask.long 0x00 5.--31. 1. "Reserved1,reserved1"
            newline
            bitfld.long 0x00 4. "KAT_BIST_KDC,kat_bist_kdc" "0,1"
            newline
            rbitfld.long 0x00 3. "Reserved,reserved" "0,1"
            newline
            bitfld.long 0x00 2. "KAT_BIST_HC,kat_bist_hc" "0,1"
            newline
            bitfld.long 0x00 1. "KAT_BIST_AES,kat_bist_aes" "0,1"
            newline
            bitfld.long 0x00 0. "CHECKER_BIST_ENABLE,checker_bist_enable" "0,1"

    rgroup.long 0x200++0x03
        line.long 0x00 "PERSO_PUBLIC_KEY_HASH_DW0,Public key hash of perso container"
            hexmask.long 0x00 0.--31. 1. "PERSO_PUBLIC_KEY_HASH_DW0,perso_public_key_hash_dw0"
    rgroup.long 0x204++0x03
        line.long 0x00 "PERSO_PUBLIC_KEY_HASH_DW1,Public key hash of perso container"
            hexmask.long 0x00 0.--31. 1. "PERSO_PUBLIC_KEY_HASH_DW1,perso_public_key_hash_dw1"
    rgroup.long 0x208++0x03
        line.long 0x00 "PERSO_PUBLIC_KEY_HASH_DW2,Public key hash of perso container"
            hexmask.long 0x00 0.--31. 1. "PERSO_PUBLIC_KEY_HASH_DW2,perso_public_key_hash_dw2"
    rgroup.long 0x20C++0x03
        line.long 0x00 "PERSO_PUBLIC_KEY_HASH_DW3,Public key hash of perso container"
            hexmask.long 0x00 0.--31. 1. "PERSO_PUBLIC_KEY_HASH_DW3,perso_public_key_hash_dw3"
    rgroup.long 0x210++0x03
        line.long 0x00 "PERSO_PUBLIC_KEY_HASH_DW4,Public key hash of perso container"
            hexmask.long 0x00 0.--31. 1. "PERSO_PUBLIC_KEY_HASH_DW4,perso_public_key_hash_dw4"
    rgroup.long 0x214++0x03
        line.long 0x00 "PERSO_PUBLIC_KEY_HASH_DW5,Public key hash of perso container"
            hexmask.long 0x00 0.--31. 1. "PERSO_PUBLIC_KEY_HASH_DW5,perso_public_key_hash_dw5"
    rgroup.long 0x218++0x03
        line.long 0x00 "PERSO_PUBLIC_KEY_HASH_DW6,Public key hash of perso container"
            hexmask.long 0x00 0.--31. 1. "PERSO_PUBLIC_KEY_HASH_DW6,perso_public_key_hash_dw6"
    rgroup.long 0x21C++0x03
        line.long 0x00 "PERSO_PUBLIC_KEY_HASH_DW7,Public key hash of perso container"
            hexmask.long 0x00 0.--31. 1. "PERSO_PUBLIC_KEY_HASH_DW7,perso_public_key_hash_dw7"
    rgroup.long 0x220++0x03
        line.long 0x00 "OTP_ESW_START_REGION,otp_esw_start_region"
            hexmask.long 0x00 0.--31. 1. "OTP_ESW_START_REGION,otp_esw_start_region"

    group.long 0x224++0x03
        line.long 0x00 "FIPS_MODE,fips_mode"
            hexmask.long.tbyte 0x00 9.--31. 1. "FipsMode_Reserved1,fipsmode_reserved1"
            newline
            bitfld.long 0x00 8. "HEALTH_CHECK_COMPLETE,health_check_complete" "0,1"
            newline
            hexmask.long.byte 0x00 1.--7. 1. "FipsMode_Reserved0,fipsmode_reserved0"
            newline
            rbitfld.long 0x00 0. "FIPS_MODE_ON,fips_mode_on" "0,1"

    rgroup.long 0x228++0x03
        line.long 0x00 "DEFAULT_TMC_TRNG_CONTROL,This register is available when TMC with EIP76a TRNG is used"
            hexmask.long 0x00 0.--31. 1. "DEFAULT_TMC_TRNG_CONTROL,default_tmc_trng_control"
    rgroup.long 0x22C++0x03
        line.long 0x00 "DEFAULT_TMC_TRNG_CONFIG,This register is available when TMC with EIP76a TRNG is used"
            hexmask.long 0x00 0.--31. 1. "DEFAULT_TMC_TRNG_CONFIG,default_tmc_trng_config"
    rgroup.long 0x400++0x03
        line.long 0x00 "BOOT_STATUS,Information about the SOC (that integrates Bristol)"
            hexmask.long.tbyte 0x00 12.--31. 1. "BootStatus_Reserved2,Reserved"
            newline
            bitfld.long 0x00 8.--11. "OTP_BOOT_STATUS,otp_boot_status" "0: UNKN_DESC,1: FAIL_PRIMARY_BOOT,2: FAIL_BACKUP_BOOT,?..."
            newline
            bitfld.long 0x00 6.--7. "BootStatus_Reserved1,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 4.--5. "CPU_SRAM_BIST_STATUS,cpu_sram_bist_status" "0: UNKN_DESC,1: IN_PROGRESS,2: SUCCESSFUL,3: UNKN_DESC"
            newline
            bitfld.long 0x00 0.--3. "BootStatus_Reserved0,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x404++0x03
        line.long 0x00 "SW_BOOT_STATUS,Boot Status written by SW"
            hexmask.long 0x00 0.--31. 1. "SW_BOOT_STATUS,sw_boot_status"

    rgroup.long 0x408++0x03
        line.long 0x00 "CYCLE_COUNTER_DW0,A 64 bit counter whose definition includes the following: * Count the number of clock cycles after the de-assertion of crdResetn"
            hexmask.long 0x00 0.--31. 1. "CYCLE_COUNTER_DW0,cycle_counter_dw0"
    rgroup.long 0x40C++0x03
        line.long 0x00 "CYCLE_COUNTER_DW1,A 64 bit counter whose definition includes the following: * Count the number of clock cycles after the de-assertion of crdResetn"
            hexmask.long 0x00 0.--31. 1. "CYCLE_COUNTER_DW1,cycle_counter_dw1"

    group.long 0x410++0x03
        line.long 0x00 "TRNG_INFO,The content of the TRNG_INFO is variable and should be ignored for normal functional use cases"
            hexmask.long 0x00 0.--31. 1. "TRNG_INFO,trng_info"

    rgroup.long 0x420++0x03
        line.long 0x00 "SOC_VERSION,Information about the SOC (that integrates Bristol)"
            hexmask.long.word 0x00 16.--31. 1. "CRD_VERSION,Assigned by CRI"
            newline
            hexmask.long.word 0x00 0.--15. 1. "MANUF_VERSION,Assigned by SOC manufacturer"
    rgroup.long 0x424++0x03
        line.long 0x00 "BUILDER_VERSION,This register tracks the version number of the device and includes both hardware and kernel version information"
            hexmask.long 0x00 0.--31. 1. "BUILDER_HARDWARE_VERSION,This field tracks the implementation version of the hardware"

    group.long 0x428++0x03
        line.long 0x00 "KERNEL_VERSION,kernel_version"
            hexmask.long 0x00 0.--31. 1. "KERNEL_VERSION,kernel_version"
    group.long 0x42C++0x03
        line.long 0x00 "SDK_VERSION,sdk_version"
            hexmask.long 0x00 0.--31. 1. "SDK_VERSION,sdk_version"

    repeat 4. (increment 0 1) (increment 0 0x04)
        rgroup.long ($2+0x430)++0x03
            line.long 0x00 "HW_VERSION[$1],128b of info $1"
                hexmask.long 0x00 0.--31. 1. "HW_VERSION,hw_version"
    repeat.end

    group.long 0x500++0x03
        line.long 0x00 "SOC_INTERRUPT_OUT,This is an interrupt register"
            hexmask.long.word 0x00 16.--31. 1. "SOC_INTERRUPT_OUT_Reserved,soc_interrupt_out_reserved"
            newline
            hexmask.long.word 0x00 1.--15. 1. "SOC_INTERRUPT_OUT,soc_interrupt_out"
            newline
            bitfld.long 0x00 0. "SOC_INTERRUPT_OUT_MESSAGE,soc_interrupt_out_message" "0,1"

    rgroup.long 0x504++0x03
        line.long 0x00 "SOC_INTERRUPT_OUT_MASK,The mask register associated with SOC_INTERRUPT_OUT"
            hexmask.long.word 0x00 16.--31. 1. "SOC_INTERRUPT_OUT_MASK_Reserved,soc_interrupt_out_mask_reserved"
            newline
            hexmask.long.word 0x00 0.--15. 1. "SOC_INTERRUPT_OUT_MASK,soc_interrupt_out_mask"
    rgroup.long 0x508++0x03
        line.long 0x00 "INTERNAL_HW_ERROR_INFO,Individual 1 bit fields in this register represent errors or error states within HW cores"
            hexmask.long 0x00 3.--31. 1. "INT_HW_ERROR_Reserved2,int_hw_error_reserved2"
            newline
            bitfld.long 0x00 2. "swHalt,SW halt" "0,1"
            newline
            bitfld.long 0x00 1. "hwPanic,HW panic" "0,1"
            newline
            bitfld.long 0x00 0. "INT_HW_ERROR_Reserved0,Reserved for parity error" "0,1"

    group.long 0x50C++0x03
        line.long 0x00 "INTERNAL_SW_ERROR_INFO,internal_sw_error_info"
            hexmask.long 0x00 0.--31. 1. "INTERNAL_SW_ERROR_INFO,Software Error Info"

    rgroup.long 0x510++0x03
        line.long 0x00 "OTP_HW_ERROR_INFO,otp_hw_error_info"
            hexmask.long 0x00 2.--31. 1. "OTP_HW_ERROR_INFO_Reserved,otp_hw_error_info_reserved"
            newline
            bitfld.long 0x00 1. "deviceLifeCycle_ERROR,The OMC has encountered an uncorrectable or protocol error in the deviceILifeCycleD field" "0,1"
            newline
            bitfld.long 0x00 0. "OMC_STATUS,This bit is not error information" "0,1"

    group.long 0x520++0x03
        line.long 0x00 "SAFETY_DIAGNOSIS_0,This register gives information to the system on the type of safety alarms triggered during operation"
            bitfld.long 0x00 31. "ESW_KAT_FAILURE,eSW KAT failure" "0,1"
            newline
            rbitfld.long 0x00 30. "SAFETY_DIAGNOSIS_0_Reserved2,Reserved" "0,1"
            newline
            rbitfld.long 0x00 29. "KDC_FSM_INTEGRITY,KDC state machine encoding alarm" "0,1"
            newline
            rbitfld.long 0x00 28. "KDC_REGISTER_INTEGRITY,KDC internal register integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 27. "KDC_BUS_INTEGRITY,KDC bus integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 26. "TMC_FSM_INTEGRITY,TMC state machine encoding alarm" "0,1"
            newline
            rbitfld.long 0x00 25. "TMC_REGISTER_INTEGRITY,TMC internal register integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 24. "TMC_BUS_INTEGRITY,TMC bus integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 23. "PKE_FSM_INTEGRITY,PKE state machine encoding alarm" "0,1"
            newline
            rbitfld.long 0x00 22. "PKE_REGISTER_REDUNDANCY_INTEGRITY,PKE internal register and redundant logic integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 21. "PKE_BUS_INTEGRITY,PKE bus integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 20. "KTC_FSM_INTEGRITY,KTC state machine encoding alarm" "0,1"
            newline
            rbitfld.long 0x00 19. "KTC_REGISTER_INTEGRITY,KTC internal register integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 18. "KTC_BUS_INTEGRITY,KTC bus integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 17. "FMC_FSM_INTEGRITY,FMC state machine encoding alarm" "0,1"
            newline
            rbitfld.long 0x00 16. "FMC_REGISTER_INTEGRITY,FMC internal register integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 15. "FMC_BUS_INTEGRITY,FMC bus integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 14. "DMAC_FSM_INTEGRITY,DMAC state machine encoding alarm" "0,1"
            newline
            rbitfld.long 0x00 13. "DMAC_REGISTER_INTEGRITY,DMAC internal register integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 12. "DMAC_BUS_INTEGRITY,DMAC bus integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 11. "HC_FSM_INTEGRITY,HC state machine encoding alarm" "0,1"
            newline
            rbitfld.long 0x00 10. "HC_REGISTER_INTEGRITY,HC internal register integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 9. "HC_BUS_INTEGRITY,HC bus integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 8. "AES_FSM_INTEGRITY,AES state machine encoding alarm" "0,1"
            newline
            rbitfld.long 0x00 7. "AES_REGISTER_INTEGRITY,AES internal register integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 6. "AES_BUS_INTEGRITY,AES bus integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 5. "SAFETY_DIAGNOSIS_0_Reserved1,Reserved" "0,1"
            newline
            rbitfld.long 0x00 4. "SIC_REGISTER_INTEGRITY,SIC internal register integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 3. "SIC_BUS_INTEGRITY,SIC bus integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 2. "SAFETY_DIAGNOSIS_0_Reserved0,Reserved" "0,1"
            newline
            rbitfld.long 0x00 1. "EAC_REGISTER_INTEGRITY,EAC internal register integrity check alarm" "0,1"
            newline
            rbitfld.long 0x00 0. "EAC_BUS_INTEGRITY,EAC bus integrity check alarm" "0,1"

    rgroup.long 0x524++0x03
        line.long 0x00 "SAFETY_DIAGNOSIS_1,This register gives information to the system on the type of safety alarms triggered during operation"
            bitfld.long 0x00 31. "EXTERNAL_SAFETY_ALARM,External safety mechanism alarm" "0,1"
            newline
            bitfld.long 0x00 30. "CLK_RST_INTEGRITY,CLK/RST redundant logic alarm" "0,1"
            newline
            bitfld.long 0x00 29. "CC_FSM_INTEGRITY,CC state machine encoding alarm" "0,1"
            newline
            bitfld.long 0x00 28. "CC_REGISTER_INTEGRITY,CC internal register integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 27. "CC_BUS_INTEGRITY,CC bus integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 26. "OMC_FSM_INTEGRITY,OMC state machine encoding alarm" "0,1"
            newline
            bitfld.long 0x00 25. "OMC_REGISTER_INTEGRITY,OMC internal register integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 24. "OMC_BUS_INTEGRITY,OMC bus integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 23. "TIM_WATCHDOG_COMP_INTEGRITY,TIM safety watchdog comparator alarm" "0,1"
            newline
            bitfld.long 0x00 22. "TIM_REGISTER_INTEGRITY,TIM internal register integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 21. "TIM_BUS_INTEGRITY,TIM bus integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 20. "SAFETY_DIAGNOSIS_1_Reserved5,Reserved" "0,1"
            newline
            bitfld.long 0x00 19. "CPU_REGISTER_REDUNDANCY_INTEGRITY,CPU internal register and redundant logic integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 18. "CPU_BUS_INTEGRITY,CPU bus integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 17. "SAFETY_DIAGNOSIS_1_Reserved4,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "PLIC_REGISTER_INTEGRITY,PLIC internal register integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 15. "PLIC_BUS_INTEGRITY,PLIC bus integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 14. "SRAM_MEMORY_INTEGRITY,SRAM memory check alarm" "0,1"
            newline
            bitfld.long 0x00 13. "SRAM_FSM_INTEGRITY,SRAM state machine encoding alarm" "0,1"
            newline
            bitfld.long 0x00 12. "SRAM_BUS_INTEGRITY,SRAM bus integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 11. "SAFETY_DIAGNOSIS_1_Reserved3,Reserved" "0,1"
            newline
            bitfld.long 0x00 10. "SAC_REGISTER_INTEGRITY,SAC internal register integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 9. "SAC_BUS_INTEGRITY,SAC bus integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 7.--8. "SAFETY_DIAGNOSIS_1_Reserved2,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 6. "BCU_FSM_INTEGRITY,BCU state machine encoding alarm" "0,1"
            newline
            bitfld.long 0x00 5. "SAFETY_DIAGNOSIS_1_Reserved1,Reserved" "0,1"
            newline
            bitfld.long 0x00 4. "MPU_REGISTER_REDUNDANCY_INTEGRITY,MPU internal register and redundant logic integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 3. "MPU_BUS_INTEGRITY,MPU bus integrity check alarm" "0,1"
            newline
            bitfld.long 0x00 2. "SAFETY_DIAGNOSIS_1_Reserved0,Reserved" "0,1"
            newline
            bitfld.long 0x00 1. "PMU_FSM_INTEGRITY,PMU state machine encoding alarm" "0,1"
            newline
            bitfld.long 0x00 0. "PMU_REDUNDANCY_INTEGRITY,PMU redundant logic integrity check alarm" "0,1"

    group.long 0x530++0x03
        line.long 0x00 "SW_SCRATCH_0,This is a SW-defined scratch register"
            hexmask.long 0x00 0.--31. 1. "SW_SCRATCH_0,sw_scratch_0"

    rgroup.long 0x540++0x03
        line.long 0x00 "DEVICE_LIFECYCLE,The deviceLifeCyle field in in the SW controlled unparsed region of OTP"
            hexmask.long 0x00 0.--31. 1. "deviceLifecycle,devicelifecycle"

    group.long 0x544++0x03
        line.long 0x00 "CUSTOM_0,custom_0"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_0,custom_0"
    group.long 0x548++0x03
        line.long 0x00 "CUSTOM_1,custom_1"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_1,custom_1"
    group.long 0x54C++0x03
        line.long 0x00 "CUSTOM_2,custom_2"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_2,custom_2"
    group.long 0x550++0x03
        line.long 0x00 "CUSTOM_3,custom_3"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_3,custom_3"
    group.long 0x554++0x03
        line.long 0x00 "CUSTOM_4,custom_4"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_4,custom_4"
    group.long 0x558++0x03
        line.long 0x00 "CUSTOM_5,custom_5"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_5,custom_5"
    group.long 0x55C++0x03
        line.long 0x00 "CUSTOM_6,custom_6"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_6,custom_6"
    group.long 0x560++0x03
        line.long 0x00 "CUSTOM_7,custom_7"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_7,custom_7"
    group.long 0x564++0x03
        line.long 0x00 "CUSTOM_8,custom_8"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_8,custom_8"
    group.long 0x568++0x03
        line.long 0x00 "CUSTOM_9,custom_9"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_9,custom_9"
    group.long 0x56C++0x03
        line.long 0x00 "CUSTOM_10,custom_10"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_10,custom_10"
    group.long 0x570++0x03
        line.long 0x00 "CUSTOM_11,custom_11"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_11,custom_11"
    group.long 0x574++0x03
        line.long 0x00 "CUSTOM_12,custom_12"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_12,custom_12"
    group.long 0x578++0x03
        line.long 0x00 "CUSTOM_13,custom_13"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_13,custom_13"
    group.long 0x57C++0x03
        line.long 0x00 "CUSTOM_14,custom_14"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_14,custom_14"
    group.long 0x580++0x03
        line.long 0x00 "CUSTOM_15,custom_15"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_15,custom_15"
    group.long 0x584++0x03
        line.long 0x00 "CUSTOM_16,custom_16"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_16,custom_16"
    group.long 0x588++0x03
        line.long 0x00 "CUSTOM_17,custom_17"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_17,custom_17"
    group.long 0x58C++0x03
        line.long 0x00 "CUSTOM_18,custom_18"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_18,custom_18"
    group.long 0x590++0x03
        line.long 0x00 "CUSTOM_19,custom_19"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_19,custom_19"
    group.long 0x594++0x03
        line.long 0x00 "CUSTOM_20,custom_20"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_20,custom_20"
    group.long 0x598++0x03
        line.long 0x00 "CUSTOM_21,custom_21"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_21,custom_21"
    group.long 0x59C++0x03
        line.long 0x00 "CUSTOM_22,custom_22"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_22,custom_22"
    group.long 0x5A0++0x03
        line.long 0x00 "CUSTOM_23,custom_23"
            hexmask.long 0x00 0.--31. 1. "CUSTOM_23,custom_23"

    rgroup.long 0x5B4++0x03
        line.long 0x00 "DEVICE_KEYS_PERSO_STATUS,The OTP status field is in the shadowed region of OTP"
            bitfld.long 0x00 30.--31. "keysPersoRegisterValid," "?,1: shadowing of this register is completed,2: Reserved,3: shadowing of this register cannot be completed"
            newline
            hexmask.long.tbyte 0x00 9.--29. 1. "Reserved,reserved"
            newline
            abitfld.long 0x00 0.--8. "keysPersoOTPValue," "0x001=1: DGOK valid,0x002=2: Key split 1 valid,0x003=3: key split 2 valid,0x004=4: key split 3 valid,0x005=5: key split 4 valid,0x006=6: key split 5 valid,0x007=7: key split 6 valid,0x008=8: key split 7 valid"
    rgroup.long 0x5B8++0x03
        line.long 0x00 "DEVICE_ROOT_TABLE_STATUS,OMC parses root table and updates this register with root status"
            bitfld.long 0x00 30.--31. "rootTableStatus_Valid," "?,1: shadowing of this register is completed,2: Reserved 11 -OTP has been updated since this,?..."
            newline
            hexmask.long.word 0x00 16.--29. 1. "Reserved,reserved"
            newline
            abitfld.long 0x00 0.--15. "rootTableStatus,Each root will have two bit status" "0x0000=0: invalid - When status is..,0x0001=1: empty,0x0002=2: valid,0x0003=3: obliterated CMRT can have up to 8 root.."

    group.long 0x5E0++0x03
        line.long 0x00 "SBOOT_HASH,sboot_hash"
            hexmask.long 0x00 0.--31. 1. "sbootHash,sboothash"
    group.long 0x600++0x03
        line.long 0x00 "ESW_2_HLOS_D0,esw_2_hlos_d0"
            hexmask.long 0x00 0.--31. 1. "ESW_2_HLOS_D0,esw_2_hlos_d0"
    group.long 0x604++0x03
        line.long 0x00 "ESW_2_HLOS_D1,esw_2_hlos_d1"
            hexmask.long 0x00 0.--31. 1. "ESW_2_HLOS_D1,esw_2_hlos_d1"
    group.long 0x608++0x03
        line.long 0x00 "ESW_2_HLOS_D2,esw_2_hlos_d2"
            hexmask.long 0x00 0.--31. 1. "ESW_2_HLOS_D2,esw_2_hlos_d2"
    group.long 0x60C++0x03
        line.long 0x00 "ESW_2_HLOS_D3,esw_2_hlos_d3"
            hexmask.long 0x00 0.--31. 1. "ESW_2_HLOS_D3,esw_2_hlos_d3"
    group.long 0x610++0x03
        line.long 0x00 "ESW_2_HLOS_D4,esw_2_hlos_d4"
            hexmask.long 0x00 0.--31. 1. "ESW_2_HLOS_D4,esw_2_hlos_d4"
    group.long 0x614++0x03
        line.long 0x00 "ESW_2_HLOS_D5,esw_2_hlos_d5"
            hexmask.long 0x00 0.--31. 1. "ESW_2_HLOS_D5,esw_2_hlos_d5"
    group.long 0x618++0x03
        line.long 0x00 "ESW_2_HLOS_D6,esw_2_hlos_d6"
            hexmask.long 0x00 0.--31. 1. "ESW_2_HLOS_D6,esw_2_hlos_d6"
    group.long 0x61C++0x03
        line.long 0x00 "ESW_2_HLOS_D7,esw_2_hlos_d7"
            hexmask.long 0x00 0.--31. 1. "ESW_2_HLOS_D7,esw_2_hlos_d7"
    group.long 0x620++0x03
        line.long 0x00 "ESW_2_HLOS_LENGTH,esw_2_hlos_length"
            hexmask.long 0x00 0.--31. 1. "ESW_2_HLOS_LENGTH,esw_2_hlos_length"

    rgroup.long 0x630++0x03
        line.long 0x00 "HLOS_2_ESW_D0,hlos_2_esw_d0"
            hexmask.long 0x00 0.--31. 1. "HLOS_2_ESW_D0,hlos_2_esw_d0"
    rgroup.long 0x634++0x03
        line.long 0x00 "HLOS_2_ESW_D1,hlos_2_esw_d1"
            hexmask.long 0x00 0.--31. 1. "HLOS_2_ESW_D1,hlos_2_esw_d1"
    rgroup.long 0x638++0x03
        line.long 0x00 "HLOS_2_ESW_D2,hlos_2_esw_d2"
            hexmask.long 0x00 0.--31. 1. "HLOS_2_ESW_D2,hlos_2_esw_d2"
    rgroup.long 0x63C++0x03
        line.long 0x00 "HLOS_2_ESW_D3,hlos_2_esw_d3"
            hexmask.long 0x00 0.--31. 1. "HLOS_2_ESW_D3,hlos_2_esw_d3"
    rgroup.long 0x640++0x03
        line.long 0x00 "HLOS_2_ESW_D4,hlos_2_esw_d4"
            hexmask.long 0x00 0.--31. 1. "HLOS_2_ESW_D4,hlos_2_esw_d4"
    rgroup.long 0x644++0x03
        line.long 0x00 "HLOS_2_ESW_D5,hlos_2_esw_d5"
            hexmask.long 0x00 0.--31. 1. "HLOS_2_ESW_D5,hlos_2_esw_d5"
    rgroup.long 0x648++0x03
        line.long 0x00 "HLOS_2_ESW_D6,hlos_2_esw_d6"
            hexmask.long 0x00 0.--31. 1. "HLOS_2_ESW_D6,hlos_2_esw_d6"
    rgroup.long 0x64C++0x03
        line.long 0x00 "HLOS_2_ESW_D7,hlos_2_esw_d7"
            hexmask.long 0x00 0.--31. 1. "HLOS_2_ESW_D7,hlos_2_esw_d7"

    group.long 0x650++0x03
        line.long 0x00 "HLOS_2_ESW_LENGTH,hlos_2_esw_length"
            hexmask.long 0x00 0.--31. 1. "HLOS_2_ESW_LENGTH,hlos_2_esw_length"
tree.end

tree "SERDES ()"
    base ad:0x84411000
    group.long 0x00++0x03
        line.long 0x00 "dtest0_0,dtest0_0"
            hexmask.long.byte 0x00 5.--12. 1. "DTEST_SEL0,Digital Test Output 0 Digital Test Selection Mappings Described in App"
            newline
            bitfld.long 0x00 0.--4. "DTEST_DIV0,Digital Test Output Divide Value For DTEST_OUT0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    group.long 0x04++0x03
        line.long 0x00 "dtest1_0,dtest1_0"
            hexmask.long.byte 0x00 5.--12. 1. "DTEST_SEL1,Digital Test Output 1 Digital Test Selection Mappings Described in App"
            newline
            bitfld.long 0x00 0.--4. "DTEST_DIV1,Digital Test Output Divide Value For DTEST_OUT1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    group.long 0x08++0x03
        line.long 0x00 "jtagA_0,jtaga_0"
            bitfld.long 0x00 2. "JTAG_SETDCREFA,For lane A JTAG DC level adjust Set JTAGENA=1'b1 & JTAG_SETDCA=1'b1 to operate in this mode 1'b0 --> 0.5*VDDARXA 1'b1 --> 0.75*VDDARXA" "0,1"
            newline
            bitfld.long 0x00 1. "JTAG_SETDCA,For lane A Set JTAG sensor to DC mode" "0,1"
            newline
            bitfld.long 0x00 0. "JTAGENA,For lane A Enable for JTAG sensor Active High" "0,1"
    group.long 0x0C++0x03
        line.long 0x00 "laneA_datapath_0,lanea_datapath_0"
            bitfld.long 0x00 20.--22. "TX_DATA_SELECTA,For SERDES Channel A Select data to serializer 3'b000 --> TXDATA_FROM_COREA 3'b001 --> PRBS Pattern Generators 3'b010 --> Decimated PRBS Pattern 3'b011 --> 101010" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 19. "TXPOSTDIVENA,For lane A Serializer post-divider enable 1'b0 --> disabled (divide-by-1 mode) 1'b1 --> enabled TXPOSTDIVA sets divide value" "0,1"
            newline
            bitfld.long 0x00 17.--18. "TXPOSTDIVA,For lane A Serializer Per-Channel Division 00 -> Divide-by-2 01 -> Divide-by-4 10 -> Divide-by-8 11 -> Divide-by-11 For PLL programming see TXPLL_FBDIV notes" "0,1,2,3"
            newline
            bitfld.long 0x00 16. "TXFIFO_RESETA,For lane A Reset TX Data FIFO 1'b0 --> FIFO is in reset 1'b1 --> FIFO is operating FIFO should be held in reset until TXPLL_LOCK=1'b1 and clocks are stable" "0,1"
            newline
            bitfld.long 0x00 15. "TXFIFO_ENABLEA,For lane A Enable TX Data FIFO 1'b0 --> FIFO disabled 1'b1 --> FIFO enabled" "0,1"
            newline
            bitfld.long 0x00 14. "TXDATA_FLIPENDA,Enable bit swap of parallel data interface to transmitter for lane A 1'b0 --> LSB first 1'b1 --> MSB first" "0,1"
            newline
            bitfld.long 0x00 11.--13. "SERMODEA,For lane A Serializer Mode Control 3'b0x0 --> 8-Bit Serialization 3'b0x1 --> 10-Bit Serialization 3'b100 --> 16-Bit Serialization 3'b101 --> 20-Bit Serialization 3'b110 --> 32-Bit Serialization 3'b111 --> 40-Bit Serialization" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 8.--10. "RXPLL_REFCLK_SELA,For lane A RXPLL Reference Clock Select 3'b000 --> RXPLL_REFCLKA CMOS clock from Core 3'b000 --> TXPLL_REFCLK_TO_CORE_IN Tx PLL Selected Clock from Hard Macro 3'b001 --> TXPLL_REFCLK) CMOS clock from core 3'b010 --> Reserved 3'b011 -->.." "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6.--7. "RXDATA_SELECTA,For SERDES Channel A select data and clock to core from deserializer" "0: CDR/CTLE data,1: DFE data 2'b1x,?..."
            newline
            bitfld.long 0x00 5. "RXDATA_FLIPENDA,Enable bit swap of parallel data interface to core for lane A 1'b0 --> LSB first 1'b1 --> MSB first" "0,1"
            newline
            bitfld.long 0x00 4. "RESET_FIFOA,For SERDES Channel A Reset FIFO" "0,1"
            newline
            bitfld.long 0x00 3. "INSERT_PRBS_ERRORA,For SERDES Channel A Insert error into Transmitter PRBS data input An error is inserted on every transition of INSERT_PRBS_ERRORA" "0,1"
            newline
            bitfld.long 0x00 0.--2. "DESMODEA,For lane A De-Serializer Mode Control 3'b0x0 --> 8-Bit De-Serialization 3'b0x1 --> 10-Bit De-Serialization 3'b100 --> 16-Bit De-Serialization 3'b101 --> 20-Bit De-Serialization 3'b110 --> 32-Bit De-Serialization 3'b111 --> 40-Bit.." "0,1,2,3,4,5,6,7"
    group.long 0x10++0x03
        line.long 0x00 "laneA_driver1_0,lanea_driver1_0"
            bitfld.long 0x00 30.--31. "TXODRVA,For lane A Transmitter Overdrive Control 2'b00 --> Normal Setting 2'b01 --> +25% Drive 2'b10 --> +50% Drive 2'b11 --> +75% Drive" "0,1,2,3"
            newline
            bitfld.long 0x00 27.--29. "TXDRVA,Enable for driver segments 2 to 8 (of 8) transmitter lane A Segment 1 is active while TXPDA=1'b0 TXDRVA=3'b000 --> Active Segments: 1 TXDRVA=3'b001 --> Active Segments: 1 2 TXDRVA=3'b010 --> Active Segments: 1 2 3 TXDRVA=3'b011 --> Active.." "0,1,2,3,4,5,6,7"
            newline
            hexmask.long.word 0x00 11.--26. 1. "TXDELA,For lane A Delay data for each output driver segment (of 8) Used for pre-emphasis / de-emphasis [1:0] -> Delay control for segment 1 of 8 [3:2] -> Delay control for segment 2 of 8 [5:4] -> Delay control for segment 3 of 8 [7:6] -> Delay control.."
            newline
            hexmask.long.byte 0x00 3.--10. 1. "TXDATA_INVA,For lane A Invert data for each output driver segment (of 8) Used for pre-emphasis / de-emphasis"
            newline
            bitfld.long 0x00 1.--2. "TXCM_LEVELA,For lane A Transmitter DC Level 2'b00 --> 0.475 * VDDATXA 2'b01 --> 0.55 * VDDATXA 2'b10 --> 0.60 * VDDATXA 2'b11 --> 0.65 * VDDATXA" "0,1,2,3"
            newline
            bitfld.long 0x00 0. "BYPASSSERA,For lane A Bypass enable for output driver" "0,1"
    group.long 0x14++0x03
        line.long 0x00 "laneA_driver2_0,lanea_driver2_0"
            hexmask.long.tbyte 0x00 0.--23. 1. "TXDRVTRIMA,For lane A [2:0] -> Drive trim for segment 1 of 8 [5:3] -> Drive trim for segment 2 of 8 [8:6] -> Drive trim for segment 3 of 8 [11:9] -> Drive trim for segment 4 of 8 [14:12] -> Drive trim for segment 5 of 8 [17:15] -> Drive trim for segment.."
    group.long 0x18++0x03
        line.long 0x00 "laneA_lfps1_0,lanea_lfps1_0"
            hexmask.long.word 0x00 6.--15. 1. "LFPS_TBURSTA,For Transmitter channel A Duration for burst portion of LFPS transmission Duration is in TXPLL reference clock periods Should have a value of at least 1 during LFPS mode"
            newline
            bitfld.long 0x00 5. "LFPS_STARTA,For Transmitter channel A Start indicator for LFPS Driver Control LFPS Signaling consists of transmitting the TXPLL Reference clock in the following manner: High drive for LFPS_TBURSTA clock periods Electrical Idle for.." "0,1"
            newline
            bitfld.long 0x00 2.--4. "LFPS_NUMCYCLESA,For Transmitter channel A Number of repetitions of the LFPS Pattern Should have a value of at least 1 during LFPS mode" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 1. "LFPS_MODEA,For Transmitter channel A Enable LFPS Control for Transmitter (low frequency burst mode signaling) Transmitter Lane A must be enabled (TXPDA=1'b0) for LFPS to function" "0,1"
            newline
            bitfld.long 0x00 0. "LFPS_CONTINUOUSA,For Transmitter channel A Place LFPS Control logic in 'continuous' mode LFPS will be continually transmitted until LFPS_CONTINUOUSA=1'b0 or LFPS_STARTA=1'b0 LFPS Signaling consists of transmitting the TXPLL Reference clock in the.." "0,1"
    group.long 0x1C++0x03
        line.long 0x00 "laneA_lfps2_0,lanea_lfps2_0"
            hexmask.long 0x00 0.--31. 1. "LFPS_TREPEATA,For Transmitter channel A Duration for electrical idle portion of LFPS transmission Duration is in TXPLL reference clock periods Should have a value of at least 1 during LFPS mode"
    group.long 0x20++0x03
        line.long 0x00 "laneA_powerdown_0,lanea_powerdown_0"
            bitfld.long 0x00 12. "TXPDA,For lane A Power down / reset for serializer channels TXPDA should be asserted for programming" "0,1"
            newline
            bitfld.long 0x00 11. "RXPKDETENA,For lane A Enable the receiver peak detector" "0,1"
            newline
            bitfld.long 0x00 10. "RXCH_PDA,For lane A Powerdown Control for Receiver Channel Logic (CDR DFE Eye Monitor) PD should be asserted for programming" "0,1"
            newline
            bitfld.long 0x00 9. "RXBIAS_PDA,Deserializer Lane A Active High Powerdown control for receiver bias Set RXBIAS_PDA=1'b0 before using Peak Detector (LOS detector) and JTAG" "0,1"
            newline
            bitfld.long 0x00 8. "RESETSERENA,Serializer Lane A Enable for RESETSERA logic Active High" "0,1"
            newline
            bitfld.long 0x00 7. "RESETSERA,Serializer Lane A Rising Edge sensitive reset for serializer datapath and clock Upon sensing a rising edge of RESETSERA the output clock (TXCLK10A etc) will become static for 8UI while resetting RESETSERENA must be set to 1'b1 for RESETSERA to.." "0,1"
            newline
            bitfld.long 0x00 6. "RESETDESA,Deserializer Lane A Active High Reset for Deserializer Datapath De-Serializer Reset" "0,1"
            newline
            bitfld.long 0x00 5. "RCVENA,Deserializer Lane A Active High enable for receiver front end" "0,1"
            newline
            bitfld.long 0x00 4. "PDEMA,Powerdown control for Eye Monitor datapath and clock lane A PDEMA=1'b0 --> DISABLE_CDRGATEA=1'b0 --> EM Datapath Active CDR Datapath Inactive DISABLE_CDRGATEA=1'b1 --> EM Datapath Active CDR Datapath Active PDEMA=1'b1 --> EM Datapath Inactive.." "0,1"
            newline
            bitfld.long 0x00 3. "PDDFEA,Powerdown control for DFE datapath and clock lane A PDDFEA=1'b0 --> DISABLE_CDRGATEA=1'b0 --> DFE Datapath Active CDR Datapath Inactive DISABLE_CDRGATEA=1'b1 --> DFE Datapath Active CDR Datapath Active PDDFEA=1'b1 --> DFE Datapath Inactive Active.." "0,1"
            newline
            bitfld.long 0x00 2. "DISABLE_CDRGATEA,Disable CDR Datapath/Clock Gating when operating in DFE or EM mode lane A 1'b0 --> When PDDFEA=1'b0 or PDEMA=1'b0 CDR Datapath and Clock is disabled 1'b1 --> When PDDFEA=1'b0 or PDEMA=1'b0 CDR Datapath and Clock remains active Active.." "0,1"
            newline
            bitfld.long 0x00 1. "CTLEEN_EMA,For lane A CTLE Enable For the Eye Monitor Path EM is not supported for the IP" "0,1"
            newline
            bitfld.long 0x00 0. "CTLEEN_DFEA,For lane A CTLE Enable For the DFE Path DFE is not supported for the IP" "0,1"
    group.long 0x24++0x03
        line.long 0x00 "laneA_presdet_0,lanea_presdet_0"
            bitfld.long 0x00 25. "RX_DETECT_ENA,Transmitter Lane A Active-High enable for receiver detection sensor (Presence Detection)" "0,1"
            newline
            rbitfld.long 0x00 24. "RXDETOUTA,For lane A Output from clocked receiver detection sensor Enable by setting RX_DETECT_ENA=1'b1 Requires active reference clock" "0,1"
            newline
            bitfld.long 0x00 19.--23. "RXDETECT_WAIT_COUNTA,For lane A Set wait duration after CMSTEP is asserted to ignore RXDETOUT" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 18. "RXDETECT_STARTA,For lane A Receiver detection start signal Begins the receiver detection RTL state machine" "0,1"
            newline
            rbitfld.long 0x00 17. "RXDETECT_DONELA,For lane A Receiver detection RTL done signal latched This signal is the same as RXDETECT_DONEA but will remain static until receiver detection is re-started" "0,1"
            newline
            rbitfld.long 0x00 16. "RXDETECT_DONEA,For lane A Receiver detection RTL done signal" "0,1"
            newline
            hexmask.long.word 0x00 2.--15. 1. "RXDETECT_COUNTA,For lane A Receiver detect RTL duration count in TXPLL reference periods"
            newline
            bitfld.long 0x00 1. "CMSTEP_VALUEA,For lane A Voltage to step to when CMSTEPA is asserted 1'b0 --> VSSS 1'b1 --> VDDATXA" "0,1"
            newline
            bitfld.long 0x00 0. "CMSTEPA,For lane A Step the common mode of TX to the level programmed by CMSTEP_VALUEA Used for RX detection by TX" "0,1"
    group.long 0x28++0x03
        line.long 0x00 "laneA_rfd_0,lanea_rfd_0"
            hexmask.long.word 0x00 16.--29. 1. "RFD_MAX_SAMPLESA,Number of Divide-By-4 Rx PLL Reference samples for a rotation shift accumulation Lane A"
            newline
            bitfld.long 0x00 12.--15. "RFD_MAX_ROTATIONA,Maximum difference between number of Rx PLL Reference and Feedback Clock edges that DO NOT cause RFD_ERRORA assertion Lane A" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 11. "RFD_ERRORA,Active HIGH error output for Rotational Frequency Detector Lane A" "0,1"
            newline
            bitfld.long 0x00 10. "RFD_ENABLEA,Active high control to allow Rotational Frequency Detector to reset the lock detector Lane A" "0,1"
            newline
            bitfld.long 0x00 6.--9. "RFD_CLKREF_SELA,Select the reference clock to the Rotational Frequency Detector Lane A" "0: RFD_CLK_REF = RXPLL_CKLOCKREF,1: RFD_CLK_REF = TXCLK_FROM_SER10,2: RFD_CLK_REF = TXCLK_FROM_SER20,3: RFD_CLK_REF = TXCLK_FROM_SER40,4: RFD_CLK_REF = TXPLL_REFCLK_TO_CORE_IN,5: RFD_CLK_REF = TXPLL_REFCLK,6: RFD_CLK_REF = RXPLL_REFCLK,7: RFD_CLK_REF = 1'b1 4'b1xxx,?..."
            newline
            bitfld.long 0x00 2.--5. "RFD_CLKIN_SELA,Select the input clock to the Rotational Frequency Detector Lane A Options match those for RFD_CLKREF_SELA" "0: RFD_CLK_IN = RXPLL_CKLOCKDIV,1: RFD_CLK_IN = RXCLK10_IN,2: RFD_CLK_IN = RXCLK20_IN,3: RFD_CLK_IN = RXCLK40_IN 4'b01xx,?..."
            newline
            bitfld.long 0x00 1. "RFD_AUTOA,RFD Automatically starts when CDR PLL locks Lane A" "0,1"
            newline
            bitfld.long 0x00 0. "RESET_RFDA,Active high control to reset the Rotational Frequency Detector Lane A" "0,1"
    group.long 0x2C++0x03
        line.long 0x00 "laneA_rfddiv_0,lanea_rfddiv_0"
            bitfld.long 0x00 6.--9. "RFD_CLKREF_DIVA,Divide option for the reference clock of the Rotational Frequency Detector Lane A In combination with RFD_CLKIN_DIVA allows for M/N comparison of RFD_CLK_IN and RFD_CLK_REF" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0.--5. "RFD_CLKIN_DIVA,Divide option for the input clock of the Rotational Frequency Detector Lane A In combination with RFD_CLKREF_DIVA allows for M/N comparison of RFD_CLK_IN and RFD_CLK_REF" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0x30++0x03
        line.long 0x00 "laneA_test1_0,lanea_test1_0"
            bitfld.long 0x00 14.--16. "TXATESTSELA,For lane A -------------------- 000 -> 16uA PTAT current 001 -> 8uA PTAT current 010 -> TX common mode voltage 011 -> 16uA bandgap current 100 -> regulated clock supply 101 -> VSSS 110 -> Logic 1 level 111 -> VDDHV" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 13. "TXATESTENA,Enable Analog Test Mux for Lane A All TX Analog Test Mux outputs can be viewed on ATESTOUT Only allowed to set one of TXPLL_ATESTEN TXATESTENA RXATESTENA=1'b1 Active High" "0,1"
            newline
            bitfld.long 0x00 12. "RXSEOUT_LPBK_SELA,For lane A Select for loopback clock to transmitter 1'b0 --> CLK10 from the CDR 1'b1 --> RXSEOUTA (Single-Ended Input to RXPA/RXNA)" "0,1"
            newline
            rbitfld.long 0x00 11. "RXSEOUTA,For lane A Single-Ended data bypass out Valid only if RXBYPASSENA=1'b1" "0,1"
            newline
            bitfld.long 0x00 7.--10. "RXDTESTSELA,Deserializer Lane A Digital Test Bus Select RXDTESTSELA[3:0] Output -------------------- 0000 -> CLK40EM (not supported) 0001 -> VSSS logic 0 0010 -> DCFBEN_CDRA signal 0011 -> VSSS logic 0 0100 -> VSSS logic 0 0101 -> VSSS logic 0 0110 ->.." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 6. "RXDTESTOUTA,For lane A Digital test bus output for RX channel A" "0,1"
            newline
            bitfld.long 0x00 5. "RXDTESTENA,For lane A Digital test bus enable for RX channel A" "0,1"
            newline
            bitfld.long 0x00 4. "RXBYPASSENA,For lane A Enable RXPA/RXNA to RXSEOUTA path" "0,1"
            newline
            bitfld.long 0x00 1.--3. "RXATESTSELA,Analog Test Mux Select for Lane A Analog test mux is enabled by setting RXATESTENA=1'b1 Only one test mux should be enabled at a time in this manner Output is viewed on ATESTOUT 3'b000 --> RX Common Mode 3'b001 --> 40uA Bandgap Bias Current.." "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0. "RXATESTENA,Enable Analog Test Mux for Lane A All RX Analog Test Mux outputs can be viewed on ATESTOUT Only allowed to set one of TXPLL_ATESTEN TXATESTENA RXATESTENA=1'b1 Active High" "0,1"
    group.long 0x34++0x03
        line.long 0x00 "laneA_test2_0,lanea_test2_0"
            bitfld.long 0x00 29.--31. "TX_BYPASS_SELECT_RTLA,For lane A RTL BYPASS_VALUE Input Select 3'b000 --> TXPLL Reference Clock 3'b001 --> Receiver Detect State Machine Output 3'b010 --> Electrical Idle Output 3'b011 --> BYPASS_VALUEA 3'b100 --> 8'b0000_0000 3'b101 --> 8'b0000_0000.." "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 28. "TX_BYPASS_SELECTA,for lane A 1'b0 --> Select BYPASS_VALUEA 1'b1 --> Select RXSEOUTA from de-serializer" "0,1"
            newline
            bitfld.long 0x00 27. "RXPLL_RST_LCK_CNTA,For CDR in Deserializer Channel A Reset lock time counter 1'b0 --> Lock time counter active 1'b1 --> Lock time counter in reset" "0,1"
            newline
            bitfld.long 0x00 26. "RXPLL_RD_LCK_STBA,For CDR in Deserializer Channel A 'Read' Control for stability monitor 1'b0 --> Monitor for falling edges of RXPLL_LOCKA 1'b1 --> Present result on RXPLL_LCK_STB_CNTA reset internal count" "0,1"
            newline
            rbitfld.long 0x00 22.--25. "RXPLL_LCK_STB_CNTA,For CDR in Deserializer Channel A Count of the number of falling edges of RXPLL_LOCKA while RXPLL_RD_LCK_STBA=1'b0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.word 0x00 6.--21. 1. "RXPLL_LCK_CNTA,For CDR in Deserializer Channel A Count of receiver channel lock time in reference clock periods"
            newline
            bitfld.long 0x00 5. "NLPBK_ENA,For lane A High speed Near-End Loopback Enable Active High" "0,1"
            newline
            bitfld.long 0x00 4. "LPBKFIFO_ENABLEA,For lane A Active High Far-End Parallel Loopback FIFO Enable Set TX_DATA_SELECTA=3'b101 to pass Rx Loopback Data to the Tx Set TXREFCLK_SEL=2'b00 and choose TXCMOSREF_SEL according to the Rx lane to loop back" "0,1"
            newline
            bitfld.long 0x00 1.--3. "HSLPBK_SELA,For lane A High speed internal loopback serializer unit select" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0. "HSLPBKENA,For lane A High speed internal loopback enable" "0,1"
    group.long 0x38++0x03
        line.long 0x00 "laneA_test3_0,lanea_test3_0"
            bitfld.long 0x00 19. "READ_ERRORA,For SERDES Channel A Read PRBS Error Counters" "0,1"
            newline
            bitfld.long 0x00 16.--18. "PRBSMODEA,For SERDES Channel A For serializer width 8 10 16" "0: PRBS7,1: PRBS9,2: PRBS15,3: PRBS23 3'b1xx,?..."
            newline
            hexmask.long.byte 0x00 8.--15. 1. "PRBSERR_SAMPLE_COUNTA,For SERDES Channel A Number of samples accumulated for PRBSERR_COUNTA measurement"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "PRBSERR_COUNTA,For SERDES Channel A PRBS error count Source for PRBS Error is either CDR DFE or Eye Monitor path Based on RXDATA_SELECTA"
    group.long 0x3C++0x03
        line.long 0x00 "laneA_trim_0,lanea_trim_0"
            bitfld.long 0x00 11. "TXTENA,For lane A TX back termination enable" "0,1"
            newline
            bitfld.long 0x00 8.--10. "TXRTRIMA,For lane A TX resistor trim When TXTENA = 1'b0 high-Z When TXTENA =" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6.--7. "TXITRIMA,For lane A Overall current scaling for TX Driver 2'b00 -> -10% 2'b01 -> -5% 2'b10 -> Nominal 2'b11 -> +5% Fine tuning of this value may be done at test and stored in NVM" "0,1,2,3"
            newline
            bitfld.long 0x00 5. "RXTENA,For lane A RX Input Termination Enable 1'b0 --> High Impedance 1'b1 --> See RXRTRIMA Active High" "0,1"
            newline
            bitfld.long 0x00 2.--4. "RXRTRIMA,For lane A RX termination trim 3'b100 is nom -------------------- 3'b000 --> 82 Ohms" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 1. "CDR_GAINA,For lane A Set CDR Gain 1'b0 --> Low Gain lower jitter tolerance lower hunting jitter output 1'b1 --> Default Gain higher jitter tolerance higher hunting jitter output" "0,1"
            newline
            bitfld.long 0x00 0. "ACCOUPLE_RXVCM_ENA,AC Couple control for RX Termination at channel A 1'b0 --> Common mode taken from input data 1'b1 --> AC couple mode internally generated common mode=VDDARXA" "0,1"
    group.long 0x40++0x03
        line.long 0x00 "laneB_datapath_0,laneb_datapath_0"
            bitfld.long 0x00 11.--13. "TX_DATA_SELECTB,For SERDES Channel B Select data to serializer 3'b000 --> TXDATA_FROM_COREB 3'b001 --> PRBS Pattern Generators 3'b010 --> Decimated PRBS Pattern 3'b011 --> 101010" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 10. "TXPOSTDIVENB,For lane B Serializer post-divider enable 1'b0 --> disabled (divide-by-1 mode) 1'b1 --> enabled TXPOSTDIVB sets divide value" "0,1"
            newline
            bitfld.long 0x00 8.--9. "TXPOSTDIVB,For lane B Serializer Per-Channel Division 00 -> Divide-by-2 01 -> Divide-by-4 10 -> Divide-by-8 11 -> Divide-by-11 For PLL programming see TXPLL_FBDIV notes" "0,1,2,3"
            newline
            bitfld.long 0x00 7. "TXFIFO_RESETB,For lane B Reset TX Data FIFO 1'b0 --> FIFO is in reset 1'b1 --> FIFO is operating FIFO should be held in reset until TXPLL_LOCK=1'b1 and clocks are stable" "0,1"
            newline
            bitfld.long 0x00 6. "TXFIFO_ENABLEB,For lane B Enable TX Data FIFO 1'b0 --> FIFO disabled 1'b1 --> FIFO enabled" "0,1"
            newline
            bitfld.long 0x00 5. "TXDATA_FLIPENDB,Enable bit swap of parallel data interface to transmitter for lane B 1'b0 --> LSB first 1'b1 --> MSB first" "0,1"
            newline
            bitfld.long 0x00 2.--4. "SERMODEB,For lane B Serializer Mode Control 3'b0x0 --> 8-Bit Serialization 3'b0x1 --> 10-Bit Serialization 3'b100 --> 16-Bit Serialization 3'b101 --> 20-Bit Serialization 3'b110 --> 32-Bit Serialization 3'b111 --> 40-Bit Serialization" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 1. "RESET_FIFOB,For SERDES Channel B Reset FIFO" "0,1"
            newline
            bitfld.long 0x00 0. "INSERT_PRBS_ERRORB,For SERDES Channel B Insert error into Transmitter PRBS data input An error is inserted on every transition of INSERT_PRBS_ERRORB" "0,1"
    group.long 0x44++0x03
        line.long 0x00 "laneB_driver1_0,laneb_driver1_0"
            bitfld.long 0x00 30.--31. "TXODRVB,For lane B Transmitter Overdrive Control 2'b00 --> Normal Setting 2'b01 --> +25% Drive 2'b10 --> +50% Drive 2'b11 --> +75% Drive" "0,1,2,3"
            newline
            bitfld.long 0x00 27.--29. "TXDRVB,Enable for driver segments 2 to 8 (of 8) transmitter lane B Segment 1 is active while TXPDB=1'b0 TXDRVB=3'b000 --> Active Segments: 1 TXDRVB=3'b001 --> Active Segments: 1 2 TXDRVB=3'b010 --> Active Segments: 1 2 3 TXDRVB=3'b011 --> Active.." "0,1,2,3,4,5,6,7"
            newline
            hexmask.long.word 0x00 11.--26. 1. "TXDELB,For lane B Delay data for each output driver segment (of 8) Used for pre-emphasis / de-emphasis [1:0] -> Delay control for segment 1 of 8 [3:2] -> Delay control for segment 2 of 8 [5:4] -> Delay control for segment 3 of 8 [7:6] -> Delay control.."
            newline
            hexmask.long.byte 0x00 3.--10. 1. "TXDATA_INVB,For lane B Invert data for each output driver segment (of 8) Used for pre-emphasis / de-emphasis"
            newline
            bitfld.long 0x00 1.--2. "TXCM_LEVELB,For lane B Transmitter DC Level 2'b00 --> 0.475 * VDDATXB 2'b01 --> 0.55 * VDDATXB 2'b10 --> 0.60 * VDDATXB 2'b11 --> 0.65 * VDDATXB" "0,1,2,3"
            newline
            bitfld.long 0x00 0. "BYPASSSERB,For lane B Bypass enable for output driver" "0,1"
    group.long 0x48++0x03
        line.long 0x00 "laneB_driver2_0,laneb_driver2_0"
            hexmask.long.tbyte 0x00 0.--23. 1. "TXDRVTRIMB,For lane B [2:0] -> Drive trim for segment 1 of 8 [5:3] -> Drive trim for segment 2 of 8 [8:6] -> Drive trim for segment 3 of 8 [11:9] -> Drive trim for segment 4 of 8 [14:12] -> Drive trim for segment 5 of 8 [17:15] -> Drive trim for segment.."
    group.long 0x4C++0x03
        line.long 0x00 "laneB_lfps1_0,laneb_lfps1_0"
            hexmask.long.word 0x00 6.--15. 1. "LFPS_TBURSTB,For Transmitter channel B Duration for burst portion of LFPS transmission Duration is in TXPLL reference clock periods Should have a value of at least 1 during LFPS mode"
            newline
            bitfld.long 0x00 5. "LFPS_STARTB,For Transmitter channel B Start indicator for LFPS Driver Control LFPS Signaling consists of transmitting the TXPLL Reference clock in the following manner: High drive for LFPS_TBURSTB clock periods Electrical Idle for.." "0,1"
            newline
            bitfld.long 0x00 2.--4. "LFPS_NUMCYCLESB,For Transmitter channel B Number of repetitions of the LFPS Pattern Should have a value of at least 1 during LFPS mode" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 1. "LFPS_MODEB,For Transmitter channel B Enable LFPS Control for Transmitter (low frequency burst mode signaling) Transmitter Lane B must be enabled (TXPDB=1'b0) for LFPS to function" "0,1"
            newline
            bitfld.long 0x00 0. "LFPS_CONTINUOUSB,For Transmitter channel B Place LFPS Control logic in 'continuous' mode LFPS will be continually transmitted until LFPS_CONTINUOUSB=1'b0 or LFPS_STARTB=1'b0 LFPS Signaling consists of transmitting the TXPLL Reference clock in the.." "0,1"
    group.long 0x50++0x03
        line.long 0x00 "laneB_lfps2_0,laneb_lfps2_0"
            hexmask.long 0x00 0.--31. 1. "LFPS_TREPEATB,For Transmitter channel B Duration for electrical idle portion of LFPS transmission Duration is in TXPLL reference clock periods Should have a value of at least 1 during LFPS mode"
    group.long 0x54++0x03
        line.long 0x00 "laneB_powerdown_0,laneb_powerdown_0"
            bitfld.long 0x00 2. "TXPDB,For lane B Power down / reset for serializer channels TXPDB should be asserted for programming" "0,1"
            newline
            bitfld.long 0x00 1. "RESETSERENB,Serializer Lane B Enable for RESETSERB logic Active High" "0,1"
            newline
            bitfld.long 0x00 0. "RESETSERB,Serializer Lane B Rising Edge sensitive reset for serializer datapath and clock Upon sensing a rising edge of RESETSERB the output clock (TXCLK10B etc) will become static for 8UI while resetting RESETSERENB must be set to 1'b1 for RESETSERB to.." "0,1"
    group.long 0x58++0x03
        line.long 0x00 "laneB_presdet_0,laneb_presdet_0"
            bitfld.long 0x00 25. "RX_DETECT_ENB,Transmitter Lane B Active-High enable for receiver detection sensor (Presence Detection)" "0,1"
            newline
            rbitfld.long 0x00 24. "RXDETOUTB,For lane B Output from clocked receiver detection sensor Enable by setting RX_DETECT_ENB=1'b1 Requires active reference clock" "0,1"
            newline
            bitfld.long 0x00 19.--23. "RXDETECT_WAIT_COUNTB,For lane B Set wait duration after CMSTEP is asserted to ignore RXDETOUT" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 18. "RXDETECT_STARTB,For lane B Receiver detection start signal Begins the receiver detection RTL state machine" "0,1"
            newline
            rbitfld.long 0x00 17. "RXDETECT_DONELB,For lane B Receiver detection RTL done signal latched This signal is the same as RXDETECT_DONEB but will remain static until receiver detection is re-started" "0,1"
            newline
            rbitfld.long 0x00 16. "RXDETECT_DONEB,For lane B Receiver detection RTL done signal" "0,1"
            newline
            hexmask.long.word 0x00 2.--15. 1. "RXDETECT_COUNTB,For lane B Receiver detect RTL duration count in TXPLL reference periods"
            newline
            bitfld.long 0x00 1. "CMSTEP_VALUEB,For lane B Voltage to step to when CMSTEPB is asserted 1'b0 --> VSSS 1'b1 --> VDDATXB" "0,1"
            newline
            bitfld.long 0x00 0. "CMSTEPB,For lane B Step the common mode of TX to the level programmed by CMSTEP_VALUEB Used for RX detection by TX" "0,1"
    group.long 0x5C++0x03
        line.long 0x00 "laneB_test1_0,laneb_test1_0"
            bitfld.long 0x00 1.--3. "TXATESTSELB,For lane B -------------------- 000 -> 16uA PTAT current 001 -> 8uA PTAT current 010 -> TX common mode voltage 011 -> 16uA bandgap current 100 -> regulated clock supply 101 -> VSSS 110 -> Logic 1 level 111 -> VDDHV" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0. "TXATESTENB,Enable Analog Test Mux for Lane B All TX Analog Test Mux outputs can be viewed on ATESTOUT Only allowed to set one of TXPLL_ATESTEN TXATESTENB RXATESTENB=1'b1 Active High" "0,1"
    group.long 0x60++0x03
        line.long 0x00 "laneB_test2_0,laneb_test2_0"
            bitfld.long 0x00 2.--4. "TX_BYPASS_SELECT_RTLB,For lane B RTL BYPASS_VALUE Input Select 3'b000 --> TXPLL Reference Clock 3'b001 --> Receiver Detect State Machine Output 3'b010 --> Electrical Idle Output 3'b011 --> BYPASS_VALUEB 3'b100 --> 8'b0000_0000 3'b101 --> 8'b0000_0000.." "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 1. "TX_BYPASS_SELECTB,for lane B 1'b0 --> Select BYPASS_VALUEB 1'b1 --> Select RXSEOUTB from de-serializer" "0,1"
            newline
            bitfld.long 0x00 0. "LPBKFIFO_ENABLEB,For lane B Active High Far-End Parallel Loopback FIFO Enable Set TX_DATA_SELECTB=3'b101 to pass Rx Loopback Data to the Tx Set TXREFCLK_SEL=2'b00 and choose TXCMOSREF_SEL according to the Rx lane to loop back" "0,1"
    group.long 0x64++0x03
        line.long 0x00 "laneB_test3_0,laneb_test3_0"
            bitfld.long 0x00 0.--2. "PRBSMODEB,For SERDES Channel B For serializer width 8 10 16" "0: PRBS7,1: PRBS9,2: PRBS15,3: PRBS23 3'b1xx,?..."
    group.long 0x68++0x03
        line.long 0x00 "laneB_trim_0,laneb_trim_0"
            bitfld.long 0x00 5. "TXTENB,For lane B TX back termination enable" "0,1"
            newline
            bitfld.long 0x00 2.--4. "TXRTRIMB,For lane B TX resistor trim When TXTENB = 1'b0 high-Z When TXTENB =" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0.--1. "TXITRIMB,For lane B Overall current scaling for TX Driver 2'b00 -> -10% 2'b01 -> -5% 2'b10 -> Nominal 2'b11 -> +5% Fine tuning of this value may be done at test and stored in NVM" "0,1,2,3"
    group.long 0x6C++0x03
        line.long 0x00 "rxA_cdr_ctle_0,rxa_cdr_ctle_0"
            bitfld.long 0x00 16.--17. "RXDRV_CDRA,For lane A RX CLTLE BW control for CDR path 2'b00 -> CTLE off for DC calibration 2'b01 -> minimum bandwidth 2'b11 -> maximum bandwidth" "0,1,2,3"
            newline
            bitfld.long 0x00 14.--15. "RST2_CDRA,CTLE degeneration resistor trim second CTLE stage for CDR path lane A 2'b00 --> Min peaking 2'b11 --> Max peaking" "0,1,2,3"
            newline
            bitfld.long 0x00 12.--13. "RST1_CDRA,CTLE degeneration resistor trim first CTLE stage for CDR path lane A 2'b00 --> Min peaking 2'b11 --> Max peaking" "0,1,2,3"
            newline
            bitfld.long 0x00 11. "DCFBEN_CDRA,For lane A Enable DC offset cancellation of the first two CTLE stages 1'b0 --> Disable DC offset cancellation 1'b1 --> Enable DC offset cancellation Cancellation should be disabled if a non-dc balanced or long run-length (>15 bits) input.." "0,1"
            newline
            bitfld.long 0x00 10. "CST2_CDRA,For lane A CTLE degeneration capacitor trim for second stage for the CDR path lane A (A = A .. A) 1'b0 --> Max peaking frequency 1'b1 --> Min peaking frequency" "0,1"
            newline
            bitfld.long 0x00 9. "CST1_CDRA,For lane A CTLE degeneration capacitor trim for first stage for the CDR path lane A (A = A .. A) 1'b0 --> Max peaking frequency 1'b1 --> Min peaking frequency" "0,1"
            newline
            bitfld.long 0x00 7.--8. "CSENT3_CDRA,For lane A CTLE Current Source Trim for the CDR path" "0,1,2,3"
            newline
            bitfld.long 0x00 5.--6. "CSENT2_CDRA,For lane A CTLE Current Source Trim for the CDR path" "0,1,2,3"
            newline
            bitfld.long 0x00 3.--4. "CSENT1_CDRA,For lane A CTLE Current Source Trim for the CDR path" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--2. "CMRTRIM_CDRA,For CDR lane A Trim for common mode restore circuit 3'b000 --> disabled 3'b001 --> minimum adjustment 3'b111 --> maximum adjustment" "0,1,2,3,4,5,6,7"
    group.long 0x70++0x03
        line.long 0x00 "rxA_cdr_ctle_offset_0,rxa_cdr_ctle_offset_0"
            hexmask.long.byte 0x00 21.--27. 1. "H0CDR3A,For lane A DC offset calibration of CDR sampler 3"
            newline
            hexmask.long.byte 0x00 14.--20. 1. "H0CDR2A,For lane A DC offset calibration of CDR sampler 2"
            newline
            hexmask.long.byte 0x00 7.--13. 1. "H0CDR1A,For lane A DC offset calibration of CDR sampler 1"
            newline
            hexmask.long.byte 0x00 0.--6. 1. "H0CDR0A,For lane A DC offset calibration of CDR sampler 0"
    group.long 0x74++0x03
        line.long 0x00 "rxA_cdr_dividers_0,rxa_cdr_dividers_0"
            bitfld.long 0x00 11.--15. "RXPLL_REFDIVA,For lane A RX PLL reference reference divide 5'b00000 -> /1 5'b00001 -> /1 5'b00010 -> /2 5'b00011 -> /3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 8.--10. "RXPLL_RANGEA,CDR PLL Range control lane A 3'b000 --> High Speed Mode - not supported in this macro 3'b001 --> Medium Speed Mode (2Gb/s-2.5Gb/s VCO divide by 2) DFE/EM can not be active 3'b010 --> Low Speed Mode (1Gb/s-2Gb/s VCO divide by 4) DFE/EM can.." "0,1,2,3,4,5,6,7"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "RXPLL_FBDIVA,For lane A RX PLL reference feedback divide (min 16) High Speed Mode - not supported in this macro Medium Speed Mode (2Gb/s-2.5Gb/s): RXPLL_RANGEA=3'b001 The VCO frequency is given by (f_ref * RXPLL_FBDIVA / RXPLL_REFDIVA * 2) The postdiv.."
    group.long 0x78++0x03
        line.long 0x00 "rxA_d10clk_0,rxa_d10clk_0"
            bitfld.long 0x00 1. "DATALOCKENA,For lane A Lock CDR to data mode enable" "0,1"
            newline
            bitfld.long 0x00 0. "DATALOCKDIVENA,For lane A Enable divide-by-32 path from data to CDR reference clock" "0,1"
    group.long 0x7C++0x03
        line.long 0x00 "rxA_dccalibration_0,rxa_dccalibration_0"
            rbitfld.long 0x00 7.--8. "CALOUT_EMA,For lane A Subsampled EM output for DC feedback correction Data is subsampled with deserializer clock During calibration set RESETDESA=1'b0 RCVENA=1'b0 Calibration only valid when RXPLL_LOCKA=1'b0 EM is not supported for the IP" "0,1,2,3"
            newline
            rbitfld.long 0x00 5.--6. "CALOUT_DFEA,For lane A Subsampled DFE output for DC feedback correction Data is subsampled with deserializer clock During calibration set RESETDESA=1'b0 RCVENA=1'b0 Calibration only valid when RXPLL_LOCKA=1'b0 DFE is not supported for the IP" "0,1,2,3"
            newline
            rbitfld.long 0x00 1.--4. "CALOUT_CDRA,For lane A Sub-sampled CDR output for DC feedback correction Data is sub-sampled with deserializer clock During calibration set RESETDESA=1'b0 RCVENA=1'b0 Calibration only valid when RXPLL_LOCKA=1'b0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0. "CALIBRATION_CLK_ENA,For lane A Enable de-serializer DC calibration clock" "0,1"

    rgroup.long 0x80++0x03
        line.long 0x00 "rxA_descal_ctle_monitor_0,rxa_descal_ctle_monitor_0"
            hexmask.long.byte 0x00 14.--20. 1. "H0CDR3_MONA,For lane A Value of H0CDR3 from Deserializer Calibration"
            newline
            hexmask.long.byte 0x00 7.--13. 1. "H0CDR1_MONA,For lane A Value of H0CDR1 from Deserializer Calibration"
            newline
            hexmask.long.byte 0x00 0.--6. 1. "H0CDR0_MONA,For lane A Value of H0CDR0 from Deserializer Calibration"
    rgroup.long 0x84++0x03
        line.long 0x00 "rxA_descal_ctle_offset_0,rxa_descal_ctle_offset_0"
            hexmask.long.byte 0x00 21.--27. 1. "OFFSET_EM1A,For lane A DC Calibration offset for the EM CTLE"
            newline
            hexmask.long.byte 0x00 14.--20. 1. "OFFSET_EM0A,For lane A DC Calibration offset for the EM CTLE"
            newline
            hexmask.long.byte 0x00 7.--13. 1. "OFFSET_DFE1A,For lane A DC Calibration offset for the DFE CTLE"
            newline
            hexmask.long.byte 0x00 0.--6. 1. "OFFSET_DFE0A,For lane A DC Calibration offset for the DFE CTLE"
    rgroup.long 0x88++0x03
        line.long 0x00 "rxA_descal_dfe_monitor_0,rxa_descal_dfe_monitor_0"
            bitfld.long 0x00 27.--31. "H5_MONA,For lane A Value of H5 from Deserializer Calibration" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 22.--26. "H4_MONA,For lane A Value of H4 from Deserializer Calibration" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 17.--21. "H3_MONA,For lane A Value of H3 from Deserializer Calibration" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 12.--16. "H2_MONA,For lane A Value of H2 from Deserializer Calibration" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 7.--11. "H1_MONA,For lane A Value of H1 from Deserializer Calibration" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            hexmask.long.byte 0x00 0.--6. 1. "H0CDR2_MONA,For lane A Value of H0CDR2 from Deserializer Calibration"

    group.long 0x8C++0x03
        line.long 0x00 "rxA_descal_enables_0,rxa_descal_enables_0"
            bitfld.long 0x00 22. "RUN_VERTICAL_USERA,For lane A Starts a Vertical Scan on positive transition" "0,1"
            newline
            bitfld.long 0x00 21. "RUN_VERTICAL_EM_USERA,For lane A Starts an EM-Only Vertical Scan on positive transition" "0,1"
            newline
            bitfld.long 0x00 20. "RUN_STEP_PHASE_EM_USERA,For lane A Changes the sampling clock phase of the EM receiver on positive transition" "0,1"
            newline
            bitfld.long 0x00 19. "RUN_STEP_PHASE_DFE_USERA,For lane A Changes the sampling clock phase of the DFE receiver on positive transition" "0,1"
            newline
            bitfld.long 0x00 18. "RUN_HORIZONTAL_USERA,For lane A Starts a Horizontal Scan on positive transition" "0,1"
            newline
            bitfld.long 0x00 17. "RUN_HORIZONTAL_EM_USERA,For lane A Starts an EM-Only Horizontal Scan on positive transition" "0,1"
            newline
            bitfld.long 0x00 16. "RUN_GOOD_LOCK_USERA,For lane A Starts a Good-lock test on positive transition" "0,1"
            newline
            bitfld.long 0x00 15. "RUN_FULL_CAL_USERA,For lane A Starts a Full Calibration on positive transition" "0,1"
            newline
            bitfld.long 0x00 14. "RUN_FE_CALIBRATION_USERA,For lane A Starts Front-End (FE) Calibration on positive transition" "0,1"
            newline
            bitfld.long 0x00 13. "RUN_FEDFE_CAL_USERA,For lane A Start Front-End / DFE Combo calibration on a positive transition" "0,1"
            newline
            bitfld.long 0x00 12. "RUN_EMCTLE_OFFSET_CAL_USERA,Starts CTLE DC-Offset calibration for the Eyre Monitor on positive transition for lane A" "0,1"
            newline
            bitfld.long 0x00 11. "RUN_DFECTLE_OFFSET_CAL_USERA,Starts CTLE DC-Offset calibration for the DFE on positive transition for lane A" "0,1"
            newline
            bitfld.long 0x00 10. "RUN_DFECAL_USERA,For lane A Starts DFE Calibration on positive transition" "0,1"
            newline
            bitfld.long 0x00 9. "RUN_CHANNEL_ALIGN_USERA,For lane A Starts Channel Alignment on positive transition" "0,1"
            newline
            bitfld.long 0x00 8. "RUN_CENTER_HORIZONTAL_USERA,For lane A Starts Phase Centering on positive transition" "0,1"
            newline
            bitfld.long 0x00 7. "RUN_CENTER_HORIZONTAL_EM_USERA,For lane A Starts Phase Centering (EM-Only) on positive transition" "0,1"
            newline
            bitfld.long 0x00 6. "RUN_CDRCTLE_OFFSET_CAL_USERA,Starts CTLE DC-Offset calibration for the CDR on positive transition for lane A While active DONE_CTLE_OFFSET_CALA will be set to 1'b0" "0,1"
            newline
            bitfld.long 0x00 5. "RUN_AREA_COMPUTE_USERA,For lane A Starts Eye-Area Computation on positive transition" "0,1"
            newline
            bitfld.long 0x00 4. "RESET_OFFSET_USERA,For lane A Reset DC Offset in sweep blocks used to calculate area" "0,1"
            newline
            bitfld.long 0x00 3. "EN_OFFSET_CALA,For lane A 1'b0 --> Do not calibrate CTLE offset during the calibration routine" "0,1"
            newline
            bitfld.long 0x00 2. "EN_FE_CALA,For lane A 1'b0 --> Do not perform Front-End calibration as part of the calibration routine 1'b1 --> Calibrate the Front-End as part of the full calibration routine (default)" "0,1"
            newline
            bitfld.long 0x00 1. "EN_FEDFE_CALA,For lane A Enable Front-End / DFE Combo calibration" "0,1"
            newline
            bitfld.long 0x00 0. "EN_DFE_CALA,For lane A 1'b0 --> Do not perform DFE Calibration as part of the calibration routine 1'b1 --> Calibrate the DFE as part of the calibration routine (default)" "0,1"
    group.long 0x90++0x03
        line.long 0x00 "rxA_descal_override_0,rxa_descal_override_0"
            bitfld.long 0x00 19. "SET_DFE_COEFFS_USERA,For lane A Use preset DFE coefficients as a starting point for calibration 1'b0 --> Start from '0' values for all coefficients" "0,1"
            newline
            bitfld.long 0x00 18. "SETALT_OFFSET_EM1A,For lane A By asserting a low-to-high transition switched the CTLE DC-offset correction set by calibration to those specified by the user in offset_XXX_alt" "0,1"
            newline
            bitfld.long 0x00 17. "SETALT_OFFSET_EM0A,For lane A By asserting a low-to-high transition switched the CTLE DC-offset correction set by calibration to those specified by the user in offset_XXX_alt" "0,1"
            newline
            bitfld.long 0x00 16. "SETALT_OFFSET_DFE1A,For lane A By asserting a low-to-high transition switched the CTLE DC-offset correction set by calibration to those specified by the user in offset_XXX_alt" "0,1"
            newline
            bitfld.long 0x00 15. "SETALT_OFFSET_DFE0A,For lane A By asserting a low-to-high transition switched the CTLE DC-offset correction set by calibration to those specified by the user in offset_XXX_alt" "0,1"
            newline
            bitfld.long 0x00 14. "SEL_SLIP_DES_EMA,For lane A If SEL_SIGNAME is high then signal SIGNAME is set by the register value SIGNAME_EXT" "0,1"
            newline
            bitfld.long 0x00 13. "SEL_RUN_EYEMONITOR_COMPARISONA,For lane A If SEL_SIGNAME is high then signal SIGNAME is set by the register value SIGNAME_EXT" "0,1"
            newline
            bitfld.long 0x00 12. "SEL_RCVENA,For lane A If SEL_SIGNAME is high then signal SIGNAME is set by the register value SIGNAME_EXT" "0,1"
            newline
            bitfld.long 0x00 11. "SEL_PHICTRL_EMA,For lane A If SEL_SIGNAME is high then signal SIGNAME is set by the register value SIGNAME_EXT" "0,1"
            newline
            bitfld.long 0x00 10. "SEL_PHICTRL_DFEA,For lane A If SEL_SIGNAME is high then signal SIGNAME is set by the register value SIGNAME_EXT" "0,1"
            newline
            bitfld.long 0x00 9. "SEL_LOCK_OVERRIDEA,For lane A If SEL_SIGNAME is high then signal SIGNAME is set by the register value SIGNAME_EXT" "0,1"
            newline
            bitfld.long 0x00 8. "SEL_H1TO5A,Override control for H1A H2A H3A H4A H5A for lane A 1'b0 --> H1A H2A H3A H4A H5A are controlled by DFE Calibration RTL 1'b1 --> H1A H2A H3A H4A H5A are controlled top level pins" "0,1"
            newline
            bitfld.long 0x00 7. "SEL_H0EMA,For lane A If SEL_SIGNAME is high then signal SIGNAME is set by the register value SIGNAME_EXT" "0,1"
            newline
            bitfld.long 0x00 6. "SEL_H0DFEA,For lane A If SEL_SIGNAME is high then signal SIGNAME is set by the register value SIGNAME_EXT" "0,1"
            newline
            bitfld.long 0x00 5. "SEL_H0CDRA,For lane A If SEL_SIGNAME is high then signal SIGNAME is set by the register value SIGNAME_EXT" "0,1"
            newline
            bitfld.long 0x00 4. "SEL_DFEEMCTLEA,Override control for CST1_DFEEMA CST2_DFEEMA RST1_DFEEMA RST2_DFEEMA CTLEEN_DFEA CTLEEN_EMA for lane A 1'b0 --> CST1_DFEEMA CST2_DFEEMA RST1_DFEEMA RST2_DFEEMA CTLEEN_DFEA CTLEEN_EMA are controlled by DFE Calibration RTL 1'b1 -->.." "0,1"
            newline
            bitfld.long 0x00 3. "SEL_CDRCTLEA,For lane A If SEL_SIGNAME is high then signal SIGNAME is set by the register value SIGNAME_EXT" "0,1"
            newline
            bitfld.long 0x00 2. "SEL_CALIBRATION_CLK_ENA,For lane A If SEL_SIGNAME is high then signal SIGNAME is set by the register value SIGNAME_EXT" "0,1"
            newline
            bitfld.long 0x00 1. "PHASE_DIRECTION_USERA,For lane A Sets the direction of the phase stepper 1'b0 --> Step down (decrease phase) 1'b1 --> Step up (increase phase) Set to 1'b1 after stepping the phase" "0,1"
            newline
            bitfld.long 0x00 0. "BYPASS_DFECAL_USERA,For lane A Bypass DFE Coefficients 1'b0 --> DFE coefficients set by the calibration RTL 1'b1 --> DFE coefficients set by the DFE calibration block are bypassed by the initial settings" "0,1"

    rgroup.long 0x94++0x03
        line.long 0x00 "rxA_descal_result2_0,rxa_descal_result2_0"
            bitfld.long 0x00 26.--31. "PHASE_EMA,For lane A Phase of the sampling clock in the DFE receiver" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 20.--25. "PHASE_DFEA,For lane A Phase of the sampling clock in the DFE receiver" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            hexmask.long.byte 0x00 13.--19. 1. "EYE_CENTER_VERTICALA,For lane A Vertical (DC-offset) center of the Eye openning"
            newline
            bitfld.long 0x00 7.--12. "EYE_CENTER_HORIZONTALA,For lane A Horizontal (Phase) center of the Eye openning" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 4.--6. "CHOICE_DFEEMA,For lane A Look-up table index for the CDR CTLE setting chosen by FE Calibration" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 3. "CHOICE_DFECOEFFA,For lane A Look-up table index for the DFE Coefficients chosen by FE Calibration" "0,1"
            newline
            bitfld.long 0x00 0.--2. "CHOICE_CDRA,For lane A Look-up table index for the CDR CTLE setting chosen by FE Calibration" "0,1,2,3,4,5,6,7"
    rgroup.long 0x98++0x03
        line.long 0x00 "rxA_descal_result_0,rxa_descal_result_0"
            bitfld.long 0x00 19.--24. "WIDTHA,For lane A Width of the Eye opening" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            hexmask.long.byte 0x00 12.--18. 1. "HEIGHTA,For lane A Height of the Eye opening"
            newline
            hexmask.long.word 0x00 0.--11. 1. "AREAA,For lane A Area of the Eye opening"

    group.long 0x9C++0x03
        line.long 0x00 "rxA_descal_settings1_0,rxa_descal_settings1_0"
            bitfld.long 0x00 27.--29. "WAIT_PERIOD_GOOD_LOCKA,For lane A Sets number of clock cycles to wait after a change in settings before starting to monitor the RX PLL lock signal" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long.byte 0x00 19.--26. 1. "NUM_SAMPLES_GOOD_LOCKA,For lane A Number of clock cycles the RX PLL lock signal will be observed and is expected to stay high to assume the PLL is properly locked"
            newline
            bitfld.long 0x00 13.--18. "NUM_SAMPLES_CTLE_OFFSET_CALA,For lane A Number of samples to collect from the CTLE outputs to determine if its output is in average logic high or low" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 8.--12. "MAX_DFE_CYCLESA,For lane A Maximum number of cycles without improvement before the DFE calibration quits" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 6.--7. "MAX_AREA_CYCLESA,For lane A Maximum number of iterations used to refine the center of the eye opening during area computation" "0,1,2,3"
            newline
            bitfld.long 0x00 5. "DFE_CAL_FREQUENCYA,For lane A Frequency of operation" "0,1"
            newline
            bitfld.long 0x00 1.--4. "DFE_CAL_CLKDIVA,For lane A DFE Calibration input clock divider Input clock frequency depends on the value of DESMODEA" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0. "DFE_CAL_CENA,For lane A Enable control for DFE Calibration 1'b0 --> DFE Calibration Disabled 1'b1 --> DFE Calibration Enabled" "0,1"
    group.long 0xA0++0x03
        line.long 0x00 "rxA_descal_settings2_0,rxa_descal_settings2_0"
            hexmask.long.word 0x00 2.--13. 1. "ERROR_THR_CHANNEL_ALIGNA,For lane A Number of eye-monitor errors (in multiples of 16) above which the DFE and EM receivers are assumed to be misaligned"
            newline
            bitfld.long 0x00 1. "DFE_CAL_RESETA,For lane A Reset DFE Calibration 1'b0 --> DFE Calibration is operating 1'b1 --> DFE Calibration is reset" "0,1"
            newline
            bitfld.long 0x00 0. "DFE_CAL_EM_ONLYA,For lane A Perform eye area calculation using eye monitor only This must be 0 during initial calibration in order to find the eye opening" "0,1"
    group.long 0xA4++0x03
        line.long 0x00 "rxA_descal_status_0,rxa_descal_status_0"
            rbitfld.long 0x00 23. "LOCK_IS_GOODA,For lane A Flag set by the Good-lock test after completion" "0,1"
            newline
            rbitfld.long 0x00 22. "DONE_VERTICAL_EMA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 21. "DONE_VERTICAL_COMBA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 20. "DONE_ROTATE_EM_EMA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 19. "DONE_ROTATE_EM_DFEA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 18. "DONE_ROTATE_EM_AREA_COMPUTEA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 17. "DONE_ROTATE_DFE_AREA_COMPUTEA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 16. "DONE_PHASE_EMA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 15. "DONE_PHASE_DFEA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 14. "DONE_HORIZONTAL_EMA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 13. "DONE_HORIZONTAL_COMBA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 12. "DONE_GOOD_LOCKA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 11. "DONE_FULL_CALA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 10. "DONE_FE_CALIBRATIONA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 9. "DONE_FEDFE_CALA,For lane A Done signal for Front-End / DFE Calibration combo" "0,1"
            newline
            rbitfld.long 0x00 8. "DONE_DFECALA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 7. "DONE_CHANNEL_ALIGNA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 6. "DONE_AREA_COMPUTEA,For lane A All done flags indicate that a process is inactive or has completed its task" "0,1"
            newline
            rbitfld.long 0x00 5. "DFE_CAL_SUCCESS_ALIGNA,For lane A Flag set by the Channel Alignment process after completion" "0,1"
            newline
            bitfld.long 0x00 2.--4. "DFE_CAL_NUM_COEFFSA,For lane A Number of coefficients to use during DFE calibration" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 1. "DFE_CAL_FORCE_CDR_COEFFSA,For lane A Forces the CTLE coefficients for the CDR to be the same as the CTLE coefficients for the DFE when calibration is running" "0,1"
            newline
            bitfld.long 0x00 0. "DFE_CAL_FORCEHA,For lane A Forces the alternative DFE coefficients to be the the only option for FE calibration and initial coefficients for DFE calibration" "0,1"
    group.long 0xA8++0x03
        line.long 0x00 "rxA_dfeem_ctle_0,rxa_dfeem_ctle_0"
            bitfld.long 0x00 19.--20. "RXDRV_EMA,For lane A RX CLTLE BW control for EM path 2'b00 -> CTLE off for DC calibration 2'b01 -> minimum bandwidth 2'b11 -> maximum bandwidth EM is not supported for the IP" "0,1,2,3"
            newline
            bitfld.long 0x00 17.--18. "RXDRV_DFEA,For lane A RX CLTLE BW control for DFE path 2'b00 -> CTLE off for DC calibration 2'b01 -> minimum bandwidth 2'b11 -> maximum bandwidth DFE is not supported for the IP" "0,1,2,3"
            newline
            bitfld.long 0x00 15.--16. "RST2_DFEEMA,CTLE degeneration resistor trim second CTLE stage shared for the DFE and Eye Monitors paths lane A 2'b00 --> Min peaking 2'b11 --> Max peaking DFE/EM are not supported for the IP" "0,1,2,3"
            newline
            bitfld.long 0x00 13.--14. "RST1_DFEEMA,CTLE degeneration resistor trim first CTLE stage shared for the DFE and Eye Monitors paths lane A 2'b00 --> Min peaking 2'b11 --> Max peaking DFE/EM are not supported for the IP" "0,1,2,3"
            newline
            bitfld.long 0x00 12. "DCFBEN_EMA,For lane A Enable DC offset cancellation of the first two CTLE stages 1'b0 --> Disable DC offset cancellation 1'b1 --> Enable DC offset cancellation Cancellation should be disabled if a non-dc balanced or long run-length (>15 bits) input.." "0,1"
            newline
            bitfld.long 0x00 11. "DCFBEN_DFEA,For lane A Enable DC offset cancellation of the first two CTLE stages 1'b0 --> Disable DC offset cancellation 1'b1 --> Enable DC offset cancellation Cancellation should be disabled if a non-dc balanced or long run-length (>15 bits) input.." "0,1"
            newline
            bitfld.long 0x00 10. "CST2_DFEEMA,For lane A CTLE degeneration capacitor trim for second stage shared for the DFE and Eye Monitor paths lane A (A = A .. A) 1'b0 --> Max peaking frequency 1'b1 --> Min peaking frequency DFE/EM are not supported for the IP" "0,1"
            newline
            bitfld.long 0x00 9. "CST1_DFEEMA,For lane A CTLE degeneration capacitor trim for first stage shared for the DFE and Eye Monitor paths lane A (A = A .. A) 1'b0 --> Max peaking frequency 1'b1 --> Min peaking frequency DFE/EM are not supported for the IP" "0,1"
            newline
            bitfld.long 0x00 7.--8. "CSENT3_DFEEMA,For lane A CTLE Current Source Trim for the DFE and Eye Monitor paths DFE/EM are not supported for the IP" "0,1,2,3"
            newline
            bitfld.long 0x00 5.--6. "CSENT2_DFEEMA,For lane A CTLE Current Source Trim for the DFE and Eye Monitor paths DFE/EM are not supported for the IP" "0,1,2,3"
            newline
            bitfld.long 0x00 3.--4. "CSENT1_DFEEMA,For lane A CTLE Current Source Trim for the DFE and Eye Monitor paths DFE/EM are not supported for the IP" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--2. "CMRTRIM_DFEEMA,For DFE/Eye Monitor lane A Trim for common mode restore circuit 3'b000 --> disabled 3'b001 --> minimum adjustment 3'b111 --> maximum adjustment DFE/EM are not supported for the IP" "0,1,2,3,4,5,6,7"
    group.long 0xAC++0x03
        line.long 0x00 "rxA_dfeem_ctle_offset_0,rxa_dfeem_ctle_offset_0"
            hexmask.long.byte 0x00 21.--27. 1. "H0EM1A,For lane A DC offset calibration for Eye monitor sampler 1 EM is not supported for the IP"
            newline
            hexmask.long.byte 0x00 14.--20. 1. "H0EM0A,For lane A DC offset calibration for Eye monitor sampler 0 EM is not supported for the IP"
            newline
            hexmask.long.byte 0x00 7.--13. 1. "H0DFE1A,For lane A DC offset calibration for DFE sampler 1 DFE is not supported for the IP"
            newline
            hexmask.long.byte 0x00 0.--6. 1. "H0DFE0A,For lane A DC offset calibration for DFE sampler 0 DFE is not supported for the IP"
    group.long 0xB0++0x03
        line.long 0x00 "rxA_dfeem_tapctrl_0,rxa_dfeem_tapctrl_0"
            bitfld.long 0x00 20.--24. "H5A,For lane A DFE eye monitor tap 5 DFE/EM are not supported for the IP" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 15.--19. "H4A,For lane A DFE eye monitor tap 4 DFE/EM are not supported for the IP" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 10.--14. "H3A,For lane A DFE eye monitor tap 3 DFE/EM are not supported for the IP" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 5.--9. "H2A,For lane A DFE eye monitor tap 2 DFE/EM are not supported for the IP" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 0.--4. "H1A,For lane A DFE eye monitor tap 1 DFE/EM are not supported for the IP" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    group.long 0xB4++0x03
        line.long 0x00 "rxA_eyemon_comparison_0,rxa_eyemon_comparison_0"
            rbitfld.long 0x00 20. "EYEMONITOR_COMPARISON_OUT_BITA,For SERDES Channel A Eye Monitor Comparison output bit 1'b0 --> DFE / Eye Monitor output agree 1'b0 --> DFE / Eye Monitor output don't agree" "0,1"
            newline
            hexmask.long.word 0x00 4.--19. 1. "EYEMONITOR_COMPARISON_OUTA,For SERDES Channel A Eye Monitor Comparison Error Count"
            newline
            rbitfld.long 0x00 3. "EYEMONITOR_COMPARISON_DONEA,For SERDES Channel A Eye Monitor Comparison Done Signal" "0,1"
            newline
            bitfld.long 0x00 0.--2. "EM_COMPARE_THRA,For SERDES Channel A Set bit-error threshold for open eye Decodes as 2^(EM_COMPARE_THR)-1 permitted errors Recommended to select EM_COMPARE_THR < 4 3'b000 --> 0 errors (legacy behavior default) 3'b001 --> 1 error 3'b010 --> 3 errors.." "0,1,2,3,4,5,6,7"
    group.long 0xB8++0x03
        line.long 0x00 "rxA_eyemon_comparison_1,rxa_eyemon_comparison_1"
            bitfld.long 0x00 12. "RUN_EYEMONITOR_COMPARISONA,For SERDES Channel A Eye Monitor Comparison RTL starts on a 0->1 transition of RUN_EYEMONITOR_COMPARISONA Eye monitor will accumulate EYEMONITOR_SAMPLE_COUNTA and then assert EYEMONITOR_COMPARISON_DONEA and present output on.." "0,1"
            newline
            hexmask.long.word 0x00 0.--11. 1. "EYEMONITOR_SAMPLE_COUNTA,For SERDES Channel A Eye Monitor comparison sample count Error rate is EYEMONITOR_COMPARISON_OUTA / (10*EYEMONITOR_SAMPLE_COUNTA) There are 10 samples taken for every clock period Eye monitor error counter will not restart until.."
    group.long 0xBC++0x03
        line.long 0x00 "rxA_frequency_det_0,rxa_frequency_det_0"
            rbitfld.long 0x00 29. "RXPLL_LOCKA,CDR Lane A Rx PLL Lock Control should be controlled by provided lock detection RTL RX data is valid once RXPLL_LOCKA=1'b1" "0,1"
            newline
            rbitfld.long 0x00 28. "RXPLL_FLOCKA,For lane A RX PLL frequency lock indication input for CDR RX data is valid after lock is asserted When LOCK_OVERRIDEA=2'b1x RXPLL_FLOCKA will initially be set to 1'b0 but will re-assert so long as the RXPLL remains frequency locked to it's.." "0,1"
            newline
            rbitfld.long 0x00 27. "RXPLL_CDRMODEA,For lane A CDR Lock Mode Select 1'b0 --> PLL Mode (Lock to RXREFCLKA) 1'b1 --> CDR Mode (Lock to Data) Controlled by included Lock Monitor RTL" "0,1"
            newline
            bitfld.long 0x00 26. "RESET_FDETA,For SERDES Channel A Asynchronous reset for frequency detector" "0,1"
            newline
            bitfld.long 0x00 25. "LOCK_OVERRIDE_ALT_ENA,For Channel A Enable for LOCK_OVERRIDE_ALTA" "0,1"
            newline
            bitfld.long 0x00 23.--24. "LOCK_OVERRIDE_ALTA,For Channel A Alternate lock override signal" "0,1,2,3"
            newline
            bitfld.long 0x00 21.--22. "LOCK_OVERRIDEA,For lane A Override control for lock signal 2'b00 --> normal operation 2'b01 --> Asynchronously Force high gain CDR mode operation" "0,1,2,3"
            newline
            bitfld.long 0x00 20. "LOCK_MODEA,For lane A Set Number of Loss-Of-Lock events for CDR LOCK to go low 1'b0 --> 1 event (normal operation) 1'b1 --> 2 events" "0,1"
            newline
            rbitfld.long 0x00 19. "FDET_VALIDA,For SERDES Channel A Frequency output is valid" "0,1"
            newline
            bitfld.long 0x00 14.--18. "FDET_SAMPLE_PERIODSA,For SERDES Channel A Frequency detector Number of periods to sample Resolution increases with number of periods" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 13. "FDET_MODEA,For Channel A Frequency detector reset mode" "0,1"
            newline
            rbitfld.long 0x00 8.--12. "FDET_CURRENT_SAMPLEA,For SERDES Channel A Frequency detector current sample" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "FDET_COUNTA,For SERDES Channel A Frequency detector count Frequency detector 'error' may be calculated FDET_COUNTA / (256*FDET_CURRENT_SAMPLEA)"
    group.long 0xC0++0x03
        line.long 0x00 "rxA_los_0,rxa_los_0"
            bitfld.long 0x00 16. "RXPKDETRANGEA,For lane A Enable the receiver peak detector 1'b0 -> gain is 30mV / bit 1'b0 -> gain is 50mV / bit" "0,1"
            newline
            hexmask.long.byte 0x00 9.--15. 1. "RXPKDETOUTA,For lane A Thermometer Coded Peak Detector Output Gain is set by RXPKDETRANGEA 7'b0000000 -> minimum level 7'b0000001 7'b0000011"
            newline
            bitfld.long 0x00 6.--8. "LOS_LTHRESHA,'Low' Threshold for LOS A If RXPKDETOUTA[<LOS_LTHRESH]=1'b0 LOSA=1'b1" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 3.--5. "LOS_HTHRESHA,'High' Threshold for LOS A If RXPKDETOUTA[>=LOS_HTHRESH]=1'b1 LOSA=1'b0" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 2. "LOS_ASYNCA,LOS Async Control Lane A Active High Place LOS Detector in async mode using LOS_LTHRESHA as the threshold for LOS" "0,1"
            newline
            rbitfld.long 0x00 1. "LOSA,Active-High Loss-Of-Signal Indicator for lane A" "0,1"
            newline
            bitfld.long 0x00 0. "EN_LOSA,Enable Receiver Loss-Of-Signal Detect Logic A 1'b1 --> If LOS is established (no data is sensed on RXPA/RXNA) CDR is disabled See LOS_HTHRESHA LOS_LTHRESHA for threshold programming" "0,1"
    group.long 0xC4++0x03
        line.long 0x00 "rxA_phctrl_0,rxa_phctrl_0"
            bitfld.long 0x00 24. "SLIP_DES_EMA,For EM lane A Slip de-serializer output alignment by 1 bit A bit slip occurs on every state change of SLIP_DES_EMA In 8b 16b and 32b de-serialization bits slip forward (ex: 101 01x 1xx) In 10b 20b and 40b de-serialization bits slip backward.." "0,1"
            newline
            bitfld.long 0x00 23. "SLIP_DES_DFEA,For DFE lane A Slip de-serializer output alignment by 1 bit A bit slip occurs on every state change of SLIP_DES_DFEA In 8b 16b and 32b de-serialization bits slip forward (ex: 101 01x 1xx) In 10b 20b and 40b de-serialization bits slip.." "0,1"
            newline
            bitfld.long 0x00 22. "SLIP_DES_CDRA,For CDR lane A Slip de-serializer output alignment by 1 bit A bit slip occurs on every state change of SLIP_DES_CDRA In 8b 16b and 32b de-serialization bits slip forward (ex: 101 01x 1xx) In 10b 20b and 40b de-serialization bits slip.." "0,1"
            newline
            hexmask.long.byte 0x00 14.--21. 1. "PHICTRL_TH_EMA,For lane A Thermometer Coded Phase control for Eye Monitor Sets phase of Eye Monitor versus the CDR Steps 1/32nd UI (1/4th UI total range) to interpolate between gray codes This should be fully stepped before transitioning gray codes to.."
            newline
            hexmask.long.byte 0x00 6.--13. 1. "PHICTRL_TH_DFEA,For lane A Thermometer Coded Phase control for DFE Sets phase of DFE versus the CDR Steps 1/32nd UI (1/4th UI total range) to interpolate between gray codes This should be fully stepped before transitioning gray codes to avoid glitching.."
            newline
            bitfld.long 0x00 3.--5. "PHICTRL_GRAY_EMA,For lane A Gray Coded Phase control for Eye Monitor Sets phase of Eye Monitor versus the CDR Steps 1/4th UI (2UI total range) EM is not supported for the IP" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0.--2. "PHICTRL_GRAY_DFEA,For lane A Gray Coded Phase control for DFE Sets phase of DFE versus the CDR Steps 1/4th UI (2UI total range) DFE is not supported for the IP" "0,1,2,3,4,5,6,7"

    rgroup.long 0xC8++0x03
        line.long 0x00 "rx_descal_status_0,rx_descal_status_0"
            bitfld.long 0x00 0. "DONE_CTLE_OFFSET_CALA,For lane A Ative-High Indicator that CTLE Offset Calibration proccess is complete or idle" "0,1"

    group.long 0xCC++0x03
        line.long 0x00 "txA_drvr_fsm_0,txa_drvr_fsm_0"
            bitfld.long 0x00 23. "TX_EIDLE_ENA,For lane A Place Transmitter Channel A in 'Electrical Idle' where differential output voltage on TXPA/TXNA = ~0V 1'b0 --> Normal Operation 1'b1 --> Electrical Idle" "0,1"
            newline
            hexmask.long.tbyte 0x00 5.--22. 1. "DRVR_COEFF_VALA,For lane A 18 bit coefficients bus"
            newline
            bitfld.long 0x00 4. "DRVR_COEFF_UPDATEA,For lane A Signal to start conversion of driver coefficients to driver settings Set DRVR_COEFF_ENA=1'b1 and program valid coefficients to DRVR_COEFF_VALA" "0,1"
            newline
            bitfld.long 0x00 3. "DRVR_COEFF_ENA,For lane A Enable Driver Coefficient-Based controller FSM 1'b0 --> Register control via TXDRVTRIMA TXDRVA TXDATA_INVA TXDELA etc 1'b1 --> Program driver emphasis via DRVR_COEFF_VALA state machine" "0,1"
            newline
            bitfld.long 0x00 0.--2. "DRVR_COEFF_AMPLA,For lane A" "0,1,2,3,4,5,6,7"

    rgroup.long 0xD0++0x03
        line.long 0x00 "txA_drvr_fsm_rsp_0,txa_drvr_fsm_rsp_0"
            bitfld.long 0x00 14. "DRVR_COEFF_RJCTA,For lane A 'Coefficients Rejected' error message from the coefficient state machine" "0,1"
            newline
            bitfld.long 0x00 8.--13. "DRVR_COEFF_LFA,For lane A Driver Low-Frequency swing level from coefficient FSM" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 2.--7. "DRVR_COEFF_FSA,For lane A Driver Full-Scale level from coefficient FSM" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 1. "DRVR_COEFF_DONELA,For lane A Latched done signal from Driver Coefficient Conversion Stat Machine DRVR_COEFF_DONELA will remain 1'b1 untilDRVR_COEFF_ENA=1'b0 RESET=1'b1 or DRVR_COEFF_UPDATEA goes from 1'b0 to 1'b1" "0,1"
            newline
            bitfld.long 0x00 0. "DRVR_COEFF_DONEA,For lane A Done signal from Driver Coefficient Conversion Stat Machine DRVR_COEFF_DONEA will remain 1'b1 for one TXPLL_REFCLK_TO_CORE_OUT period" "0,1"

    group.long 0xD4++0x03
        line.long 0x00 "txA_fixed_data_lsb_0,txa_fixed_data_lsb_0"
            hexmask.long.tbyte 0x00 0.--19. 1. "TXDATA_FIXED_LSBA,For SERDES Channel A 20 LSBs for a fixed pattern to Transmitter for testing Select by setting TX_DATA_SELECTA=3'b110"
    group.long 0xD8++0x03
        line.long 0x00 "txA_fixed_data_msb_0,txa_fixed_data_msb_0"
            hexmask.long.tbyte 0x00 0.--19. 1. "TXDATA_FIXED_MSBA,For SERDES Channel A 20 MSBs for a fixed pattern to Transmitter for testing Select by setting TX_DATA_SELECTA=3'b110"
    group.long 0xDC++0x03
        line.long 0x00 "txB_drvr_fsm_0,txb_drvr_fsm_0"
            bitfld.long 0x00 23. "TX_EIDLE_ENB,For lane B Place Transmitter Channel B in 'Electrical Idle' where differential output voltage on TXPB/TXNB = ~0V 1'b0 --> Normal Operation 1'b1 --> Electrical Idle" "0,1"
            newline
            hexmask.long.tbyte 0x00 5.--22. 1. "DRVR_COEFF_VALB,For lane B 18 bit coefficients bus"
            newline
            bitfld.long 0x00 4. "DRVR_COEFF_UPDATEB,For lane B Signal to start conversion of driver coefficients to driver settings Set DRVR_COEFF_ENB=1'b1 and program valid coefficients to DRVR_COEFF_VALB" "0,1"
            newline
            bitfld.long 0x00 3. "DRVR_COEFF_ENB,For lane B Enable Driver Coefficient-Based controller FSM 1'b0 --> Register control via TXDRVTRIMB TXDRVB TXDATA_INVB TXDELB etc 1'b1 --> Program driver emphasis via DRVR_COEFF_VALB state machine" "0,1"
            newline
            bitfld.long 0x00 0.--2. "DRVR_COEFF_AMPLB,For lane B" "0,1,2,3,4,5,6,7"

    rgroup.long 0xE0++0x03
        line.long 0x00 "txB_drvr_fsm_rsp_0,txb_drvr_fsm_rsp_0"
            bitfld.long 0x00 14. "DRVR_COEFF_RJCTB,For lane B 'Coefficients Rejected' error message from the coefficient state machine" "0,1"
            newline
            bitfld.long 0x00 8.--13. "DRVR_COEFF_LFB,For lane B Driver Low-Frequency swing level from coefficient FSM" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 2.--7. "DRVR_COEFF_FSB,For lane B Driver Full-Scale level from coefficient FSM" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 1. "DRVR_COEFF_DONELB,For lane B Latched done signal from Driver Coefficient Conversion Stat Machine DRVR_COEFF_DONELB will remain 1'b1 untilDRVR_COEFF_ENB=1'b0 RESET=1'b1 or DRVR_COEFF_UPDATEB goes from 1'b0 to 1'b1" "0,1"
            newline
            bitfld.long 0x00 0. "DRVR_COEFF_DONEB,For lane B Done signal from Driver Coefficient Conversion Stat Machine DRVR_COEFF_DONEB will remain 1'b1 for one TXPLL_REFCLK_TO_CORE_OUT period" "0,1"

    group.long 0xE4++0x03
        line.long 0x00 "txB_fixed_data_lsb_0,txb_fixed_data_lsb_0"
            hexmask.long.tbyte 0x00 0.--19. 1. "TXDATA_FIXED_LSBB,For SERDES Channel B 20 LSBs for a fixed pattern to Transmitter for testing Select by setting TX_DATA_SELECTB=3'b110"
    group.long 0xE8++0x03
        line.long 0x00 "txB_fixed_data_msb_0,txb_fixed_data_msb_0"
            hexmask.long.tbyte 0x00 0.--19. 1. "TXDATA_FIXED_MSBB,For SERDES Channel B 20 MSBs for a fixed pattern to Transmitter for testing Select by setting TX_DATA_SELECTB=3'b110"
    group.long 0xEC++0x03
        line.long 0x00 "txpll_control_0,txpll_control_0"
            bitfld.long 0x00 23.--24. "TXREFCLK_SEL,Reference Clock to TXPLL Select 2'b00 --> Select TXREFCLK_CORE refclk connected to core logic Set TXREFCLK_PD=1'b1 to power down LVDS Receiver for TXREFCLKP/TXREFCLKN 2'b01 --> Select LVDS reference clock from the neighboring lane 2'b10 -->.." "0,1,2,3"
            newline
            bitfld.long 0x00 21.--22. "TXREFCLK_RTRIM,Coarse Resistor Trim for LVDS Receiver for TXREFCLKP/TXREFCLKN Nominal Value is 2'b10 2'b00 --> 85 Ohms 2'b01 --> 95 Ohms 2'b10 --> 110 Ohms 2'b11 --> 130 Ohms" "0,1,2,3"
            newline
            bitfld.long 0x00 20. "TXREFCLK_PD,TXPLL TXREFCLKP/TXREFCLKN Receiver Powerdown Set to 1'b0 to use TXREFCLKP/TXREFCLKN" "0,1"
            newline
            bitfld.long 0x00 19. "TXPLL_PD,Active-High Transmit PLL Power Down Control" "0,1"
            newline
            bitfld.long 0x00 18. "TXPLL_FOUTVCO_EN,Active High Enable for TXPLL_FOUTVCO 1'b0 --> TXPLL_FOUTVCO Disabled Value = 'd0 1'b1 --> TXPLL_FOUTVCO Active" "0,1"
            newline
            bitfld.long 0x00 17. "TXPLL_CLKRESETEN,Enable for TXPLL_CLKRESET logic Active High" "0,1"
            newline
            bitfld.long 0x00 16. "TXPLL_CLKRESET,Reset signal synchronized and sent to serializers Stop Serializer clock for 4 VCO periods when TXPLL_CLKRESET transitions from 0 to 1" "0,1"
            newline
            bitfld.long 0x00 15. "TXPLL_BWSEL,Transmit PLL Bandwidth Control 1'b0 --> Minimum BW 1'b1 --> Maximum BW" "0,1"
            newline
            bitfld.long 0x00 14. "TXPLL_AUXDIVPD,Active High powerdown for Auxilary clock output from TXPLL Auxilary divider is used for jitter attenuator" "0,1"
            newline
            bitfld.long 0x00 11.--13. "TXPLL_ATESTSEL,Tx PLL Analog Test Output Select for ATESTOUT Active if TXPLL_ATESTEN=1'b1 Only allowed to set one of TXPLL_ATESTEN TXATESTEN# RXATESTEN#=1'b1 3'b000 --> 16uA PTAT current 3'b001 --> 8uA PTAT current 3'b010 --> Replica Ring Voltage 3'b011.." "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 10. "TXPLL_ATESTEN,Enable Analog Test Mux for TxPLL Output may be viewed on ATESTOUT Only allowed to set one of TXPLL_ATESTEN TXATESTEN# RXATESTEN#=1'b1 Active High" "0,1"
            newline
            bitfld.long 0x00 7.--9. "TXCMOSREF_SEL,Select for CMOS Reference clock to Tx PLL 3'b000 --> TXPLL_REFCLK (core reference clock default) 3'b001 --> RXCLK_TO_COREA_OUT 3'b010 --> RXCLK_TO_COREB_OUT 3'b011 --> RXCLK_TO_COREC_OUT 3'b100 --> RXCLK_TO_CORED_OUT 3'b101 --> Reserved.." "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 6. "REFCMLOUTEN_R,Active-High Enable for CML Output buffer to macro right side 1'b0 --> REFCMLOUTP_R / REFCMLOUTN_R=1'b0" "0,1"
            newline
            bitfld.long 0x00 5. "REFCMLOUTEN_L,Active-High Enable for CML Output buffer to macro left side 1'b0 --> REFCMLOUTP_L / REFCMLOUTN_L=1'b0" "0,1"
            newline
            bitfld.long 0x00 4. "REFCMLINEN_R,Active High Enable for CML buffer from macro right side Must be set to 1'b1 if TXREFCLK_SEL=2'b10" "0,1"
            newline
            bitfld.long 0x00 3. "REFCMLINEN_L,Active High Enable for CML buffer from macro left side Must be set to 1'b1 if TXREFCLK_SEL=2'b11" "0,1"
            newline
            bitfld.long 0x00 2. "LVDSCLK_SEL_R,Selection control for REFCMLOUTP_R / REFCMLOUTN_R LVDSCLK_SEL_R=1'b0 --> REFCMLINP_L / REFCMLINN_L LVDSCLK_SEL_R=1'b1 --> Output from LVDS Receiver" "0,1"
            newline
            bitfld.long 0x00 1. "LVDSCLK_SEL_L,Selection control for REFCMLOUTP_L / REFCMLOUTN_L LVDSCLK_SEL_L=1'b0 --> REFCMLINP_R / REFCMLINN_R LVDSCLK_SEL_L=1'b1 --> Output from LVDS Receiver" "0,1"
            newline
            bitfld.long 0x00 0. "BGSELVDD,Bandgap Voltage Select 1'b0 --> Generated from Bandgap Circuit (1.2V) 1'b1 --> Generated from VDDHV*2/3 (1.2V)" "0,1"
    group.long 0xF0++0x03
        line.long 0x00 "txpll_divider1_0,txpll_divider1_0"
            bitfld.long 0x00 25.--26. "TXPLL_FBDIV_SEL,Select Tx PLL Feedback Divide Control for Tx PLL 2'b00 --> Core Side TXPLL_FBDIV TXPLL_FRAC 2'b01 --> Spread Spectrum Modulator 2'b10 --> Reserved 2'b11 --> Core Side + Phase Step Logic TXPLL_FBDIV_SEL should only be updated while.." "0,1,2,3"
            newline
            hexmask.long.word 0x00 13.--24. 1. "TXPLL_FBDIV,Transmit PLL feedback divide value from: -16 in integer mode -19 in fractional-N mode The VCO frequency is given by (f_ref * TXPLL_FBDIV / TXPLL_REFDIV) where f_ref is the reference frequency The bit rate is given by (2 * f_ref * TXPLL_FBDIV.."
            newline
            bitfld.long 0x00 12. "TXPLL_DSMPD,Transmit PLL fractional modulator PD 1'b0 --> Fractional Mode 1'b1 --> Integer Mode The PLL should be in integer mode (TXPLL_DSMPD=1'b1) for lowest jitter PLL must be in fractional mode (TXPLL_DSMPD=1'b0) to use the JA PLL or SSMOD" "0,1"
            newline
            hexmask.long.word 0x00 0.--11. 1. "TXPLL_AUXDIV,Transmit PLL Auxilary clock output TXPLL_FOUTAUXDIV= VCO Frequency / TXPLL_AUXDIV Valid divide settings : 8-10 12-4095 TXPLL_FOUTAUXDIV connected to Jitter Attenuator FFB port Auxilary divider is used for jitter attenuator"
    group.long 0xF4++0x03
        line.long 0x00 "txpll_divider2_0,txpll_divider2_0"
            bitfld.long 0x00 24.--29. "TXPLL_REFDIV,Transmit PLL reference divide value (1 to 63) For PLL programming see TXPLL_FBDIV notes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            hexmask.long.tbyte 0x00 0.--23. 1. "TXPLL_FRAC,PLL fractional part of feedback divide value Used when TXPLL_DSMPD=1'b0"
    group.long 0xF8++0x03
        line.long 0x00 "txpll_offsetcal_0,txpll_offsetcal_0"
            bitfld.long 0x00 29. "TXPLL_OFFSETFASTCAL,Active High Fast Calibration Enable 1'b0 --> Low gain mode" "0,1"
            newline
            hexmask.long.word 0x00 17.--28. 1. "TXPLL_OFFSETCALOUT,Output calibration value from offset calibration"
            newline
            hexmask.long.word 0x00 5.--16. 1. "TXPLL_OFFSETCALIN,Offset calibration input"
            newline
            bitfld.long 0x00 4. "TXPLL_OFFSETCALEN,Active High control to enable Tx PLL's static phase offset calibration 1'b0 --> skew calibration is disabled" "0,1"
            newline
            bitfld.long 0x00 1.--3. "TXPLL_OFFSETCALCNT,Programmable counter for deskew calibration loop Selects the number of PFD edges to wait after each deskew calibration step" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0. "TXPLL_OFFSETCALBYP,Active High bypass control for offset calibration 1'b0 --> Use the skew calibration output (when TXPLL_OFFSETCALEN=1) to set the phase correction 1'b1 --> Use the TXPLL_OFFSETCALIN[11:7] to set phase correction" "0,1"
    group.long 0xFC++0x03
        line.long 0x00 "txpll_phstep_0,txpll_phstep_0"
            bitfld.long 0x00 8. "TXPLL_PHSTEP_RUN,Rising Edge sensitive run control for phase step logic for Tx PLL PLL Must operate in fractional mode for phase step logic to function (TXPLL_DSMPD=1'b0) Set TXPLL_FBDIV_SEL=2'b11 to use Phase Step block" "0,1"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "TXPLL_PHSTEP_AMT,Transmit PLL Phase Step Amount Fractions of a VCO period for Tx PLL 8'b0000_0001 --> +Fvco/128 8'b0100_0000 --> +Fvco/4 (1/2 UI) 8'b1100_0000 --> -Fvco/4 (-1/2 UI) Set TXPLL_FBDIV_SEL=2'b11 to use Phase Step block"

    rgroup.long 0x100++0x03
        line.long 0x00 "txpll_status_0,txpll_status_0"
            bitfld.long 0x00 1. "TXPLL_OFFSETCALLOCK,Active high indicator that offset calibration has settled Only active when TXPLL_OFFSETCALEN=1'b1" "0,1"
            newline
            bitfld.long 0x00 0. "TXPLL_LOCK,Transmit PLL lock output" "0,1"

    group.long 0x104++0x03
        line.long 0x00 "txpll_test_0,txpll_test_0"
            bitfld.long 0x00 5. "TXPLL_RD_LCK_STB,'Read' Control for stability monitor for TxPLL 1'b0 --> Monitor for falling edges of TXPLL_LOCK 1'b1 --> Present result on TXPLL_LCK_STB_CNT reset internal count" "0,1"
            newline
            bitfld.long 0x00 4. "TXPLL_LTC_RESET,Reset lock time counter 1'b0 --> Lock time counter active 1'b1 --> Lock time counter in reset" "0,1"
            newline
            rbitfld.long 0x00 0.--3. "TXPLL_LCK_STB_CNT,Count of the number of falling edges of TXPLL_LOCK while TXPLL_RD_LCK_STB=1'b0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x108++0x03
        line.long 0x00 "txpll_test_lck_cnt_0,txpll_test_lck_cnt_0"
            hexmask.long.word 0x00 16.--31. 1. "TXPLL_OFFS_LCK_CNT,Lock Time Count for Offset Calibration Units of input Clock Periods (TXPLL_REFCLK_TO_CORE_IN Periods)"
            newline
            hexmask.long.word 0x00 0.--15. 1. "TXPLL_LCK_CNT,Count of transmit PLL lock time in reference clock periods for txpll # (# = A .. B)"
tree.end

tree "SMALL_NOC ()"
    base ad:0x8BF00000
    rgroup.long 0x00++0x03
        line.long 0x00 "Id_CoreId,Stores the Core Id and its checksum"
            hexmask.long.tbyte 0x00 8.--31. 1. "CORECHECKSUM,Field containing a checksum of the parameters of the IP"
            hexmask.long.byte 0x00 0.--7. 1. "CORETYPEID,Field identifying the type of IP"
    rgroup.long 0x04++0x03
        line.long 0x00 "Id_RevisionId,Stores a user-defined Id and the software revision"
            hexmask.long.tbyte 0x00 8.--31. 1. "FLEXNOCID,Field containing the build revision of the software used to generate the IP HDL code"
            hexmask.long.byte 0x00 0.--7. 1. "USERID,Field containing a user defined value not used anywhere inside the IP itself"

    group.long 0x08++0x03
        line.long 0x00 "FreezeEn,Register FreezeEn"
            hexmask.long.byte 0x00 0.--7. 1. "FREEZEEN,This 8 bits register enable/disable the Write operation on the RegBank when set"
    group.long 0x0C++0x03
        line.long 0x00 "Clear,clear"
            bitfld.long 0x00 1. "BISTCLEAR,Clear all BIST related registers" "0,1"
            bitfld.long 0x00 0. "MISSIONCLEAR,Clear Mission Faults" "0,1"
    group.long 0x10++0x03
        line.long 0x00 "BistControl,bistcontrol"
            bitfld.long 0x00 24. "AUTOMISSION,BIST AutoMission - Automaticaly go back into mission mode when BIST is done" "0,1"
            hexmask.long.byte 0x00 16.--23. 1. "TIMEOUT1,BIST TimeOut1 value"
            hexmask.long.word 0x00 0.--15. 1. "TIMEOUT0,BIST TimeOut0 value"

    rgroup.long 0x14++0x03
        line.long 0x00 "BistStatus,biststatus"
            bitfld.long 0x00 1. "FAILED,BIST Status (1=Failed)" "0,1"
            bitfld.long 0x00 0. "DONE,BIST Done" "0,1"

    group.long 0x18++0x03
        line.long 0x00 "BistStart,Register BistStart"
            hexmask.long.byte 0x00 0.--7. 1. "BISTSTART,Start BIST mode only with code word 0xB5"
    group.long 0x20++0x03
        line.long 0x00 "FaultTypeReg0,faulttypereg0"
            bitfld.long 0x00 30.--31. "FAULTTYPE15,Fault Type 15" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE14,Fault Type 14" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE13,Fault Type 13" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE12,Fault Type 12" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE11,Fault Type 11" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE10,Fault Type 10" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE9,Fault Type 9" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE8,Fault Type 8" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE7,Fault Type 7" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE6,Fault Type 6" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE5,Fault Type 5" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE4,Fault Type 4" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE3,Fault Type 3" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE2,Fault Type 2" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE1,Fault Type 1" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE0,Fault Type 0" "0,1,2,3"
    group.long 0x24++0x03
        line.long 0x00 "FaultTypeReg1,faulttypereg1"
            bitfld.long 0x00 30.--31. "FAULTTYPE31,Fault Type 31" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE30,Fault Type 30" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE29,Fault Type 29" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE28,Fault Type 28" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE27,Fault Type 27" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE26,Fault Type 26" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE25,Fault Type 25" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE24,Fault Type 24" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE23,Fault Type 23" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE22,Fault Type 22" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE21,Fault Type 21" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE20,Fault Type 20" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE19,Fault Type 19" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE18,Fault Type 18" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE17,Fault Type 17" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE16,Fault Type 16" "0,1,2,3"
    group.long 0x28++0x03
        line.long 0x00 "FaultTypeReg2,faulttypereg2"
            bitfld.long 0x00 30.--31. "FAULTTYPE47,Fault Type 47" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE46,Fault Type 46" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE45,Fault Type 45" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE44,Fault Type 44" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE43,Fault Type 43" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE42,Fault Type 42" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE41,Fault Type 41" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE40,Fault Type 40" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE39,Fault Type 39" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE38,Fault Type 38" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE37,Fault Type 37" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE36,Fault Type 36" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE35,Fault Type 35" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE34,Fault Type 34" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE33,Fault Type 33" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE32,Fault Type 32" "0,1,2,3"
    group.long 0x2C++0x03
        line.long 0x00 "FaultTypeReg3,faulttypereg3"
            bitfld.long 0x00 12.--13. "FAULTTYPE54,Fault Type 54" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE53,Fault Type 53" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE52,Fault Type 52" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE51,Fault Type 51" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE50,Fault Type 50" "0,1,2,3"
            bitfld.long 0x00 2.--3. "FAULTTYPE49,Fault Type 49" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE48,Fault Type 48" "0,1,2,3"

    rgroup.long 0x40++0x03
        line.long 0x00 "MissionFault0,missionfault0"
            bitfld.long 0x00 31. "FAULT31,Fault 31" "0,1"
            bitfld.long 0x00 30. "FAULT30,Fault 30" "0,1"
            bitfld.long 0x00 29. "FAULT29,Fault 29" "0,1"
            bitfld.long 0x00 28. "FAULT28,Fault 28" "0,1"
            bitfld.long 0x00 27. "FAULT27,Fault 27" "0,1"
            bitfld.long 0x00 26. "FAULT26,Fault 26" "0,1"
            bitfld.long 0x00 25. "FAULT25,Fault 25" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT24,Fault 24" "0,1"
            bitfld.long 0x00 23. "FAULT23,Fault 23" "0,1"
            bitfld.long 0x00 22. "FAULT22,Fault 22" "0,1"
            bitfld.long 0x00 21. "FAULT21,Fault 21" "0,1"
            bitfld.long 0x00 20. "FAULT20,Fault 20" "0,1"
            bitfld.long 0x00 19. "FAULT19,Fault 19" "0,1"
            bitfld.long 0x00 18. "FAULT18,Fault 18" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT17,Fault 17" "0,1"
            bitfld.long 0x00 16. "FAULT16,Fault 16" "0,1"
            bitfld.long 0x00 15. "FAULT15,Fault 15" "0,1"
            bitfld.long 0x00 14. "FAULT14,Fault 14" "0,1"
            bitfld.long 0x00 13. "FAULT13,Fault 13" "0,1"
            bitfld.long 0x00 12. "FAULT12,Fault 12" "0,1"
            bitfld.long 0x00 11. "FAULT11,Fault 11" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT10,Fault 10" "0,1"
            bitfld.long 0x00 9. "FAULT9,Fault 9" "0,1"
            bitfld.long 0x00 8. "FAULT8,Fault 8" "0,1"
            bitfld.long 0x00 7. "FAULT7,Fault 7" "0,1"
            bitfld.long 0x00 6. "FAULT6,Fault 6" "0,1"
            bitfld.long 0x00 5. "FAULT5,Fault 5" "0,1"
            bitfld.long 0x00 4. "FAULT4,Fault 4" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT3,Fault 3" "0,1"
            bitfld.long 0x00 2. "FAULT2,Fault 2" "0,1"
            bitfld.long 0x00 1. "FAULT1,Fault 1" "0,1"
            bitfld.long 0x00 0. "FAULT0,Fault 0" "0,1"
    rgroup.long 0x44++0x03
        line.long 0x00 "MissionFault1,missionfault1"
            bitfld.long 0x00 31. "CONSTANT_0_63,Reserved bit" "0,1"
            bitfld.long 0x00 30. "CONSTANT_0_62,Reserved bit" "0,1"
            bitfld.long 0x00 29. "CONSTANT_0_61,Reserved bit" "0,1"
            bitfld.long 0x00 28. "CONSTANT_0_60,Reserved bit" "0,1"
            bitfld.long 0x00 27. "CONSTANT_0_59,Reserved bit" "0,1"
            bitfld.long 0x00 26. "CONSTANT_0_58,Reserved bit" "0,1"
            bitfld.long 0x00 25. "CONSTANT_0_57,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 24. "CONSTANT_0_56,Reserved bit" "0,1"
            bitfld.long 0x00 23. "CONSTANT_0_55,Reserved bit" "0,1"
            bitfld.long 0x00 22. "FAULT54,Fault 54" "0,1"
            bitfld.long 0x00 21. "FAULT53,Fault 53" "0,1"
            bitfld.long 0x00 20. "FAULT52,Fault 52" "0,1"
            bitfld.long 0x00 19. "FAULT51,Fault 51" "0,1"
            bitfld.long 0x00 18. "FAULT50,Fault 50" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT49,Fault 49" "0,1"
            bitfld.long 0x00 16. "FAULT48,Fault 48" "0,1"
            bitfld.long 0x00 15. "FAULT47,Fault 47" "0,1"
            bitfld.long 0x00 14. "FAULT46,Fault 46" "0,1"
            bitfld.long 0x00 13. "FAULT45,Fault 45" "0,1"
            bitfld.long 0x00 12. "FAULT44,Fault 44" "0,1"
            bitfld.long 0x00 11. "FAULT43,Fault 43" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT42,Fault 42" "0,1"
            bitfld.long 0x00 9. "FAULT41,Fault 41" "0,1"
            bitfld.long 0x00 8. "FAULT40,Fault 40" "0,1"
            bitfld.long 0x00 7. "FAULT39,Fault 39" "0,1"
            bitfld.long 0x00 6. "FAULT38,Fault 38" "0,1"
            bitfld.long 0x00 5. "FAULT37,Fault 37" "0,1"
            bitfld.long 0x00 4. "FAULT36,Fault 36" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT35,Fault 35" "0,1"
            bitfld.long 0x00 2. "FAULT34,Fault 34" "0,1"
            bitfld.long 0x00 1. "FAULT33,Fault 33" "0,1"
            bitfld.long 0x00 0. "FAULT32,Fault 32" "0,1"
    rgroup.long 0x48++0x03
        line.long 0x00 "MissionFault2,missionfault2"
            bitfld.long 0x00 31. "CONSTANT_0_95,Reserved bit" "0,1"
            bitfld.long 0x00 30. "CONSTANT_0_94,Reserved bit" "0,1"
            bitfld.long 0x00 29. "CONSTANT_0_93,Reserved bit" "0,1"
            bitfld.long 0x00 28. "CONSTANT_0_92,Reserved bit" "0,1"
            bitfld.long 0x00 27. "CONSTANT_0_91,Reserved bit" "0,1"
            bitfld.long 0x00 26. "CONSTANT_0_90,Reserved bit" "0,1"
            bitfld.long 0x00 25. "CONSTANT_0_89,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 24. "CONSTANT_0_88,Reserved bit" "0,1"
            bitfld.long 0x00 23. "CONSTANT_0_87,Reserved bit" "0,1"
            bitfld.long 0x00 22. "CONSTANT_0_86,Reserved bit" "0,1"
            bitfld.long 0x00 21. "CONSTANT_0_85,Reserved bit" "0,1"
            bitfld.long 0x00 20. "CONSTANT_0_84,Reserved bit" "0,1"
            bitfld.long 0x00 19. "CONSTANT_0_83,Reserved bit" "0,1"
            bitfld.long 0x00 18. "CONSTANT_0_82,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 17. "CONSTANT_0_81,Reserved bit" "0,1"
            bitfld.long 0x00 16. "CONSTANT_0_80,Reserved bit" "0,1"
            bitfld.long 0x00 15. "CONSTANT_0_79,Reserved bit" "0,1"
            bitfld.long 0x00 14. "CONSTANT_0_78,Reserved bit" "0,1"
            bitfld.long 0x00 13. "CONSTANT_0_77,Reserved bit" "0,1"
            bitfld.long 0x00 12. "CONSTANT_0_76,Reserved bit" "0,1"
            bitfld.long 0x00 11. "CONSTANT_0_75,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 10. "CONSTANT_0_74,Reserved bit" "0,1"
            bitfld.long 0x00 9. "CONSTANT_0_73,Reserved bit" "0,1"
            bitfld.long 0x00 8. "CONSTANT_0_72,Reserved bit" "0,1"
            bitfld.long 0x00 7. "CONSTANT_0_71,Reserved bit" "0,1"
            bitfld.long 0x00 6. "CONSTANT_0_70,Reserved bit" "0,1"
            bitfld.long 0x00 5. "CONSTANT_0_69,Reserved bit" "0,1"
            bitfld.long 0x00 4. "CONSTANT_0_68,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 3. "CONSTANT_0_67,Reserved bit" "0,1"
            bitfld.long 0x00 2. "CONSTANT_0_66,Reserved bit" "0,1"
            bitfld.long 0x00 1. "CONSTANT_0_65,Reserved bit" "0,1"
            bitfld.long 0x00 0. "CONSTANT_0_64,Reserved bit" "0,1"
    rgroup.long 0x4C++0x03
        line.long 0x00 "MissionFault3,missionfault3"
            bitfld.long 0x00 31. "CONSTANT_0_127,Reserved bit" "0,1"
            bitfld.long 0x00 30. "CONSTANT_0_126,Reserved bit" "0,1"
            bitfld.long 0x00 29. "CONSTANT_0_125,Reserved bit" "0,1"
            bitfld.long 0x00 28. "CONSTANT_0_124,Reserved bit" "0,1"
            bitfld.long 0x00 27. "CONSTANT_0_123,Reserved bit" "0,1"
            bitfld.long 0x00 26. "CONSTANT_0_122,Reserved bit" "0,1"
            bitfld.long 0x00 25. "CONSTANT_0_121,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 24. "CONSTANT_0_120,Reserved bit" "0,1"
            bitfld.long 0x00 23. "CONSTANT_0_119,Reserved bit" "0,1"
            bitfld.long 0x00 22. "CONSTANT_0_118,Reserved bit" "0,1"
            bitfld.long 0x00 21. "CONSTANT_0_117,Reserved bit" "0,1"
            bitfld.long 0x00 20. "CONSTANT_0_116,Reserved bit" "0,1"
            bitfld.long 0x00 19. "CONSTANT_0_115,Reserved bit" "0,1"
            bitfld.long 0x00 18. "CONSTANT_0_114,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 17. "CONSTANT_0_113,Reserved bit" "0,1"
            bitfld.long 0x00 16. "CONSTANT_0_112,Reserved bit" "0,1"
            bitfld.long 0x00 15. "CONSTANT_0_111,Reserved bit" "0,1"
            bitfld.long 0x00 14. "CONSTANT_0_110,Reserved bit" "0,1"
            bitfld.long 0x00 13. "CONSTANT_0_109,Reserved bit" "0,1"
            bitfld.long 0x00 12. "CONSTANT_0_108,Reserved bit" "0,1"
            bitfld.long 0x00 11. "CONSTANT_0_107,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 10. "CONSTANT_0_106,Reserved bit" "0,1"
            bitfld.long 0x00 9. "CONSTANT_0_105,Reserved bit" "0,1"
            bitfld.long 0x00 8. "CONSTANT_0_104,Reserved bit" "0,1"
            bitfld.long 0x00 7. "CONSTANT_0_103,Reserved bit" "0,1"
            bitfld.long 0x00 6. "CONSTANT_0_102,Reserved bit" "0,1"
            bitfld.long 0x00 5. "CONSTANT_0_101,Reserved bit" "0,1"
            bitfld.long 0x00 4. "CONSTANT_0_100,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 3. "CONSTANT_0_99,Reserved bit" "0,1"
            bitfld.long 0x00 2. "CONSTANT_0_98,Reserved bit" "0,1"
            bitfld.long 0x00 1. "CONSTANT_0_97,Reserved bit" "0,1"
            bitfld.long 0x00 0. "CONSTANT_0_96,Reserved bit" "0,1"
    rgroup.long 0x50++0x03
        line.long 0x00 "LatentInternalFault,latentinternalfault"
            bitfld.long 0x00 2. "CRITORTREE,Latent internal Fault in Crit OR Tree" "0,1"
            bitfld.long 0x00 1. "MAJORTREE,Latent internal Fault in Maj OR Tree" "0,1"
            bitfld.long 0x00 0. "MINORTREE,Latent internal Fault in Min OR Tree" "0,1"
    rgroup.long 0x54++0x03
        line.long 0x00 "LatentComFault0,latentcomfault0"
            bitfld.long 0x00 31. "FAULT31,Latent communication Fault 31" "0,1"
            bitfld.long 0x00 30. "FAULT30,Latent communication Fault 30" "0,1"
            bitfld.long 0x00 29. "FAULT29,Latent communication Fault 29" "0,1"
            bitfld.long 0x00 28. "FAULT28,Latent communication Fault 28" "0,1"
            bitfld.long 0x00 27. "FAULT27,Latent communication Fault 27" "0,1"
            bitfld.long 0x00 26. "FAULT26,Latent communication Fault 26" "0,1"
            bitfld.long 0x00 25. "FAULT25,Latent communication Fault 25" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT24,Latent communication Fault 24" "0,1"
            bitfld.long 0x00 23. "FAULT23,Latent communication Fault 23" "0,1"
            bitfld.long 0x00 22. "FAULT22,Latent communication Fault 22" "0,1"
            bitfld.long 0x00 21. "FAULT21,Latent communication Fault 21" "0,1"
            bitfld.long 0x00 20. "FAULT20,Latent communication Fault 20" "0,1"
            bitfld.long 0x00 19. "FAULT19,Latent communication Fault 19" "0,1"
            bitfld.long 0x00 18. "FAULT18,Latent communication Fault 18" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT17,Latent communication Fault 17" "0,1"
            bitfld.long 0x00 16. "FAULT16,Latent communication Fault 16" "0,1"
            bitfld.long 0x00 15. "FAULT15,Latent communication Fault 15" "0,1"
            bitfld.long 0x00 14. "FAULT14,Latent communication Fault 14" "0,1"
            bitfld.long 0x00 13. "FAULT13,Latent communication Fault 13" "0,1"
            bitfld.long 0x00 12. "FAULT12,Latent communication Fault 12" "0,1"
            bitfld.long 0x00 11. "FAULT11,Latent communication Fault 11" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT10,Latent communication Fault 10" "0,1"
            bitfld.long 0x00 9. "FAULT9,Latent communication Fault 9" "0,1"
            bitfld.long 0x00 8. "FAULT8,Latent communication Fault 8" "0,1"
            bitfld.long 0x00 7. "FAULT7,Latent communication Fault 7" "0,1"
            bitfld.long 0x00 6. "FAULT6,Latent communication Fault 6" "0,1"
            bitfld.long 0x00 5. "FAULT5,Latent communication Fault 5" "0,1"
            bitfld.long 0x00 4. "FAULT4,Latent communication Fault 4" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT3,Latent communication Fault 3" "0,1"
            bitfld.long 0x00 2. "FAULT2,Latent communication Fault 2" "0,1"
            bitfld.long 0x00 1. "FAULT1,Latent communication Fault 1" "0,1"
            bitfld.long 0x00 0. "FAULT0,Latent communication Fault 0" "0,1"
    rgroup.long 0x58++0x03
        line.long 0x00 "LatentComFault1,latentcomfault1"
            bitfld.long 0x00 31. "CONSTANT_0_63,Reserved bit" "0,1"
            bitfld.long 0x00 30. "CONSTANT_0_62,Reserved bit" "0,1"
            bitfld.long 0x00 29. "CONSTANT_0_61,Reserved bit" "0,1"
            bitfld.long 0x00 28. "CONSTANT_0_60,Reserved bit" "0,1"
            bitfld.long 0x00 27. "CONSTANT_0_59,Reserved bit" "0,1"
            bitfld.long 0x00 26. "CONSTANT_0_58,Reserved bit" "0,1"
            bitfld.long 0x00 25. "CONSTANT_0_57,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 24. "CONSTANT_0_56,Reserved bit" "0,1"
            bitfld.long 0x00 23. "CONSTANT_0_55,Reserved bit" "0,1"
            bitfld.long 0x00 22. "CONSTANT_0_54,Reserved bit" "0,1"
            bitfld.long 0x00 21. "FAULT53,Latent communication Fault 53" "0,1"
            bitfld.long 0x00 20. "FAULT52,Latent communication Fault 52" "0,1"
            bitfld.long 0x00 19. "FAULT51,Latent communication Fault 51" "0,1"
            bitfld.long 0x00 18. "FAULT50,Latent communication Fault 50" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT49,Latent communication Fault 49" "0,1"
            bitfld.long 0x00 16. "FAULT48,Latent communication Fault 48" "0,1"
            bitfld.long 0x00 15. "FAULT47,Latent communication Fault 47" "0,1"
            bitfld.long 0x00 14. "FAULT46,Latent communication Fault 46" "0,1"
            bitfld.long 0x00 13. "FAULT45,Latent communication Fault 45" "0,1"
            bitfld.long 0x00 12. "FAULT44,Latent communication Fault 44" "0,1"
            bitfld.long 0x00 11. "FAULT43,Latent communication Fault 43" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT42,Latent communication Fault 42" "0,1"
            bitfld.long 0x00 9. "FAULT41,Latent communication Fault 41" "0,1"
            bitfld.long 0x00 8. "FAULT40,Latent communication Fault 40" "0,1"
            bitfld.long 0x00 7. "FAULT39,Latent communication Fault 39" "0,1"
            bitfld.long 0x00 6. "FAULT38,Latent communication Fault 38" "0,1"
            bitfld.long 0x00 5. "FAULT37,Latent communication Fault 37" "0,1"
            bitfld.long 0x00 4. "FAULT36,Latent communication Fault 36" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT35,Latent communication Fault 35" "0,1"
            bitfld.long 0x00 2. "FAULT34,Latent communication Fault 34" "0,1"
            bitfld.long 0x00 1. "FAULT33,Latent communication Fault 33" "0,1"
            bitfld.long 0x00 0. "FAULT32,Latent communication Fault 32" "0,1"
    rgroup.long 0x5C++0x03
        line.long 0x00 "LatentComFault2,latentcomfault2"
            bitfld.long 0x00 31. "CONSTANT_0_95,Reserved bit" "0,1"
            bitfld.long 0x00 30. "CONSTANT_0_94,Reserved bit" "0,1"
            bitfld.long 0x00 29. "CONSTANT_0_93,Reserved bit" "0,1"
            bitfld.long 0x00 28. "CONSTANT_0_92,Reserved bit" "0,1"
            bitfld.long 0x00 27. "CONSTANT_0_91,Reserved bit" "0,1"
            bitfld.long 0x00 26. "CONSTANT_0_90,Reserved bit" "0,1"
            bitfld.long 0x00 25. "CONSTANT_0_89,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 24. "CONSTANT_0_88,Reserved bit" "0,1"
            bitfld.long 0x00 23. "CONSTANT_0_87,Reserved bit" "0,1"
            bitfld.long 0x00 22. "CONSTANT_0_86,Reserved bit" "0,1"
            bitfld.long 0x00 21. "CONSTANT_0_85,Reserved bit" "0,1"
            bitfld.long 0x00 20. "CONSTANT_0_84,Reserved bit" "0,1"
            bitfld.long 0x00 19. "CONSTANT_0_83,Reserved bit" "0,1"
            bitfld.long 0x00 18. "CONSTANT_0_82,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 17. "CONSTANT_0_81,Reserved bit" "0,1"
            bitfld.long 0x00 16. "CONSTANT_0_80,Reserved bit" "0,1"
            bitfld.long 0x00 15. "CONSTANT_0_79,Reserved bit" "0,1"
            bitfld.long 0x00 14. "CONSTANT_0_78,Reserved bit" "0,1"
            bitfld.long 0x00 13. "CONSTANT_0_77,Reserved bit" "0,1"
            bitfld.long 0x00 12. "CONSTANT_0_76,Reserved bit" "0,1"
            bitfld.long 0x00 11. "CONSTANT_0_75,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 10. "CONSTANT_0_74,Reserved bit" "0,1"
            bitfld.long 0x00 9. "CONSTANT_0_73,Reserved bit" "0,1"
            bitfld.long 0x00 8. "CONSTANT_0_72,Reserved bit" "0,1"
            bitfld.long 0x00 7. "CONSTANT_0_71,Reserved bit" "0,1"
            bitfld.long 0x00 6. "CONSTANT_0_70,Reserved bit" "0,1"
            bitfld.long 0x00 5. "CONSTANT_0_69,Reserved bit" "0,1"
            bitfld.long 0x00 4. "CONSTANT_0_68,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 3. "CONSTANT_0_67,Reserved bit" "0,1"
            bitfld.long 0x00 2. "CONSTANT_0_66,Reserved bit" "0,1"
            bitfld.long 0x00 1. "CONSTANT_0_65,Reserved bit" "0,1"
            bitfld.long 0x00 0. "CONSTANT_0_64,Reserved bit" "0,1"
    rgroup.long 0x60++0x03
        line.long 0x00 "LatentComFault3,latentcomfault3"
            bitfld.long 0x00 31. "CONSTANT_0_127,Reserved bit" "0,1"
            bitfld.long 0x00 30. "CONSTANT_0_126,Reserved bit" "0,1"
            bitfld.long 0x00 29. "CONSTANT_0_125,Reserved bit" "0,1"
            bitfld.long 0x00 28. "CONSTANT_0_124,Reserved bit" "0,1"
            bitfld.long 0x00 27. "CONSTANT_0_123,Reserved bit" "0,1"
            bitfld.long 0x00 26. "CONSTANT_0_122,Reserved bit" "0,1"
            bitfld.long 0x00 25. "CONSTANT_0_121,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 24. "CONSTANT_0_120,Reserved bit" "0,1"
            bitfld.long 0x00 23. "CONSTANT_0_119,Reserved bit" "0,1"
            bitfld.long 0x00 22. "CONSTANT_0_118,Reserved bit" "0,1"
            bitfld.long 0x00 21. "CONSTANT_0_117,Reserved bit" "0,1"
            bitfld.long 0x00 20. "CONSTANT_0_116,Reserved bit" "0,1"
            bitfld.long 0x00 19. "CONSTANT_0_115,Reserved bit" "0,1"
            bitfld.long 0x00 18. "CONSTANT_0_114,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 17. "CONSTANT_0_113,Reserved bit" "0,1"
            bitfld.long 0x00 16. "CONSTANT_0_112,Reserved bit" "0,1"
            bitfld.long 0x00 15. "CONSTANT_0_111,Reserved bit" "0,1"
            bitfld.long 0x00 14. "CONSTANT_0_110,Reserved bit" "0,1"
            bitfld.long 0x00 13. "CONSTANT_0_109,Reserved bit" "0,1"
            bitfld.long 0x00 12. "CONSTANT_0_108,Reserved bit" "0,1"
            bitfld.long 0x00 11. "CONSTANT_0_107,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 10. "CONSTANT_0_106,Reserved bit" "0,1"
            bitfld.long 0x00 9. "CONSTANT_0_105,Reserved bit" "0,1"
            bitfld.long 0x00 8. "CONSTANT_0_104,Reserved bit" "0,1"
            bitfld.long 0x00 7. "CONSTANT_0_103,Reserved bit" "0,1"
            bitfld.long 0x00 6. "CONSTANT_0_102,Reserved bit" "0,1"
            bitfld.long 0x00 5. "CONSTANT_0_101,Reserved bit" "0,1"
            bitfld.long 0x00 4. "CONSTANT_0_100,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 3. "CONSTANT_0_99,Reserved bit" "0,1"
            bitfld.long 0x00 2. "CONSTANT_0_98,Reserved bit" "0,1"
            bitfld.long 0x00 1. "CONSTANT_0_97,Reserved bit" "0,1"
            bitfld.long 0x00 0. "CONSTANT_0_96,Reserved bit" "0,1"
tree.end

tree "SYSCTRL ()"
    base ad:0x89000000
    rgroup.long 0x00++0x03
        line.long 0x00 "NAME,ASIC name"
            hexmask.long 0x00 0.--31. 1. "NAME,A read from this register will return the ASIC name (CHND)"
    rgroup.long 0x04++0x03
        line.long 0x00 "REV,Silicon Revision"
            hexmask.long.word 0x00 0.--15. 1. "REV,A read from this register will return the silicon revision (e.g. B0)"

    group.long 0x08++0x03
        line.long 0x00 "RETAIN_0,Retained data 0"
            hexmask.long 0x00 0.--31. 1. "RETAIN_0,Only reset by RSTN pin"
    group.long 0x0C++0x03
        line.long 0x00 "RETAIN_1,Retained data 1"
            hexmask.long 0x00 0.--31. 1. "RETAIN_1,Only reset by RSTN pin"
    group.long 0x10++0x03
        line.long 0x00 "RETAIN_2,Retained data 2"
            hexmask.long 0x00 0.--31. 1. "RETAIN_2,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x14++0x03
        line.long 0x00 "RETAIN_3,Retained data 3"
            hexmask.long 0x00 0.--31. 1. "RETAIN_3,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x18++0x03
        line.long 0x00 "RETAIN_4,Retained data 4"
            hexmask.long 0x00 0.--31. 1. "RETAIN_4,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x1C++0x03
        line.long 0x00 "RETAIN_5,Retained data 5"
            hexmask.long 0x00 0.--31. 1. "RETAIN_5,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x20++0x03
        line.long 0x00 "RETAIN_6,Retained data 6"
            hexmask.long 0x00 0.--31. 1. "RETAIN_6,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x24++0x03
        line.long 0x00 "RETAIN_7,Retained data 7"
            hexmask.long 0x00 0.--31. 1. "RETAIN_7,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x28++0x03
        line.long 0x00 "RETAIN_8,Retained data 8"
            hexmask.long 0x00 0.--31. 1. "RETAIN_8,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x2C++0x03
        line.long 0x00 "RETAIN_9,Retained data 9"
            hexmask.long 0x00 0.--31. 1. "RETAIN_9,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x30++0x03
        line.long 0x00 "RETAIN_A,Retained data A"
            hexmask.long 0x00 0.--31. 1. "RETAIN_A,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x34++0x03
        line.long 0x00 "RETAIN_B,Retained data B"
            hexmask.long 0x00 0.--31. 1. "RETAIN_B,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x38++0x03
        line.long 0x00 "RETAIN_C,Retained data C"
            hexmask.long 0x00 0.--31. 1. "RETAIN_C,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x3C++0x03
        line.long 0x00 "RETAIN_D,Retained data D"
            hexmask.long 0x00 0.--31. 1. "RETAIN_D,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x40++0x03
        line.long 0x00 "RETAIN_E,Retained data E"
            hexmask.long 0x00 0.--31. 1. "RETAIN_E,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x44++0x03
        line.long 0x00 "RETAIN_F,Retained data F"
            hexmask.long 0x00 0.--31. 1. "RETAIN_F,This register is either reset by RSTN pin WDT or CRG.RESETREQ.ALL"
    group.long 0x48++0x03
        line.long 0x00 "DEBUG_CODE,Debug access key"
            hexmask.long 0x00 0.--31. 1. "DEBUG_ACCESS_KEY,Write the value 0x1dacce55 to this register to enable debug options"

    rgroup.long 0x4C++0x03
        line.long 0x00 "DEBUG_STS,Debug access enabled"
            bitfld.long 0x00 0. "DEBUG_ACCESS_STATUS,A status flag that is set when debug access is enabled" "0,1"

    group.long 0x50++0x03
        line.long 0x00 "TRIM_CODE,Trim access key"
            hexmask.long 0x00 0.--31. 1. "TRIM_ACCESS_KEY,Write the value 0xCA005AFE to this register to set 'trim access_status' RO field to '1'"
    group.long 0x54++0x03
        line.long 0x00 "TRIM,Trim access enabled"
            bitfld.long 0x00 8.--10. "CTL_BG_RTRIM,BandGap voltage trim" "0,1,2,3,4,5,6,7"
            rbitfld.long 0x00 0. "TRIM_ACCESS_STATUS,A status flag that is set when TRIM_ACCESS_KEY is set to its key value" "0,1"

    rgroup.long 0x58++0x03
        line.long 0x00 "LBIST_SEQ_STAT0,LBIST Sequencer Status Register 0"
            bitfld.long 0x00 31. "STS_LBSC_TIM_EXP,Timeout expired for bootup LBIST" "0,1"
            bitfld.long 0x00 30. "STS_LBSC_TIM_ENA,Timeout was enabled for bootup LBIST" "0,1"
            newline
            hexmask.long.word 0x00 20.--29. 1. "STS_LBSC_LAST_ADDR,Last address as read out from OTP by LBIST sequencer"
            hexmask.long.word 0x00 4.--19. 1. "STS_LBSC_STATE,LBIST sequencer state"
            newline
            bitfld.long 0x00 3. "STS_LBSC_ERR,LBIST sequencer saw pslverr while reading out from OTP" "0,1"
            bitfld.long 0x00 2. "STS_LBSC_GOOD,LBIST sequencer completed and did not fail" "0,1"
            newline
            bitfld.long 0x00 1. "STS_LBSC_DONE,LBIST sequencer has loaded the In-System Test RAM" "0,1"
            bitfld.long 0x00 0. "STS_LBSC_LOADED,LBIST sequencer has loaded the In-System Test RAM" "0,1"

    group.long 0x5C++0x03
        line.long 0x00 "LBIST_MEM_MISC_CTRL0,LBIST Sequencer Memory Control Register"
            bitfld.long 0x00 31. "CTL_LBSC_IRQ_ENA,When this field is set (1) when functional/period LBIST is done an interrupt request will be triggered to supervisory processor" "0,1"
            bitfld.long 0x00 28.--29. "CTL_LBSC_PLBIST_BLK,When running functional/periodic LBIST each individual bit controls LBIST termination and clearing for a LBIST block" "0,1,2,3"
            newline
            bitfld.long 0x00 24. "CTL_LBSC_FUNC_RUN,Run LBIST from a 'functional' state as opposed to on power-up" "0,1"
            hexmask.long.byte 0x00 16.--23. 1. "CTL_LBSC_FUNC_KEY,This field must match 0x9e to allow SFR to kick off an LBIST run"
            newline
            bitfld.long 0x00 12. "CTL_LBSC_OP_WR,If set (1) then do RAM write's" "0,1"
            bitfld.long 0x00 8.--10. "CTL_LBSC_NUM_OPS,Number of operations to execute upon one toggling of CTL_LBSC_OP_GO" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_LBSC_MEM_KEY,This field must match 0xb5 to allow SFR access to the IST Memory"
    group.long 0x60++0x03
        line.long 0x00 "LBIST_MEM_MISC_CTRL1,LBIST Sequencer Memory Address Control Register"
            bitfld.long 0x00 16. "CTL_LBSC_OP_GO,Toggle (write to '1' then '0') to execute operation to IST Memory from SFR" "0,1"
            bitfld.long 0x00 12. "CTL_LBSC_ADDR_PUSH,Toggle (write '1' then '0') this field to push the field CTL_LBSC_ADDR_INIT into internal registers" "0,1"
            newline
            hexmask.long.word 0x00 0.--9. 1. "CTL_LBSC_ADDR_INIT,This field allows user to explicitly set the IST memory address to write or read from"

    rgroup.long 0x64++0x03
        line.long 0x00 "LBIST_MEM_MISC_STAT,LBIST Sequencer Memory Address Status Register"
            bitfld.long 0x00 16. "STS_LBSC_OP_DONE,Operations from toggling CTL_LBSC_OP_GO are complete" "0,1"
            bitfld.long 0x00 12. "STS_LBSC_SFR_MEM,If this field is '1' control of the IST memory is given to SFR control" "0,1"
            newline
            hexmask.long.word 0x00 0.--9. 1. "STS_LBSC_ADDR_NEXT,IST memory address of the next transaction"

    group.long 0x70++0x03
        line.long 0x00 "LBIST_MEM_WDATA_0,LBIST Sequencer Memory Data 0"
            hexmask.long 0x00 0.--31. 1. "CTL_LBSC_MEM_DATA0,Data to write to IST memory"
    group.long 0x74++0x03
        line.long 0x00 "LBIST_MEM_WDATA_1,LBIST Sequencer Memory Data 1"
            hexmask.long 0x00 0.--31. 1. "CTL_LBSC_MEM_DATA1,ctl_lbsc_mem_data1"
    group.long 0x78++0x03
        line.long 0x00 "LBIST_MEM_WDATA_2,LBIST Sequencer Memory Data 2"
            hexmask.long 0x00 0.--31. 1. "CTL_LBSC_MEM_DATA2,ctl_lbsc_mem_data2"
    group.long 0x7C++0x03
        line.long 0x00 "LBIST_MEM_WDATA_3,LBIST Sequencer Memory Data 3"
            hexmask.long 0x00 0.--31. 1. "CTL_LBSC_MEM_DATA3,ctl_lbsc_mem_data3"
    group.long 0x80++0x03
        line.long 0x00 "LBIST_MEM_WDATA_4,LBIST Sequencer Memory Data 4"
            hexmask.long 0x00 0.--31. 1. "CTL_LBSC_MEM_DATA4,ctl_lbsc_mem_data4"
    group.long 0x84++0x03
        line.long 0x00 "LBIST_MEM_WDATA_5,LBIST Sequencer Memory Data 5"
            hexmask.long 0x00 0.--31. 1. "CTL_LBSC_MEM_DATA5,ctl_lbsc_mem_data5"
    group.long 0x88++0x03
        line.long 0x00 "LBIST_MEM_WDATA_6,LBIST Sequencer Memory Data 6"
            hexmask.long 0x00 0.--31. 1. "CTL_LBSC_MEM_DATA6,ctl_lbsc_mem_data6"
    group.long 0x8C++0x03
        line.long 0x00 "LBIST_MEM_WDATA_7,LBIST Sequencer Memory Data 7"
            hexmask.long 0x00 0.--31. 1. "CTL_LBSC_MEM_DATA7,ctl_lbsc_mem_data7"

    rgroup.long 0x90++0x03
        line.long 0x00 "LBIST_MEM_RDATA_0,LBIST Sequencer Memory Data 0"
            hexmask.long 0x00 0.--31. 1. "STS_LBSC_MEM_DATA0,Data to read from IST memory"
    rgroup.long 0x94++0x03
        line.long 0x00 "LBIST_MEM_RDATA_1,LBIST Sequencer Memory Data 1"
            hexmask.long 0x00 0.--31. 1. "STS_LBSC_MEM_DATA1,sts_lbsc_mem_data1"
    rgroup.long 0x98++0x03
        line.long 0x00 "LBIST_MEM_RDATA_2,LBIST Sequencer Memory Data 2"
            hexmask.long 0x00 0.--31. 1. "STS_LBSC_MEM_DATA2,sts_lbsc_mem_data2"
    rgroup.long 0x9C++0x03
        line.long 0x00 "LBIST_MEM_RDATA_3,LBIST Sequencer Memory Data 3"
            hexmask.long 0x00 0.--31. 1. "STS_LBSC_MEM_DATA3,sts_lbsc_mem_data3"
    rgroup.long 0xA0++0x03
        line.long 0x00 "LBIST_MEM_RDATA_4,LBIST Sequencer Memory Data 4"
            hexmask.long 0x00 0.--31. 1. "STS_LBSC_MEM_DATA4,sts_lbsc_mem_data4"
    rgroup.long 0xA4++0x03
        line.long 0x00 "LBIST_MEM_RDATA_5,LBIST Sequencer Memory Data 5"
            hexmask.long 0x00 0.--31. 1. "STS_LBSC_MEM_DATA5,sts_lbsc_mem_data5"
    rgroup.long 0xA8++0x03
        line.long 0x00 "LBIST_MEM_RDATA_6,LBIST Sequencer Memory Data 6"
            hexmask.long 0x00 0.--31. 1. "STS_LBSC_MEM_DATA6,sts_lbsc_mem_data6"
    rgroup.long 0xAC++0x03
        line.long 0x00 "LBIST_MEM_RDATA_7,LBIST Sequencer Memory Data 7"
            hexmask.long 0x00 0.--31. 1. "STS_LBSC_MEM_DATA7,sts_lbsc_mem_data7"

    group.long 0xB0++0x03
        line.long 0x00 "PVT0_CTRL0,PVT 0 Control 0"
            bitfld.long 0x00 4. "CTL_PVT0_SOFT_RST,Soft-reset of controller FSM" "0,1"
            bitfld.long 0x00 1. "CTL_PVT0_RUN,Primary run control" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_PVT0_CK_EN,Enable PVT analog macro CLK signal" "0,1"
    group.long 0xB4++0x03
        line.long 0x00 "PVT0_CTRL1,PVT 0 Control 1"
            hexmask.long.byte 0x00 20.--27. 1. "CTL_PVT0_PERIOD,The frequency of the CLK driven to PVT monitor is configurable by this field"
            bitfld.long 0x00 12.--16. "CTL_PVT0_TRIMG,ctl_pvt0_trimg" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 6.--11. "CTL_PVT0_TRIMO,ctl_pvt0_trimo" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            bitfld.long 0x00 4.--5. "CTL_PVT0_PSAMPLE,ctl_pvt0_psample" "0,1,2,3"
            newline
            bitfld.long 0x00 3. "CTL_PVT0_VSAMPLE,ctl_pvt0_vsample" "0,1"
            bitfld.long 0x00 0.--2. "CTL_PVT0_ANA_TEST_SEL,ctl_pvt0_ana_test_sel" "0,1,2,3,4,5,6,7"
    group.long 0xB8++0x03
        line.long 0x00 "PVT0_CTRL2,PVT 0 Control 2"
            hexmask.long.byte 0x00 16.--23. 1. "CTL_PVT0_ENA_LOW,Minimum number of clock cycles that ENA must stay low for"
            hexmask.long.byte 0x00 8.--15. 1. "CTL_PVT0_DOUT_PST,ENA signal is lowered back to '0' after this_field number of clk_pvt cycles then when clock counter hits the ENA_FALL field value"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_PVT0_DOUT_PRE,DATA_OUT from the PVT analog macro is sampled by the controller when internal FSM counter hits this_field value"
    group.long 0xBC++0x03
        line.long 0x00 "PVT0_CTRL3,PVT 0 Control 3"
            bitfld.long 0x00 25. "CTL_PVT0_ALARM1_ACC,If set (1) use accumulated value for comparison for alarm 1" "0,1"
            bitfld.long 0x00 24. "CTL_PVT0_ALARM0_ACC,If set (1) use accumulated value for comparison for alarm 0" "0,1"
            newline
            bitfld.long 0x00 16.--21. "CTL_PVT0_ACC_LEN,Number of read's to accumulate over before sending interrupt to user (0-indexed)" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            hexmask.long.byte 0x00 8.--15. 1. "CTL_PVT0_ENA_FALL,ENA signal from controller to PVT analog macro is lowered when the clock counter hits this_field"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_PVT0_ENA_RISE,ENA signal from controller to PVT analog macro is raised high after leaving the ST_ENA_RISE state when the clock counter hits this_field"
    group.long 0xC0++0x03
        line.long 0x00 "PVT0_CTRL4,PVT 0 Control 4"
            hexmask.long.word 0x00 16.--31. 1. "CTL_PVT0_ALARM1_THR,If selected value is greater than this_field then the alarm 1 is asserted"
            hexmask.long.word 0x00 0.--15. 1. "CTL_PVT0_ALARM0_THR,If selected value is greater than this_field then the alarm 0 is asserted"
    group.long 0xC4++0x03
        line.long 0x00 "PVT0_TO_CTRL,PVT 0 Timeout Control"
            hexmask.long.tbyte 0x00 0.--23. 1. "CTL_PVT0_TIMEOUT,Timeout for Controller FSM"

    rgroup.long 0xC8++0x03
        line.long 0x00 "PVT0_TO_STAT,PVT 0 Timeout Status"
            hexmask.long 0x00 0.--31. 1. "STS_PVT0_TIMER_VAL,Timer value of Controller FSM"

    group.long 0xCC++0x03
        line.long 0x00 "PVT0_BYP_CTRL,PVT 0 Control 6"
            bitfld.long 0x00 1. "CTL_PVT0_ENA_VAL,Used to drive 'ENA' signal to PVT macro if override is enabled" "0,1"
            bitfld.long 0x00 0. "CTL_PVT0_OVR,If set (1) override of controller's FSM control of 'ENA' signal to PVT macro with 'ena_val' SFR field" "0,1"

    rgroup.long 0xD0++0x03
        line.long 0x00 "PVT0_STAT0,PVT 0 Status 0"
            bitfld.long 0x00 16.--21. "STS_PVT0_READ_CNT,Number of readings' that went into 'dout_acc'" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            hexmask.long.word 0x00 0.--9. 1. "STS_PVT0_DOUT_INS,Last valid DATA_OUT output from PVT analog macro"
    rgroup.long 0xD4++0x03
        line.long 0x00 "PVT0_STAT1,PVT 0 Status 1"
            hexmask.long.byte 0x00 16.--22. 1. "STS_PVT0_STATE,Internal FSM state used for diagnostic only"
            hexmask.long.word 0x00 0.--15. 1. "STS_PVT0_DOUT_ACC,Accumulated DATA_OUT's over averaging window"
    rgroup.long 0xD8++0x03
        line.long 0x00 "PVT0_STAT2,PVT 0 Status 2"
            bitfld.long 0x00 16. "STS_PVT0_RAW_DVALID,DATA_VALID from PVT macro with no handling of timing" "0,1"
            hexmask.long.word 0x00 0.--9. 1. "STS_PVT0_RAW_DOUT,DATA_OUT from PVT macro with no handling of timing"

    group.long 0xDC++0x03
        line.long 0x00 "PVT0_IRQ_CTRL,PVT 0 Interrupt and Alarm Control"
            bitfld.long 0x00 4.--5. "CTL_PVT0_ALARM_ENA,Enable bits for alarm 0 and 1" "0,1,2,3"
            bitfld.long 0x00 3. "CTL_PVT0_SIG_ENA,Enable bits for signaling IRQ source" "0,1"
            newline
            bitfld.long 0x00 0.--2. "CTL_PVT0_ERR_ENA,Enable bits for error IRQ sources" "0,1,2,3,4,5,6,7"
    group.long 0xE0++0x03
        line.long 0x00 "PVT0_IRQ_STAT,PVT 0 Interrupt and Alarm Status"
            bitfld.long 0x00 16.--17. "STS_PVT0_ALARM,Bits are sticky write a '1' to individual bits to clear" "0,1,2,3"
            bitfld.long 0x00 8. "STS_PVT0_SIG,Bits are sticky write a '1' to individual bits to clear" "0,1"
            newline
            bitfld.long 0x00 0.--2. "STS_PVT0_ERR,Each bit corresponds to a specific error source" "0,1,2,3,4,5,6,7"
    group.long 0xE4++0x03
        line.long 0x00 "PVT1_CTRL0,PVT 1 Control 0"
            bitfld.long 0x00 4. "CTL_PVT1_SOFT_RST,Soft-reset of controller FSM" "0,1"
            bitfld.long 0x00 1. "CTL_PVT1_RUN,Primary run control" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_PVT1_CK_EN,Enable PVT analog macro CLK signal" "0,1"
    group.long 0xE8++0x03
        line.long 0x00 "PVT1_CTRL1,PVT 1 Control 1"
            hexmask.long.byte 0x00 20.--27. 1. "CTL_PVT1_PERIOD,The frequency of the CLK driven to PVT monitor is configurable by this field"
            bitfld.long 0x00 12.--16. "CTL_PVT1_TRIMG,ctl_pvt1_trimg" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 6.--11. "CTL_PVT1_TRIMO,ctl_pvt1_trimo" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            bitfld.long 0x00 4.--5. "CTL_PVT1_PSAMPLE,ctl_pvt1_psample" "0,1,2,3"
            newline
            bitfld.long 0x00 3. "CTL_PVT1_VSAMPLE,ctl_pvt1_vsample" "0,1"
            bitfld.long 0x00 0.--2. "CTL_PVT1_ANA_TEST_SEL,ctl_pvt1_ana_test_sel" "0,1,2,3,4,5,6,7"
    group.long 0xEC++0x03
        line.long 0x00 "PVT1_CTRL2,PVT 1 Control 2"
            hexmask.long.byte 0x00 16.--23. 1. "CTL_PVT1_ENA_LOW,Minimum number of clock cycles that ENA must stay low for"
            hexmask.long.byte 0x00 8.--15. 1. "CTL_PVT1_DOUT_PST,ENA signal is lowered back to '0' after this_field number of clk_pvt cycles then when clock counter hits the ENA_FALL field value"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_PVT1_DOUT_PRE,DATA_OUT from the PVT analog macro is sampled by the controller when internal FSM counter hits this_field value"
    group.long 0xF0++0x03
        line.long 0x00 "PVT1_CTRL3,PVT 1 Control 3"
            bitfld.long 0x00 25. "CTL_PVT1_ALARM1_ACC,If set (1) use accumulated value for comparison for alarm 1" "0,1"
            bitfld.long 0x00 24. "CTL_PVT1_ALARM0_ACC,If set (1) use accumulated value for comparison for alarm 0" "0,1"
            newline
            bitfld.long 0x00 16.--21. "CTL_PVT1_ACC_LEN,Number of read's to accumulate over before sending interrupt to user (0-indexed)" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            hexmask.long.byte 0x00 8.--15. 1. "CTL_PVT1_ENA_FALL,ENA signal from controller to PVT analog macro is lowered when the clock counter hits this_field"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_PVT1_ENA_RISE,ENA signal from controller to PVT analog macro is raised high after leaving the ST_ENA_RISE state when the clock counter hits this_field"
    group.long 0xF4++0x03
        line.long 0x00 "PVT1_CTRL4,PVT 1 Control 4"
            hexmask.long.word 0x00 16.--31. 1. "CTL_PVT1_ALARM1_THR,If selected value is greater than this_field then the alarm 1 is asserted"
            hexmask.long.word 0x00 0.--15. 1. "CTL_PVT1_ALARM0_THR,If selected value is greater than this_field then the alarm 0 is asserted"
    group.long 0xF8++0x03
        line.long 0x00 "PVT1_TO_CTRL,PVT 1 Timeout Control"
            hexmask.long.tbyte 0x00 0.--23. 1. "CTL_PVT1_TIMEOUT,Timeout for Controller FSM"

    rgroup.long 0xFC++0x03
        line.long 0x00 "PVT1_TO_STAT,PVT 1 Timeout Status"
            hexmask.long 0x00 0.--31. 1. "STS_PVT1_TIMER_VAL,Timer value of Controller FSM"

    group.long 0x100++0x03
        line.long 0x00 "PVT1_BYP_CTRL,PVT 1 Control 6"
            bitfld.long 0x00 1. "CTL_PVT1_ENA_VAL,Used to drive 'ENA' signal to PVT macro if override is enabled" "0,1"
            bitfld.long 0x00 0. "CTL_PVT1_OVR,If set (1) override of controller's FSM control of 'ENA' signal to PVT macro with 'ena_val' SFR field" "0,1"

    rgroup.long 0x104++0x03
        line.long 0x00 "PVT1_STAT0,PVT 1 Status 0"
            bitfld.long 0x00 16.--21. "STS_PVT1_READ_CNT,Number of readings' that went into 'dout_acc'" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            hexmask.long.word 0x00 0.--9. 1. "STS_PVT1_DOUT_INS,Last valid DATA_OUT output from PVT analog macro"
    rgroup.long 0x108++0x03
        line.long 0x00 "PVT1_STAT1,PVT 1 Status 1"
            hexmask.long.byte 0x00 16.--22. 1. "STS_PVT1_STATE,Internal FSM state used for diagnostic only"
            hexmask.long.word 0x00 0.--15. 1. "STS_PVT1_DOUT_ACC,Accumulated DATA_OUT's over averaging window"
    rgroup.long 0x10C++0x03
        line.long 0x00 "PVT1_STAT2,PVT 1 Status 2"
            bitfld.long 0x00 16. "STS_PVT1_RAW_DVALID,DATA_VALID from PVT macro with no handling of timing" "0,1"
            hexmask.long.word 0x00 0.--9. 1. "STS_PVT1_RAW_DOUT,DATA_OUT from PVT macro with no handling of timing"

    group.long 0x110++0x03
        line.long 0x00 "PVT1_IRQ_CTRL,PVT 1 Interrupt and Alarm Control"
            bitfld.long 0x00 4.--5. "CTL_PVT1_ALARM_ENA,Enable bits for alarm 0 and 1" "0,1,2,3"
            bitfld.long 0x00 3. "CTL_PVT1_SIG_ENA,Enable bits for signaling IRQ source" "0,1"
            newline
            bitfld.long 0x00 0.--2. "CTL_PVT1_ERR_ENA,Enable bits for error IRQ sources" "0,1,2,3,4,5,6,7"
    group.long 0x114++0x03
        line.long 0x00 "PVT1_IRQ_STAT,PVT 1 Interrupt and Alarm Status"
            bitfld.long 0x00 16.--17. "STS_PVT1_ALARM,Bits are sticky write a '1' to individual bits to clear" "0,1,2,3"
            bitfld.long 0x00 8. "STS_PVT1_SIG,Bits are sticky write a '1' to individual bits to clear" "0,1"
            newline
            bitfld.long 0x00 0.--2. "STS_PVT1_ERR,Each bit corresponds to a specific error source" "0,1,2,3,4,5,6,7"
    group.long 0x118++0x03
        line.long 0x00 "MMINTF_SIG_CTRL,MMIC Interface Signalling Control"
            bitfld.long 0x00 12.--13. "CTL_MMINTF_SIG_TYPE_2,Interrupt type for MMIC interface signal source MM_IRQ" "0: Direct from pin,1: Pulse from rising edge of signal source,2: Pulse from falling edge of signal source,3: Sticky interrupt"
            bitfld.long 0x00 10.--11. "CTL_MMINTF_SIG_TYPE_1,Interrupt type for MMIC interface signal source MM_FRAME_SOT" "0: Direct from pin,1: Pulse from rising edge of signal source,2: Pulse from falling edge of signal source,3: Sticky interrupt"
            newline
            bitfld.long 0x00 8.--9. "CTL_MMINTF_SIG_TYPE_0,Interrupt type for MMIC interface signal source MM_ERROR" "0: Direct from pin,1: Pulse from rising edge of signal source,2: Pulse from falling edge of signal source,3: Sticky interrupt"
            bitfld.long 0x00 4.--6. "CTL_MMINTF_SIG_STICKY,Sticky interrupt trigger selection" "0: Rising edge trigger,1: Falling edge trigger,?..."
            newline
            bitfld.long 0x00 0.--2. "CTL_MMINTF_SIG_ENA,Bitwise enable of interrupt source from following MMIC interface signals" "0,1,2,3,4,5,6,7"
    group.long 0x11C++0x03
        line.long 0x00 "MMINTF_SIG_ISTAT,MMIC Interface Interrupt Status"
            bitfld.long 0x00 0.--2. "STS_MMINTF_SIG,Interrupt triggered status from following sources" "0,1,2,3,4,5,6,7"

    rgroup.long 0x120++0x03
        line.long 0x00 "MMINTF_SIG_STAT0,MMIC Interface Status"
            bitfld.long 0x00 0.--2. "STS_MMINTF_CURR,Current value of MMIC interface pins" "0,1,2,3,4,5,6,7"

    group.long 0x124++0x03
        line.long 0x00 "STC_MISC_CTRL0,System Time Counter control 0"
            bitfld.long 0x00 18. "CTL_STC_SNAP_PPS_SEL,If '0' 'CTL_STC_SNAP0_GO' used to take snapshot of PPS counter" "0,1"
            bitfld.long 0x00 17. "CTL_STC_SNAP_PTP_SEL,If '0' 'CTL_STC_SNAP0_GO' used to take snapshot of PTP timestamp from Ethernet" "0,1"
            newline
            bitfld.long 0x00 16. "CTL_STC_SNAPF_POL,If '1' take snapshot of System Time Counter on the falling edge of 'FRAME_SOT_IN'" "0,1"
            bitfld.long 0x00 8.--12. "CTL_STC_TICK,System Time Counter tick value to increment every System clock cycle by" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 0. "CTL_STC_CNT_ENA,Enable System Time Counter" "0,1"
    group.long 0x128++0x03
        line.long 0x00 "STC_WRAP_CTRL0,System Time Counter Wrap Control 0"
            hexmask.long 0x00 0.--31. 1. "CTL_STC_LS_WRAP,Less Significant System Time Counter wrap value"
    group.long 0x12C++0x03
        line.long 0x00 "STC_WRAP_CTRL1,System Time Counter Wrap Control 1"
            hexmask.long 0x00 0.--31. 1. "CTL_STC_MS_WRAP0,Most Significant System Time Counter wrap value bits [31:0]"
    group.long 0x130++0x03
        line.long 0x00 "STC_WRAP_CTRL2,System Time Counter Wrap Control 2"
            hexmask.long.word 0x00 0.--15. 1. "CTL_STC_MS_WRAP1,Most Significant System Time Counter wrap value bits [47:32]"
    group.long 0x134++0x03
        line.long 0x00 "STC_SET_CTRL0,System Time Counter SET Control 0"
            hexmask.long 0x00 0.--31. 1. "CTL_STC_LS_SET,Less Significant System Time Counter SET value"
    group.long 0x138++0x03
        line.long 0x00 "STC_SET_CTRL1,System Time Counter SET Control 1"
            hexmask.long 0x00 0.--31. 1. "CTL_STC_MS_SET0,Most Significant System Time Counter SET value bits [31:0]"
    group.long 0x13C++0x03
        line.long 0x00 "STC_SET_CTRL2,System Time Counter SET Control 2"
            hexmask.long.word 0x00 0.--15. 1. "CTL_STC_MS_SET1,Most Significant System Time Counter SET value bits [47:32]"
    group.long 0x140++0x03
        line.long 0x00 "STC_SET_GO_CTRL,System Time Counter Set Go Control"
            bitfld.long 0x00 0. "CTL_STC_SET_GO,Toggle to '1' to set value of Counters - resynchronized internally" "0,1"
    group.long 0x144++0x03
        line.long 0x00 "STC_ADJ_CTRL0,System Time Counter ADJ Control 0"
            hexmask.long 0x00 0.--31. 1. "CTL_STC_LS_ADJ,Less Significant System Time Counter ADJ value in signed 2's complement"
    group.long 0x148++0x03
        line.long 0x00 "STC_ADJ_CTRL1,System Time Counter ADJ Control 1"
            hexmask.long.word 0x00 0.--15. 1. "CTL_STC_MS_ADJ,Most Significant System Time Counter ADJ value in signed 2's complement"
    group.long 0x14C++0x03
        line.long 0x00 "STC_ADJ_GO_CTRL,System Time Counter ADJ Go Control"
            bitfld.long 0x00 0. "CTL_STC_ADJ_GO,Toggle to '1' to apply ajdustment value to Counters - resynchronized internally" "0,1"
    group.long 0x150++0x03
        line.long 0x00 "STC_SNAP0_CTRL,System Time Counter Snap 0 Control"
            bitfld.long 0x00 10.--11. "CTL_STC_SNAP0_HW_SEL,Select which HW trigger to enable for snapshot" "0: MIPI chirp end,1: MIPI frame end,2: MIPI chirp start,3: MIPI frame start"
            bitfld.long 0x00 8. "CTL_STC_SNAP0_HW_ENA,If '1' enable snapshot 0 to be taken by HW trigger source" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_STC_SNAP0_GO,Toggle to '1' to update snapshot 0 of sys time counters" "0,1"

    rgroup.long 0x154++0x03
        line.long 0x00 "STC_SNAP0_STAT0,System Time Counter SNAP0 Status 0"
            hexmask.long 0x00 0.--31. 1. "STS_STC_SNAP0_CNT0,Less Significant System Time Counter SNAP value"
    rgroup.long 0x158++0x03
        line.long 0x00 "STC_SNAP0_STAT1,System Time Counter SNAP0 Status 1"
            hexmask.long 0x00 0.--31. 1. "STS_STC_SNAP0_CNT1,Most Significant System Time Counter SNAP value"
    rgroup.long 0x15C++0x03
        line.long 0x00 "STC_SNAP0_STAT2,System Time Counter SNAP0 Status 1"
            hexmask.long.word 0x00 0.--15. 1. "STS_STC_SNAP0_CNT2,Most Significant System Time Counter SNAP value"

    group.long 0x160++0x03
        line.long 0x00 "STC_SNAP1_CTRL,System Time Counter Snap 1 Control"
            bitfld.long 0x00 10.--11. "CTL_STC_SNAP1_HW_SEL,Select which HW trigger to enable for snapshot" "0: MIPI chirp end,1: MIPI frame end,2: MIPI chirp start,3: MIPI frame start"
            bitfld.long 0x00 8. "CTL_STC_SNAP1_HW_ENA,If '1' enable snapshot 0 to be taken by HW trigger source" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_STC_SNAP1_GO,Toggle to '1' to update snapshot 1 of sys time counters" "0,1"

    rgroup.long 0x164++0x03
        line.long 0x00 "STC_SNAP1_STAT0,System Time Counter SNAP1 Status 0"
            hexmask.long 0x00 0.--31. 1. "STS_STC_SNAP1_CNT0,Less Significant System Time Counter SNAP value"
    rgroup.long 0x168++0x03
        line.long 0x00 "STC_SNAP1_STAT1,System Time Counter SNAP1 Status 1"
            hexmask.long 0x00 0.--31. 1. "STS_STC_SNAP1_CNT1,Most Significant System Time Counter SNAP value"
    rgroup.long 0x16C++0x03
        line.long 0x00 "STC_SNAP1_STAT2,System Time Counter SNAP1 Status 1"
            hexmask.long.word 0x00 0.--15. 1. "STS_STC_SNAP1_CNT2,Most Significant System Time Counter SNAP value"
    rgroup.long 0x170++0x03
        line.long 0x00 "STC_SNAPF_STAT0,System Time Counter SNAPF Status 0"
            hexmask.long 0x00 0.--31. 1. "STS_STC_SNAPF_CNT0,Less Significant System Time Counter SNAP value"
    rgroup.long 0x174++0x03
        line.long 0x00 "STC_SNAPF_STAT1,System Time Counter SNAPF Status 1"
            hexmask.long 0x00 0.--31. 1. "STS_STC_SNAPF_CNT1,Most Significant System Time Counter SNAP value"
    rgroup.long 0x178++0x03
        line.long 0x00 "STC_SNAPF_STAT2,System Time Counter SNAPF Status 1"
            hexmask.long.word 0x00 0.--15. 1. "STS_STC_SNAPF_CNT2,Most Significant System Time Counter SNAP value"
    rgroup.long 0x17C++0x03
        line.long 0x00 "STC_SNAP_PTP_STAT0,System Time Counter SNAP PTP Status 0"
            hexmask.long 0x00 0.--31. 1. "STS_STC_SNAP_PTP0,Snapshot of PTP timestamp"
    rgroup.long 0x180++0x03
        line.long 0x00 "STC_SNAP_PTP_STAT1,System Time Counter SNAP PTP Status 1"
            hexmask.long 0x00 0.--31. 1. "STS_STC_SNAP_PTP1,Snapshot of PTP timestamp"
    rgroup.long 0x184++0x03
        line.long 0x00 "STC_SNAP_PTP_STAT2,System Time Counter SNAP PTP Status 2"
            hexmask.long.word 0x00 0.--15. 1. "STS_STC_SNAP_PTP2,Snapshot of PTP timestamp"

    group.long 0x188++0x03
        line.long 0x00 "STC_ALARM0_MISC_CTRL,System Time Counter ALARM0 Top Control"
            bitfld.long 0x00 1. "CTL_STC_ALARM0_TYPE,Select between 'irq_stc_alarm0' being" "0: pulse(synchronous to,1: sticky or"
            bitfld.long 0x00 0. "CTL_STC_ALARM0_ENA,Set to '1' to enable ALARM0 interrupt" "0,1"
    group.long 0x18C++0x03
        line.long 0x00 "STC_ALARM0_VAL_CTRL0,System Time Counter ALARM0 Value Control 0"
            hexmask.long 0x00 0.--31. 1. "CTL_STC_ALARM0_VAL0,System Time Counter ALARM0 value to apply"
    group.long 0x190++0x03
        line.long 0x00 "STC_ALARM0_VAL_CTRL1,System Time Counter ALARM0 Value Control 1"
            hexmask.long 0x00 0.--31. 1. "CTL_STC_ALARM0_VAL1,System Time Counter ALARM0 value to apply"
    group.long 0x194++0x03
        line.long 0x00 "STC_ALARM0_VAL_CTRL2,System Time Counter ALARM0 Value Control 2"
            hexmask.long.word 0x00 0.--15. 1. "CTL_STC_ALARM0_VAL2,System Time Counter ALARM0 value to apply"
    group.long 0x198++0x03
        line.long 0x00 "STC_ALARM0_GO_CTRL,System Time Counter ALARM0 Go Control"
            bitfld.long 0x00 8. "CTL_STC_FSTRT0_GO,Toggle to '1' to use ALARM0 value for the Frame Start value" "0,1"
            bitfld.long 0x00 0. "CTL_STC_ALARM0_GO,Toggle to '1' to set ALARM0 value" "0,1"

    rgroup.long 0x19C++0x03
        line.long 0x00 "STC_ALARM0_VAL_STAT0,System Time Counter ALARM0 Value Status 0"
            hexmask.long 0x00 0.--31. 1. "STS_STC_ALARM0_VAL0,System Time Counter ALARM0 value that has been applied"
    rgroup.long 0x1A0++0x03
        line.long 0x00 "STC_ALARM0_VAL_STAT1,System Time Counter ALARM0 Value Status 1"
            hexmask.long 0x00 0.--31. 1. "STS_STC_ALARM0_VAL1,System Time Counter ALARM0 value that has been applied"
    rgroup.long 0x1A4++0x03
        line.long 0x00 "STC_ALARM0_VAL_STAT2,System Time Counter ALARM0 Value Status 2"
            hexmask.long.word 0x00 0.--15. 1. "STS_STC_ALARM0_VAL2,System Time Counter ALARM0 value that has been applied"

    group.long 0x1A8++0x03
        line.long 0x00 "STC_ALARM0_IRQ_STAT,System Time Counter ALARM0 Interrupt status"
            bitfld.long 0x00 0. "STS_STC_ALARM0,System Time Counter ALARM0 Interrupt" "0,1"
    group.long 0x1AC++0x03
        line.long 0x00 "STC_ALARM1_MISC_CTRL,System Time Counter ALARM1 Top Control"
            bitfld.long 0x00 1. "CTL_STC_ALARM1_TYPE,Select between 'irq_stc_ALARM1' being" "0: pulse(synchronous to,1: sticky or"
            bitfld.long 0x00 0. "CTL_STC_ALARM1_ENA,Set to '1' to enable ALARM1 interrupt" "0,1"
    group.long 0x1B0++0x03
        line.long 0x00 "STC_ALARM1_VAL_CTRL0,System Time Counter ALARM1 Value Control 0"
            hexmask.long 0x00 0.--31. 1. "CTL_STC_ALARM1_VAL0,System Time Counter ALARM1 value to apply"
    group.long 0x1B4++0x03
        line.long 0x00 "STC_ALARM1_VAL_CTRL1,System Time Counter ALARM1 Value Control 1"
            hexmask.long 0x00 0.--31. 1. "CTL_STC_ALARM1_VAL1,System Time Counter ALARM1 value to apply"
    group.long 0x1B8++0x03
        line.long 0x00 "STC_ALARM1_VAL_CTRL2,System Time Counter ALARM1 Value Control 2"
            hexmask.long.word 0x00 0.--15. 1. "CTL_STC_ALARM1_VAL2,System Time Counter ALARM1 value to apply"
    group.long 0x1BC++0x03
        line.long 0x00 "STC_ALARM1_GO_CTRL,System Time Counter ALARM1 Go Control"
            bitfld.long 0x00 8. "CTL_STC_FSTRT1_GO,Toggle to '1' to use ALARM1 value for the Frame Start value" "0,1"
            bitfld.long 0x00 0. "CTL_STC_ALARM1_GO,Toggle to '1' to set ALARM1 value" "0,1"

    rgroup.long 0x1C0++0x03
        line.long 0x00 "STC_ALARM1_VAL_STAT0,System Time Counter ALARM1 Value Status 0"
            hexmask.long 0x00 0.--31. 1. "STS_STC_ALARM1_VAL0,System Time Counter ALARM1 value that has been applied"
    rgroup.long 0x1C4++0x03
        line.long 0x00 "STC_ALARM1_VAL_STAT1,System Time Counter ALARM1 Value Status 1"
            hexmask.long 0x00 0.--31. 1. "STS_STC_ALARM1_VAL1,System Time Counter ALARM1 value that has been applied"
    rgroup.long 0x1C8++0x03
        line.long 0x00 "STC_ALARM1_VAL_STAT2,System Time Counter ALARM1 Value Status 2"
            hexmask.long.word 0x00 0.--15. 1. "STS_STC_ALARM1_VAL2,System Time Counter ALARM1 value that has been applied"

    group.long 0x1CC++0x03
        line.long 0x00 "STC_ALARM1_IRQ_STAT,System Time Counter ALARM1 Interrupt status"
            bitfld.long 0x00 0. "STS_STC_ALARM1,System Time Counter ALARM1 Interrupt" "0,1"

    rgroup.long 0x1D0++0x03
        line.long 0x00 "FRAME_START_VAL_STAT0,Frame Start Value Status 0"
            hexmask.long 0x00 0.--31. 1. "STS_STC_FSTRT_VAL0,System Time Counter Frame Start value that has been applied"
    rgroup.long 0x1D4++0x03
        line.long 0x00 "FRAME_START_VAL_STAT1,Frame Start Value Status 1"
            hexmask.long 0x00 0.--31. 1. "STS_STC_FSTRT_VAL1,System Time Counter Frame Start value that has been applied"
    rgroup.long 0x1D8++0x03
        line.long 0x00 "FRAME_START_VAL_STAT2,Frame Start Value Status 2"
            hexmask.long.word 0x00 0.--15. 1. "STS_STC_FSTRT_VAL2,System Time Counter Frame Start value that has been applied"

    group.long 0x1DC++0x03
        line.long 0x00 "FRAME_START_CTRL0,MM_FRAME_START Control 0"
            hexmask.long.word 0x00 16.--31. 1. "CTL_MMINTF_FS_DUR,FRAME_START pulse duration in 2ns steps"
            bitfld.long 0x00 4. "CTL_MMINTF_FSTRT_SW,Toggle '1' to explicitly start a FRAME_START pulse" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_STC_FSTRT_ENA,Enable launching of a FRAME_START pulse based on System Time Counter" "0,1"

    rgroup.long 0x1E0++0x03
        line.long 0x00 "FRAME_START_TIMER_STAT0,Frame Start Timer Status"
            hexmask.long.word 0x00 0.--15. 1. "STS_MMINTF_FS_TIMER,Current FRAME START timer"

    group.long 0x1E4++0x03
        line.long 0x00 "PMIC_FAULTB_CTRL,PMIC_FAULTB Control"
            bitfld.long 0x00 1. "CTL_PMIC_ALARM_ENA,Enable IRQ based on selected edge of PMIC_FAULTB" "0,1"
            bitfld.long 0x00 0. "CTL_PMIC_ALARM_SEL,Select which edge of PMIC_FAULTB should trigger an IRQ" "0: Rising,1: Falling"

    rgroup.long 0x1E8++0x03
        line.long 0x00 "PMIC_FAULTB_STAT,PMIC_FAULTB Status"
            bitfld.long 0x00 0. "STS_PMIC_FAULTB,Current PMIC_FAULTB value after resynchronization" "0,1"

    group.long 0x1EC++0x03
        line.long 0x00 "PMIC_FAULTB_ALARM,PMIC_FAULTB Alarm"
            bitfld.long 0x00 0. "STS_PMIC_ALARM,PMIC_FAULTB Interrupt" "0,1"
    group.long 0x1F0++0x03
        line.long 0x00 "MISC_CTRL,Miscellaneous Control"
            bitfld.long 0x00 5. "RA_CQ_HOLD_CTI_ENA,Enable RA Command Queue Hold on Top CTI event" "0,1"
            bitfld.long 0x00 4. "RA_CQ_HOLD_DSP_XOCD_ENA,Enable RA Command Queue Hold on DSP (BBE32) entering debug mode" "0,1"
            newline
            bitfld.long 0x00 0.--2. "CTL_TOP_NOC_EXTREF_SEL,Select prescaler for Top NoC's timeout counter" "0: sys clock divide-by-4,1: sys clock divide-by-8,2: sys clock divide-by-16,3: sys clock divide-by-32,4: sys clock divide-by-64,5: sys clock divide-by-128,6: sys clock divide-by-256,7: sys clock divide-by-512"
    group.long 0x1F4++0x03
        line.long 0x00 "SERDES_MISC_CTRL,SERDES Diagnostic Control"
            bitfld.long 0x00 17. "CTL_SRDS_DTEST_IN1,DTEST_IN1 diagnostic input of PMATS" "0,1"
            bitfld.long 0x00 16. "CTL_SRDS_DTEST_IN0,DTEST_IN0 diagnostic input of PMATS" "0,1"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "CTL_SRDS_BYPASS_VALUEB,BYPASS_VALUEB diagnostic input of PMATS"
            hexmask.long.byte 0x00 0.--7. 1. "CTL_SRDS_BYPASS_VALUEA,BYPASS_VALUEA diagnostic input of PMATS"

    rgroup.long 0x1F8++0x03
        line.long 0x00 "SERDES_MISC_STAT,SERDES Diagnostic Status"
            bitfld.long 0x00 12.--13. "STS_SRDS_SETA,SERDES macro JTAG_SETA output" "0,1,2,3"
            bitfld.long 0x00 10.--11. "STS_SRDS_OUT_LATCHEDA,SERDES macro JTAG_OUT_LATCHEDA output" "0,1,2,3"
            newline
            bitfld.long 0x00 8.--9. "STS_SRDS_CLEARA,SERDES macro JTAG_CLEARA output" "0,1,2,3"
            bitfld.long 0x00 1. "STS_SRDS_RXPLL_LOCK,SERDES Rx lane CDR lock" "0,1"
            newline
            bitfld.long 0x00 0. "STS_SRDS_RXPLL_FLOCK,SERDES Rx lane Frequency lock" "0,1"
    rgroup.long 0x200++0x03
        line.long 0x00 "MUTEX_0_STAT,Mutex 0 status"
            bitfld.long 0x00 0.--3. "MUTEX_0_STAT,Read from this field to check that state of mutex 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x204++0x03
        line.long 0x00 "MUTEX_0_PID01,Mutex 0 for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID01,Read from this field to request lock of mutex 0 from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x208++0x03
        line.long 0x00 "MUTEX_0_PID02,Mutex 0 for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID02,Read from this field to request lock of mutex 0 from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x20C++0x03
        line.long 0x00 "MUTEX_0_PID03,Mutex 0 for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID03,Read from this field to request lock of mutex 0 from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x210++0x03
        line.long 0x00 "MUTEX_0_PID04,Mutex 0 for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID04,Read from this field to request lock of mutex 0 from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x214++0x03
        line.long 0x00 "MUTEX_0_PID05,Mutex 0 for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID05,Read from this field to request lock of mutex 0 from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x218++0x03
        line.long 0x00 "MUTEX_0_PID06,Mutex 0 for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID06,Read from this field to request lock of mutex 0 from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x21C++0x03
        line.long 0x00 "MUTEX_0_PID07,Mutex 0 for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID07,Read from this field to request lock of mutex 0 from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x220++0x03
        line.long 0x00 "MUTEX_0_PID08,Mutex 0 for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID08,Read from this field to request lock of mutex 0 from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x224++0x03
        line.long 0x00 "MUTEX_0_PID09,Mutex 0 for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID09,Read from this field to request lock of mutex 0 from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x228++0x03
        line.long 0x00 "MUTEX_0_PID10,Mutex 0 for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID10,Read from this field to request lock of mutex 0 from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x22C++0x03
        line.long 0x00 "MUTEX_0_PID11,Mutex 0 for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID11,Read from this field to request lock of mutex 0 from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x230++0x03
        line.long 0x00 "MUTEX_0_PID12,Mutex 0 for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID12,Read from this field to request lock of mutex 0 from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x234++0x03
        line.long 0x00 "MUTEX_0_PID13,Mutex 0 for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID13,Read from this field to request lock of mutex 0 from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x238++0x03
        line.long 0x00 "MUTEX_0_PID14,Mutex 0 for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID14,Read from this field to request lock of mutex 0 from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x23C++0x03
        line.long 0x00 "MUTEX_0_PID15,Mutex 0 for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_0_PID15,Read from this field to request lock of mutex 0 from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x240++0x03
        line.long 0x00 "MUTEX_1_STAT,Mutex 1 status"
            bitfld.long 0x00 0.--3. "MUTEX_1_STAT,Read from this field to check that state of mutex 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x244++0x03
        line.long 0x00 "MUTEX_1_PID01,Mutex 1 for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID01,Read from this field to request lock of mutex 1 from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x248++0x03
        line.long 0x00 "MUTEX_1_PID02,Mutex 1 for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID02,Read from this field to request lock of mutex 1 from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x24C++0x03
        line.long 0x00 "MUTEX_1_PID03,Mutex 1 for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID03,Read from this field to request lock of mutex 1 from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x250++0x03
        line.long 0x00 "MUTEX_1_PID04,Mutex 1 for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID04,Read from this field to request lock of mutex 1 from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x254++0x03
        line.long 0x00 "MUTEX_1_PID05,Mutex 1 for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID05,Read from this field to request lock of mutex 1 from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x258++0x03
        line.long 0x00 "MUTEX_1_PID06,Mutex 1 for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID06,Read from this field to request lock of mutex 1 from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x25C++0x03
        line.long 0x00 "MUTEX_1_PID07,Mutex 1 for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID07,Read from this field to request lock of mutex 1 from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x260++0x03
        line.long 0x00 "MUTEX_1_PID08,Mutex 1 for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID08,Read from this field to request lock of mutex 1 from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x264++0x03
        line.long 0x00 "MUTEX_1_PID09,Mutex 1 for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID09,Read from this field to request lock of mutex 1 from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x268++0x03
        line.long 0x00 "MUTEX_1_PID10,Mutex 1 for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID10,Read from this field to request lock of mutex 1 from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x26C++0x03
        line.long 0x00 "MUTEX_1_PID11,Mutex 1 for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID11,Read from this field to request lock of mutex 1 from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x270++0x03
        line.long 0x00 "MUTEX_1_PID12,Mutex 1 for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID12,Read from this field to request lock of mutex 1 from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x274++0x03
        line.long 0x00 "MUTEX_1_PID13,Mutex 1 for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID13,Read from this field to request lock of mutex 1 from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x278++0x03
        line.long 0x00 "MUTEX_1_PID14,Mutex 1 for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID14,Read from this field to request lock of mutex 1 from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x27C++0x03
        line.long 0x00 "MUTEX_1_PID15,Mutex 1 for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_1_PID15,Read from this field to request lock of mutex 1 from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x280++0x03
        line.long 0x00 "MUTEX_2_STAT,Mutex 2 status"
            bitfld.long 0x00 0.--3. "MUTEX_2_STAT,Read from this field to check that state of mutex 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x284++0x03
        line.long 0x00 "MUTEX_2_PID01,Mutex 2 for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID01,Read from this field to request lock of mutex 2 from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x288++0x03
        line.long 0x00 "MUTEX_2_PID02,Mutex 2 for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID02,Read from this field to request lock of mutex 2 from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x28C++0x03
        line.long 0x00 "MUTEX_2_PID03,Mutex 2 for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID03,Read from this field to request lock of mutex 2 from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x290++0x03
        line.long 0x00 "MUTEX_2_PID04,Mutex 2 for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID04,Read from this field to request lock of mutex 2 from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x294++0x03
        line.long 0x00 "MUTEX_2_PID05,Mutex 2 for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID05,Read from this field to request lock of mutex 2 from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x298++0x03
        line.long 0x00 "MUTEX_2_PID06,Mutex 2 for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID06,Read from this field to request lock of mutex 2 from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x29C++0x03
        line.long 0x00 "MUTEX_2_PID07,Mutex 2 for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID07,Read from this field to request lock of mutex 2 from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2A0++0x03
        line.long 0x00 "MUTEX_2_PID08,Mutex 2 for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID08,Read from this field to request lock of mutex 2 from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2A4++0x03
        line.long 0x00 "MUTEX_2_PID09,Mutex 2 for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID09,Read from this field to request lock of mutex 2 from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2A8++0x03
        line.long 0x00 "MUTEX_2_PID10,Mutex 2 for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID10,Read from this field to request lock of mutex 2 from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2AC++0x03
        line.long 0x00 "MUTEX_2_PID11,Mutex 2 for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID11,Read from this field to request lock of mutex 2 from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2B0++0x03
        line.long 0x00 "MUTEX_2_PID12,Mutex 2 for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID12,Read from this field to request lock of mutex 2 from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2B4++0x03
        line.long 0x00 "MUTEX_2_PID13,Mutex 2 for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID13,Read from this field to request lock of mutex 2 from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2B8++0x03
        line.long 0x00 "MUTEX_2_PID14,Mutex 2 for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID14,Read from this field to request lock of mutex 2 from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2BC++0x03
        line.long 0x00 "MUTEX_2_PID15,Mutex 2 for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_2_PID15,Read from this field to request lock of mutex 2 from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x2C0++0x03
        line.long 0x00 "MUTEX_3_STAT,Mutex 3 status"
            bitfld.long 0x00 0.--3. "MUTEX_3_STAT,Read from this field to check that state of mutex 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x2C4++0x03
        line.long 0x00 "MUTEX_3_PID01,Mutex 3 for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID01,Read from this field to request lock of mutex 3 from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2C8++0x03
        line.long 0x00 "MUTEX_3_PID02,Mutex 3 for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID02,Read from this field to request lock of mutex 3 from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2CC++0x03
        line.long 0x00 "MUTEX_3_PID03,Mutex 3 for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID03,Read from this field to request lock of mutex 3 from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2D0++0x03
        line.long 0x00 "MUTEX_3_PID04,Mutex 3 for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID04,Read from this field to request lock of mutex 3 from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2D4++0x03
        line.long 0x00 "MUTEX_3_PID05,Mutex 3 for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID05,Read from this field to request lock of mutex 3 from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2D8++0x03
        line.long 0x00 "MUTEX_3_PID06,Mutex 3 for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID06,Read from this field to request lock of mutex 3 from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2DC++0x03
        line.long 0x00 "MUTEX_3_PID07,Mutex 3 for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID07,Read from this field to request lock of mutex 3 from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2E0++0x03
        line.long 0x00 "MUTEX_3_PID08,Mutex 3 for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID08,Read from this field to request lock of mutex 3 from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2E4++0x03
        line.long 0x00 "MUTEX_3_PID09,Mutex 3 for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID09,Read from this field to request lock of mutex 3 from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2E8++0x03
        line.long 0x00 "MUTEX_3_PID10,Mutex 3 for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID10,Read from this field to request lock of mutex 3 from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2EC++0x03
        line.long 0x00 "MUTEX_3_PID11,Mutex 3 for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID11,Read from this field to request lock of mutex 3 from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2F0++0x03
        line.long 0x00 "MUTEX_3_PID12,Mutex 3 for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID12,Read from this field to request lock of mutex 3 from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2F4++0x03
        line.long 0x00 "MUTEX_3_PID13,Mutex 3 for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID13,Read from this field to request lock of mutex 3 from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2F8++0x03
        line.long 0x00 "MUTEX_3_PID14,Mutex 3 for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID14,Read from this field to request lock of mutex 3 from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x2FC++0x03
        line.long 0x00 "MUTEX_3_PID15,Mutex 3 for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_3_PID15,Read from this field to request lock of mutex 3 from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x300++0x03
        line.long 0x00 "MUTEX_4_STAT,Mutex 4 status"
            bitfld.long 0x00 0.--3. "MUTEX_4_STAT,Read from this field to check that state of mutex 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x304++0x03
        line.long 0x00 "MUTEX_4_PID01,Mutex 4 for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID01,Read from this field to request lock of mutex 4 from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x308++0x03
        line.long 0x00 "MUTEX_4_PID02,Mutex 4 for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID02,Read from this field to request lock of mutex 4 from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x30C++0x03
        line.long 0x00 "MUTEX_4_PID03,Mutex 4 for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID03,Read from this field to request lock of mutex 4 from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x310++0x03
        line.long 0x00 "MUTEX_4_PID04,Mutex 4 for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID04,Read from this field to request lock of mutex 4 from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x314++0x03
        line.long 0x00 "MUTEX_4_PID05,Mutex 4 for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID05,Read from this field to request lock of mutex 4 from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x318++0x03
        line.long 0x00 "MUTEX_4_PID06,Mutex 4 for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID06,Read from this field to request lock of mutex 4 from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x31C++0x03
        line.long 0x00 "MUTEX_4_PID07,Mutex 4 for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID07,Read from this field to request lock of mutex 4 from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x320++0x03
        line.long 0x00 "MUTEX_4_PID08,Mutex 4 for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID08,Read from this field to request lock of mutex 4 from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x324++0x03
        line.long 0x00 "MUTEX_4_PID09,Mutex 4 for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID09,Read from this field to request lock of mutex 4 from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x328++0x03
        line.long 0x00 "MUTEX_4_PID10,Mutex 4 for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID10,Read from this field to request lock of mutex 4 from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x32C++0x03
        line.long 0x00 "MUTEX_4_PID11,Mutex 4 for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID11,Read from this field to request lock of mutex 4 from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x330++0x03
        line.long 0x00 "MUTEX_4_PID12,Mutex 4 for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID12,Read from this field to request lock of mutex 4 from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x334++0x03
        line.long 0x00 "MUTEX_4_PID13,Mutex 4 for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID13,Read from this field to request lock of mutex 4 from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x338++0x03
        line.long 0x00 "MUTEX_4_PID14,Mutex 4 for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID14,Read from this field to request lock of mutex 4 from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x33C++0x03
        line.long 0x00 "MUTEX_4_PID15,Mutex 4 for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_4_PID15,Read from this field to request lock of mutex 4 from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x340++0x03
        line.long 0x00 "MUTEX_5_STAT,Mutex 5 status"
            bitfld.long 0x00 0.--3. "MUTEX_5_STAT,Read from this field to check that state of mutex 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x344++0x03
        line.long 0x00 "MUTEX_5_PID01,Mutex 5 for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID01,Read from this field to request lock of mutex 5 from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x348++0x03
        line.long 0x00 "MUTEX_5_PID02,Mutex 5 for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID02,Read from this field to request lock of mutex 5 from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x34C++0x03
        line.long 0x00 "MUTEX_5_PID03,Mutex 5 for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID03,Read from this field to request lock of mutex 5 from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x350++0x03
        line.long 0x00 "MUTEX_5_PID04,Mutex 5 for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID04,Read from this field to request lock of mutex 5 from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x354++0x03
        line.long 0x00 "MUTEX_5_PID05,Mutex 5 for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID05,Read from this field to request lock of mutex 5 from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x358++0x03
        line.long 0x00 "MUTEX_5_PID06,Mutex 5 for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID06,Read from this field to request lock of mutex 5 from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x35C++0x03
        line.long 0x00 "MUTEX_5_PID07,Mutex 5 for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID07,Read from this field to request lock of mutex 5 from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x360++0x03
        line.long 0x00 "MUTEX_5_PID08,Mutex 5 for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID08,Read from this field to request lock of mutex 5 from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x364++0x03
        line.long 0x00 "MUTEX_5_PID09,Mutex 5 for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID09,Read from this field to request lock of mutex 5 from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x368++0x03
        line.long 0x00 "MUTEX_5_PID10,Mutex 5 for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID10,Read from this field to request lock of mutex 5 from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x36C++0x03
        line.long 0x00 "MUTEX_5_PID11,Mutex 5 for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID11,Read from this field to request lock of mutex 5 from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x370++0x03
        line.long 0x00 "MUTEX_5_PID12,Mutex 5 for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID12,Read from this field to request lock of mutex 5 from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x374++0x03
        line.long 0x00 "MUTEX_5_PID13,Mutex 5 for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID13,Read from this field to request lock of mutex 5 from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x378++0x03
        line.long 0x00 "MUTEX_5_PID14,Mutex 5 for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID14,Read from this field to request lock of mutex 5 from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x37C++0x03
        line.long 0x00 "MUTEX_5_PID15,Mutex 5 for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_5_PID15,Read from this field to request lock of mutex 5 from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x380++0x03
        line.long 0x00 "MUTEX_6_STAT,Mutex 6 status"
            bitfld.long 0x00 0.--3. "MUTEX_6_STAT,Read from this field to check that state of mutex 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x384++0x03
        line.long 0x00 "MUTEX_6_PID01,Mutex 6 for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID01,Read from this field to request lock of mutex 6 from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x388++0x03
        line.long 0x00 "MUTEX_6_PID02,Mutex 6 for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID02,Read from this field to request lock of mutex 6 from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x38C++0x03
        line.long 0x00 "MUTEX_6_PID03,Mutex 6 for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID03,Read from this field to request lock of mutex 6 from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x390++0x03
        line.long 0x00 "MUTEX_6_PID04,Mutex 6 for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID04,Read from this field to request lock of mutex 6 from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x394++0x03
        line.long 0x00 "MUTEX_6_PID05,Mutex 6 for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID05,Read from this field to request lock of mutex 6 from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x398++0x03
        line.long 0x00 "MUTEX_6_PID06,Mutex 6 for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID06,Read from this field to request lock of mutex 6 from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x39C++0x03
        line.long 0x00 "MUTEX_6_PID07,Mutex 6 for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID07,Read from this field to request lock of mutex 6 from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3A0++0x03
        line.long 0x00 "MUTEX_6_PID08,Mutex 6 for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID08,Read from this field to request lock of mutex 6 from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3A4++0x03
        line.long 0x00 "MUTEX_6_PID09,Mutex 6 for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID09,Read from this field to request lock of mutex 6 from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3A8++0x03
        line.long 0x00 "MUTEX_6_PID10,Mutex 6 for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID10,Read from this field to request lock of mutex 6 from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3AC++0x03
        line.long 0x00 "MUTEX_6_PID11,Mutex 6 for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID11,Read from this field to request lock of mutex 6 from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3B0++0x03
        line.long 0x00 "MUTEX_6_PID12,Mutex 6 for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID12,Read from this field to request lock of mutex 6 from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3B4++0x03
        line.long 0x00 "MUTEX_6_PID13,Mutex 6 for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID13,Read from this field to request lock of mutex 6 from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3B8++0x03
        line.long 0x00 "MUTEX_6_PID14,Mutex 6 for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID14,Read from this field to request lock of mutex 6 from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3BC++0x03
        line.long 0x00 "MUTEX_6_PID15,Mutex 6 for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_6_PID15,Read from this field to request lock of mutex 6 from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x3C0++0x03
        line.long 0x00 "MUTEX_7_STAT,Mutex 7 status"
            bitfld.long 0x00 0.--3. "MUTEX_7_STAT,Read from this field to check that state of mutex 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x3C4++0x03
        line.long 0x00 "MUTEX_7_PID01,Mutex 7 for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID01,Read from this field to request lock of mutex 7 from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3C8++0x03
        line.long 0x00 "MUTEX_7_PID02,Mutex 7 for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID02,Read from this field to request lock of mutex 7 from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3CC++0x03
        line.long 0x00 "MUTEX_7_PID03,Mutex 7 for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID03,Read from this field to request lock of mutex 7 from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3D0++0x03
        line.long 0x00 "MUTEX_7_PID04,Mutex 7 for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID04,Read from this field to request lock of mutex 7 from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3D4++0x03
        line.long 0x00 "MUTEX_7_PID05,Mutex 7 for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID05,Read from this field to request lock of mutex 7 from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3D8++0x03
        line.long 0x00 "MUTEX_7_PID06,Mutex 7 for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID06,Read from this field to request lock of mutex 7 from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3DC++0x03
        line.long 0x00 "MUTEX_7_PID07,Mutex 7 for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID07,Read from this field to request lock of mutex 7 from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3E0++0x03
        line.long 0x00 "MUTEX_7_PID08,Mutex 7 for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID08,Read from this field to request lock of mutex 7 from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3E4++0x03
        line.long 0x00 "MUTEX_7_PID09,Mutex 7 for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID09,Read from this field to request lock of mutex 7 from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3E8++0x03
        line.long 0x00 "MUTEX_7_PID10,Mutex 7 for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID10,Read from this field to request lock of mutex 7 from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3EC++0x03
        line.long 0x00 "MUTEX_7_PID11,Mutex 7 for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID11,Read from this field to request lock of mutex 7 from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3F0++0x03
        line.long 0x00 "MUTEX_7_PID12,Mutex 7 for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID12,Read from this field to request lock of mutex 7 from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3F4++0x03
        line.long 0x00 "MUTEX_7_PID13,Mutex 7 for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID13,Read from this field to request lock of mutex 7 from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3F8++0x03
        line.long 0x00 "MUTEX_7_PID14,Mutex 7 for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID14,Read from this field to request lock of mutex 7 from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x3FC++0x03
        line.long 0x00 "MUTEX_7_PID15,Mutex 7 for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_7_PID15,Read from this field to request lock of mutex 7 from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x400++0x03
        line.long 0x00 "MUTEX_8_STAT,Mutex 8 status"
            bitfld.long 0x00 0.--3. "MUTEX_8_STAT,Read from this field to check that state of mutex 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x404++0x03
        line.long 0x00 "MUTEX_8_PID01,Mutex 8 for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID01,Read from this field to request lock of mutex 8 from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x408++0x03
        line.long 0x00 "MUTEX_8_PID02,Mutex 8 for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID02,Read from this field to request lock of mutex 8 from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x40C++0x03
        line.long 0x00 "MUTEX_8_PID03,Mutex 8 for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID03,Read from this field to request lock of mutex 8 from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x410++0x03
        line.long 0x00 "MUTEX_8_PID04,Mutex 8 for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID04,Read from this field to request lock of mutex 8 from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x414++0x03
        line.long 0x00 "MUTEX_8_PID05,Mutex 8 for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID05,Read from this field to request lock of mutex 8 from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x418++0x03
        line.long 0x00 "MUTEX_8_PID06,Mutex 8 for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID06,Read from this field to request lock of mutex 8 from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x41C++0x03
        line.long 0x00 "MUTEX_8_PID07,Mutex 8 for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID07,Read from this field to request lock of mutex 8 from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x420++0x03
        line.long 0x00 "MUTEX_8_PID08,Mutex 8 for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID08,Read from this field to request lock of mutex 8 from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x424++0x03
        line.long 0x00 "MUTEX_8_PID09,Mutex 8 for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID09,Read from this field to request lock of mutex 8 from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x428++0x03
        line.long 0x00 "MUTEX_8_PID10,Mutex 8 for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID10,Read from this field to request lock of mutex 8 from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x42C++0x03
        line.long 0x00 "MUTEX_8_PID11,Mutex 8 for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID11,Read from this field to request lock of mutex 8 from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x430++0x03
        line.long 0x00 "MUTEX_8_PID12,Mutex 8 for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID12,Read from this field to request lock of mutex 8 from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x434++0x03
        line.long 0x00 "MUTEX_8_PID13,Mutex 8 for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID13,Read from this field to request lock of mutex 8 from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x438++0x03
        line.long 0x00 "MUTEX_8_PID14,Mutex 8 for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID14,Read from this field to request lock of mutex 8 from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x43C++0x03
        line.long 0x00 "MUTEX_8_PID15,Mutex 8 for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_8_PID15,Read from this field to request lock of mutex 8 from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x440++0x03
        line.long 0x00 "MUTEX_9_STAT,Mutex 9 status"
            bitfld.long 0x00 0.--3. "MUTEX_9_STAT,Read from this field to check that state of mutex 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x444++0x03
        line.long 0x00 "MUTEX_9_PID01,Mutex 9 for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID01,Read from this field to request lock of mutex 9 from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x448++0x03
        line.long 0x00 "MUTEX_9_PID02,Mutex 9 for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID02,Read from this field to request lock of mutex 9 from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x44C++0x03
        line.long 0x00 "MUTEX_9_PID03,Mutex 9 for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID03,Read from this field to request lock of mutex 9 from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x450++0x03
        line.long 0x00 "MUTEX_9_PID04,Mutex 9 for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID04,Read from this field to request lock of mutex 9 from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x454++0x03
        line.long 0x00 "MUTEX_9_PID05,Mutex 9 for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID05,Read from this field to request lock of mutex 9 from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x458++0x03
        line.long 0x00 "MUTEX_9_PID06,Mutex 9 for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID06,Read from this field to request lock of mutex 9 from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x45C++0x03
        line.long 0x00 "MUTEX_9_PID07,Mutex 9 for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID07,Read from this field to request lock of mutex 9 from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x460++0x03
        line.long 0x00 "MUTEX_9_PID08,Mutex 9 for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID08,Read from this field to request lock of mutex 9 from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x464++0x03
        line.long 0x00 "MUTEX_9_PID09,Mutex 9 for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID09,Read from this field to request lock of mutex 9 from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x468++0x03
        line.long 0x00 "MUTEX_9_PID10,Mutex 9 for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID10,Read from this field to request lock of mutex 9 from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x46C++0x03
        line.long 0x00 "MUTEX_9_PID11,Mutex 9 for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID11,Read from this field to request lock of mutex 9 from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x470++0x03
        line.long 0x00 "MUTEX_9_PID12,Mutex 9 for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID12,Read from this field to request lock of mutex 9 from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x474++0x03
        line.long 0x00 "MUTEX_9_PID13,Mutex 9 for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID13,Read from this field to request lock of mutex 9 from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x478++0x03
        line.long 0x00 "MUTEX_9_PID14,Mutex 9 for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID14,Read from this field to request lock of mutex 9 from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x47C++0x03
        line.long 0x00 "MUTEX_9_PID15,Mutex 9 for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_9_PID15,Read from this field to request lock of mutex 9 from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x480++0x03
        line.long 0x00 "MUTEX_A_STAT,Mutex A status"
            bitfld.long 0x00 0.--3. "MUTEX_A_STAT,Read from this field to check that state of mutex A" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x484++0x03
        line.long 0x00 "MUTEX_A_PID01,Mutex A for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID01,Read from this field to request lock of mutex A from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x488++0x03
        line.long 0x00 "MUTEX_A_PID02,Mutex A for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID02,Read from this field to request lock of mutex A from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x48C++0x03
        line.long 0x00 "MUTEX_A_PID03,Mutex A for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID03,Read from this field to request lock of mutex A from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x490++0x03
        line.long 0x00 "MUTEX_A_PID04,Mutex A for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID04,Read from this field to request lock of mutex A from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x494++0x03
        line.long 0x00 "MUTEX_A_PID05,Mutex A for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID05,Read from this field to request lock of mutex A from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x498++0x03
        line.long 0x00 "MUTEX_A_PID06,Mutex A for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID06,Read from this field to request lock of mutex A from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x49C++0x03
        line.long 0x00 "MUTEX_A_PID07,Mutex A for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID07,Read from this field to request lock of mutex A from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4A0++0x03
        line.long 0x00 "MUTEX_A_PID08,Mutex A for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID08,Read from this field to request lock of mutex A from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4A4++0x03
        line.long 0x00 "MUTEX_A_PID09,Mutex A for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID09,Read from this field to request lock of mutex A from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4A8++0x03
        line.long 0x00 "MUTEX_A_PID10,Mutex A for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID10,Read from this field to request lock of mutex A from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4AC++0x03
        line.long 0x00 "MUTEX_A_PID11,Mutex A for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID11,Read from this field to request lock of mutex A from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4B0++0x03
        line.long 0x00 "MUTEX_A_PID12,Mutex A for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID12,Read from this field to request lock of mutex A from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4B4++0x03
        line.long 0x00 "MUTEX_A_PID13,Mutex A for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID13,Read from this field to request lock of mutex A from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4B8++0x03
        line.long 0x00 "MUTEX_A_PID14,Mutex A for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID14,Read from this field to request lock of mutex A from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4BC++0x03
        line.long 0x00 "MUTEX_A_PID15,Mutex A for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_A_PID15,Read from this field to request lock of mutex A from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x4C0++0x03
        line.long 0x00 "MUTEX_B_STAT,Mutex B status"
            bitfld.long 0x00 0.--3. "MUTEX_B_STAT,Read from this field to check that state of mutex B" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x4C4++0x03
        line.long 0x00 "MUTEX_B_PID01,Mutex B for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID01,Read from this field to request lock of mutex B from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4C8++0x03
        line.long 0x00 "MUTEX_B_PID02,Mutex B for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID02,Read from this field to request lock of mutex B from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4CC++0x03
        line.long 0x00 "MUTEX_B_PID03,Mutex B for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID03,Read from this field to request lock of mutex B from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4D0++0x03
        line.long 0x00 "MUTEX_B_PID04,Mutex B for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID04,Read from this field to request lock of mutex B from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4D4++0x03
        line.long 0x00 "MUTEX_B_PID05,Mutex B for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID05,Read from this field to request lock of mutex B from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4D8++0x03
        line.long 0x00 "MUTEX_B_PID06,Mutex B for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID06,Read from this field to request lock of mutex B from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4DC++0x03
        line.long 0x00 "MUTEX_B_PID07,Mutex B for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID07,Read from this field to request lock of mutex B from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4E0++0x03
        line.long 0x00 "MUTEX_B_PID08,Mutex B for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID08,Read from this field to request lock of mutex B from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4E4++0x03
        line.long 0x00 "MUTEX_B_PID09,Mutex B for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID09,Read from this field to request lock of mutex B from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4E8++0x03
        line.long 0x00 "MUTEX_B_PID10,Mutex B for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID10,Read from this field to request lock of mutex B from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4EC++0x03
        line.long 0x00 "MUTEX_B_PID11,Mutex B for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID11,Read from this field to request lock of mutex B from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4F0++0x03
        line.long 0x00 "MUTEX_B_PID12,Mutex B for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID12,Read from this field to request lock of mutex B from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4F4++0x03
        line.long 0x00 "MUTEX_B_PID13,Mutex B for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID13,Read from this field to request lock of mutex B from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4F8++0x03
        line.long 0x00 "MUTEX_B_PID14,Mutex B for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID14,Read from this field to request lock of mutex B from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x4FC++0x03
        line.long 0x00 "MUTEX_B_PID15,Mutex B for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_B_PID15,Read from this field to request lock of mutex B from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x500++0x03
        line.long 0x00 "MUTEX_C_STAT,Mutex C status"
            bitfld.long 0x00 0.--3. "MUTEX_C_STAT,Read from this field to check that state of mutex C" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x504++0x03
        line.long 0x00 "MUTEX_C_PID01,Mutex C for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID01,Read from this field to request lock of mutex C from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x508++0x03
        line.long 0x00 "MUTEX_C_PID02,Mutex C for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID02,Read from this field to request lock of mutex C from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x50C++0x03
        line.long 0x00 "MUTEX_C_PID03,Mutex C for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID03,Read from this field to request lock of mutex C from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x510++0x03
        line.long 0x00 "MUTEX_C_PID04,Mutex C for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID04,Read from this field to request lock of mutex C from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x514++0x03
        line.long 0x00 "MUTEX_C_PID05,Mutex C for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID05,Read from this field to request lock of mutex C from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x518++0x03
        line.long 0x00 "MUTEX_C_PID06,Mutex C for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID06,Read from this field to request lock of mutex C from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x51C++0x03
        line.long 0x00 "MUTEX_C_PID07,Mutex C for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID07,Read from this field to request lock of mutex C from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x520++0x03
        line.long 0x00 "MUTEX_C_PID08,Mutex C for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID08,Read from this field to request lock of mutex C from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x524++0x03
        line.long 0x00 "MUTEX_C_PID09,Mutex C for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID09,Read from this field to request lock of mutex C from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x528++0x03
        line.long 0x00 "MUTEX_C_PID10,Mutex C for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID10,Read from this field to request lock of mutex C from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x52C++0x03
        line.long 0x00 "MUTEX_C_PID11,Mutex C for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID11,Read from this field to request lock of mutex C from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x530++0x03
        line.long 0x00 "MUTEX_C_PID12,Mutex C for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID12,Read from this field to request lock of mutex C from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x534++0x03
        line.long 0x00 "MUTEX_C_PID13,Mutex C for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID13,Read from this field to request lock of mutex C from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x538++0x03
        line.long 0x00 "MUTEX_C_PID14,Mutex C for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID14,Read from this field to request lock of mutex C from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x53C++0x03
        line.long 0x00 "MUTEX_C_PID15,Mutex C for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_C_PID15,Read from this field to request lock of mutex C from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x540++0x03
        line.long 0x00 "MUTEX_D_STAT,Mutex D status"
            bitfld.long 0x00 0.--3. "MUTEX_D_STAT,Read from this field to check that state of mutex D" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x544++0x03
        line.long 0x00 "MUTEX_D_PID01,Mutex D for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID01,Read from this field to request lock of mutex D from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x548++0x03
        line.long 0x00 "MUTEX_D_PID02,Mutex D for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID02,Read from this field to request lock of mutex D from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x54C++0x03
        line.long 0x00 "MUTEX_D_PID03,Mutex D for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID03,Read from this field to request lock of mutex D from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x550++0x03
        line.long 0x00 "MUTEX_D_PID04,Mutex D for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID04,Read from this field to request lock of mutex D from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x554++0x03
        line.long 0x00 "MUTEX_D_PID05,Mutex D for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID05,Read from this field to request lock of mutex D from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x558++0x03
        line.long 0x00 "MUTEX_D_PID06,Mutex D for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID06,Read from this field to request lock of mutex D from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x55C++0x03
        line.long 0x00 "MUTEX_D_PID07,Mutex D for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID07,Read from this field to request lock of mutex D from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x560++0x03
        line.long 0x00 "MUTEX_D_PID08,Mutex D for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID08,Read from this field to request lock of mutex D from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x564++0x03
        line.long 0x00 "MUTEX_D_PID09,Mutex D for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID09,Read from this field to request lock of mutex D from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x568++0x03
        line.long 0x00 "MUTEX_D_PID10,Mutex D for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID10,Read from this field to request lock of mutex D from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x56C++0x03
        line.long 0x00 "MUTEX_D_PID11,Mutex D for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID11,Read from this field to request lock of mutex D from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x570++0x03
        line.long 0x00 "MUTEX_D_PID12,Mutex D for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID12,Read from this field to request lock of mutex D from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x574++0x03
        line.long 0x00 "MUTEX_D_PID13,Mutex D for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID13,Read from this field to request lock of mutex D from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x578++0x03
        line.long 0x00 "MUTEX_D_PID14,Mutex D for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID14,Read from this field to request lock of mutex D from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x57C++0x03
        line.long 0x00 "MUTEX_D_PID15,Mutex D for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_D_PID15,Read from this field to request lock of mutex D from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x580++0x03
        line.long 0x00 "MUTEX_E_STAT,Mutex E status"
            bitfld.long 0x00 0.--3. "MUTEX_E_STAT,Read from this field to check that state of mutex E" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x584++0x03
        line.long 0x00 "MUTEX_E_PID01,Mutex E for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID01,Read from this field to request lock of mutex E from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x588++0x03
        line.long 0x00 "MUTEX_E_PID02,Mutex E for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID02,Read from this field to request lock of mutex E from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x58C++0x03
        line.long 0x00 "MUTEX_E_PID03,Mutex E for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID03,Read from this field to request lock of mutex E from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x590++0x03
        line.long 0x00 "MUTEX_E_PID04,Mutex E for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID04,Read from this field to request lock of mutex E from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x594++0x03
        line.long 0x00 "MUTEX_E_PID05,Mutex E for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID05,Read from this field to request lock of mutex E from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x598++0x03
        line.long 0x00 "MUTEX_E_PID06,Mutex E for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID06,Read from this field to request lock of mutex E from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x59C++0x03
        line.long 0x00 "MUTEX_E_PID07,Mutex E for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID07,Read from this field to request lock of mutex E from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5A0++0x03
        line.long 0x00 "MUTEX_E_PID08,Mutex E for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID08,Read from this field to request lock of mutex E from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5A4++0x03
        line.long 0x00 "MUTEX_E_PID09,Mutex E for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID09,Read from this field to request lock of mutex E from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5A8++0x03
        line.long 0x00 "MUTEX_E_PID10,Mutex E for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID10,Read from this field to request lock of mutex E from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5AC++0x03
        line.long 0x00 "MUTEX_E_PID11,Mutex E for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID11,Read from this field to request lock of mutex E from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5B0++0x03
        line.long 0x00 "MUTEX_E_PID12,Mutex E for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID12,Read from this field to request lock of mutex E from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5B4++0x03
        line.long 0x00 "MUTEX_E_PID13,Mutex E for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID13,Read from this field to request lock of mutex E from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5B8++0x03
        line.long 0x00 "MUTEX_E_PID14,Mutex E for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID14,Read from this field to request lock of mutex E from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5BC++0x03
        line.long 0x00 "MUTEX_E_PID15,Mutex E for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_E_PID15,Read from this field to request lock of mutex E from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x5C0++0x03
        line.long 0x00 "MUTEX_F_STAT,Mutex F status"
            bitfld.long 0x00 0.--3. "MUTEX_F_STAT,Read from this field to check that state of mutex F" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x5C4++0x03
        line.long 0x00 "MUTEX_F_PID01,Mutex F for PID01"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID01,Read from this field to request lock of mutex F from process ID 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5C8++0x03
        line.long 0x00 "MUTEX_F_PID02,Mutex F for PID02"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID02,Read from this field to request lock of mutex F from process ID 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5CC++0x03
        line.long 0x00 "MUTEX_F_PID03,Mutex F for PID03"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID03,Read from this field to request lock of mutex F from process ID 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5D0++0x03
        line.long 0x00 "MUTEX_F_PID04,Mutex F for PID04"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID04,Read from this field to request lock of mutex F from process ID 4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5D4++0x03
        line.long 0x00 "MUTEX_F_PID05,Mutex F for PID05"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID05,Read from this field to request lock of mutex F from process ID 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5D8++0x03
        line.long 0x00 "MUTEX_F_PID06,Mutex F for PID06"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID06,Read from this field to request lock of mutex F from process ID 6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5DC++0x03
        line.long 0x00 "MUTEX_F_PID07,Mutex F for PID07"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID07,Read from this field to request lock of mutex F from process ID 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5E0++0x03
        line.long 0x00 "MUTEX_F_PID08,Mutex F for PID08"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID08,Read from this field to request lock of mutex F from process ID 8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5E4++0x03
        line.long 0x00 "MUTEX_F_PID09,Mutex F for PID09"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID09,Read from this field to request lock of mutex F from process ID 9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5E8++0x03
        line.long 0x00 "MUTEX_F_PID10,Mutex F for PID10"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID10,Read from this field to request lock of mutex F from process ID 10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5EC++0x03
        line.long 0x00 "MUTEX_F_PID11,Mutex F for PID11"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID11,Read from this field to request lock of mutex F from process ID 11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5F0++0x03
        line.long 0x00 "MUTEX_F_PID12,Mutex F for PID12"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID12,Read from this field to request lock of mutex F from process ID 12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5F4++0x03
        line.long 0x00 "MUTEX_F_PID13,Mutex F for PID13"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID13,Read from this field to request lock of mutex F from process ID 13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5F8++0x03
        line.long 0x00 "MUTEX_F_PID14,Mutex F for PID14"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID14,Read from this field to request lock of mutex F from process ID 14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x5FC++0x03
        line.long 0x00 "MUTEX_F_PID15,Mutex F for PID15"
            bitfld.long 0x00 0.--3. "MUTEX_F_PID15,Read from this field to request lock of mutex F from process ID 15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x600++0x03
        line.long 0x00 "LBIST_SEQ_STAT1,LBIST Sequencer Status Register 1"
            bitfld.long 0x00 29. "STS_LBSC_FUNC_FAIL,LBIST sequencer functional/periodic LBIST run failed" "0,1"
            bitfld.long 0x00 28. "STS_LBSC_FUNC_PASS,LBIST sequencer functional/periodic LBIST run passed" "0,1"
            newline
            bitfld.long 0x00 24. "STS_LBSC_MISR_VALID,LBIST sequencer saved MISR is valid from last BIST run" "0,1"
            hexmask.long.tbyte 0x00 0.--23. 1. "STS_LBSC_MISR_DAT,LBIST sequencer saved MISR value from BIST run"

    group.long 0x604++0x03
        line.long 0x00 "LBIST_SEQ_STAT2,LBIST Sequencer Status Register 2"
            rbitfld.long 0x00 8. "STS_LBSC_IRQ_NOMASK,If high indicates that LBIST Sequence Controller finished functional/periodic run even if the IRQ was not enabled" "0,1"
            bitfld.long 0x00 0. "STS_LBSC_IRQ,If high indicates that LBIST Sequence Controller finished functional/periodic run if the IRQ was enabled" "0,1"
    group.long 0x608++0x03
        line.long 0x00 "PPS_MISC_CTRL,Pulse Per Second miscellaneous control"
            bitfld.long 0x00 8.--11. "CTL_PPS_PIN_SEL,Select whether to take PPS driven by this counter or by Ethernet MAC driven PPS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 4. "CTL_PPS_POL,Polarity selection for PPS output signal" "0,1"
            newline
            bitfld.long 0x00 1. "CTL_PPS_CLR,Set (1) to clear PPS counter to 0" "0,1"
            bitfld.long 0x00 0. "CTL_PPS_ENA,Set (1) to run Pulse-Per-Second (PPS) counter" "0,1"
    group.long 0x60C++0x03
        line.long 0x00 "PPS_WRAP_CTRL,Pulse Per Second wrap limit control"
            hexmask.long 0x00 0.--30. 1. "CTL_PPS_WRAP,When PPS counter reaches this value it will wrap around to 0"
    group.long 0x610++0x03
        line.long 0x00 "PPS_HIGH_CTRL,Pulse Per Second duty cycle control"
            hexmask.long 0x00 0.--30. 1. "CTL_PPS_HIGH,PPS pulse is 'high' when counter is greater than 0 and less-than-or-equal-to this value"
    group.long 0x614++0x03
        line.long 0x00 "PPS_ADJ_VAL_CTRL,Pulse Per Second adjustment application control"
            hexmask.long 0x00 0.--30. 1. "CTL_PPS_ADJ_VAL,Adjustment value to apply to PPS counter"
    group.long 0x618++0x03
        line.long 0x00 "PPS_ADJ_GO_CTRL,Pulse Per Second adjustment application control"
            bitfld.long 0x00 31. "CTL_PPS_ADJ_GO,Toggle to '1' to request PPS counter adjustment" "0,1"
            hexmask.long 0x00 0.--30. 1. "CTL_PPS_ADJ_TIME,When PPS counter hits this field value then the adjustment is applied (if requested)"

    rgroup.long 0x61C++0x03
        line.long 0x00 "PPS_MISC_STAT,Pulse Per Second miscellaneous status"
            bitfld.long 0x00 0. "STS_PPS_ADJ_PEND,PPS counter adjustment request is pending" "0,1"
    rgroup.long 0x620++0x03
        line.long 0x00 "PPS_SNAP_STAT,Pulse Per Second Counter snap status"
            hexmask.long 0x00 0.--30. 1. "STS_PPS_CNT,Snapshot of PPS counter"

    group.long 0x624++0x03
        line.long 0x00 "HSM_RETAIN0,Retain for HSM register 0"
            hexmask.long.byte 0x00 24.--31. 1. "CTL_HSM_RETAIN_03,Reserved"
