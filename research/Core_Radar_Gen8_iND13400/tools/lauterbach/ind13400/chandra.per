autoindent.on center tree

sif (CORENAME()=="CORTEXR52")
INCLUDE ~~/percortexr52.per
else
INCLUDE ~~/perxtensa.per
endif

tree "ARTIE ()"
    base ad:0x89003000
    group.long 0x00++0x03
        line.long 0x00 "CAN0_CTRL,CAN0 Control Registers"
            bitfld.long 0x00 8.--10. "CAN0_TIMER_DIV_SEL,Division by increasing powers of two" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 5. "CAN0_TIMER_CLEAR,Division by increasing powers of two" "0,1"
            newline
            bitfld.long 0x00 4. "CAN0_TIMER_ENABLE,Currently unused/unsupported" "0,1"
            newline
            bitfld.long 0x00 0. "CAN0_FD_ENABLE,Enable FD features within the CAN module" "0,1"
    group.long 0x04++0x03
        line.long 0x00 "CAN1_CTRL,CAN1 Control Registers"
            bitfld.long 0x00 8.--10. "CAN1_TIMER_DIV_SEL,Division by increasing powers of two" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 5. "CAN1_TIMER_CLEAR,Division by increasing powers of two" "0,1"
            newline
            bitfld.long 0x00 4. "CAN1_TIMER_ENABLE,Currently unused/unsupported" "0,1"
            newline
            bitfld.long 0x00 0. "CAN1_FD_ENABLE,Enable FD features within the CAN module" "0,1"
    group.long 0x08++0x03
        line.long 0x00 "ETHER_CTRL,Ethernet Control Registers"
            bitfld.long 0x00 10. "ETH_SIGDET_BYPASS_VAL,Ethernet signal detect override value" "0,1"
            newline
            bitfld.long 0x00 9. "ETH_SIGDET_BYPASS,eth_sigdet_bypass" "0: Ethernet Signal detect value taken directly..,1: Ethernet Signal detect value bypassing SERDES.."
            newline
            bitfld.long 0x00 8. "ETH_MACSEC_BYPASS,eth_macsec_bypass" "0: Ethernet MAC Security Enabled,1: Ethernet MAC Security Disabled"
            newline
            rbitfld.long 0x00 6.--7. "ETH_SGMII_SPEED,eth_sgmii_speed" "0: Ethernet SGMII running at 10 Mbps,1: Ethernet SGMII running at 100 Mbps,2: Ethernet SGMII running at 1000 Mbps,?..."
            newline
            rbitfld.long 0x00 4.--5. "ETH_MAC_SPEED,eth_mac_speed" "0: Ethernet MAC running at 10 Mbps,1: Ethernet MAC running at 100 Mbps,2: Ethernet MAC running at 1000 Mbps,3: Ethernet MAC running at 2500 Mbps"
            newline
            bitfld.long 0x00 0.--1. "ETH_PHY_SEL,eth_phy_sel" "0: Interface to Ethernet MAC Reserved for future..,1: Ethernet MAC connected to SGMII phy,2: Interface to Ethernet MAC Reserved for future..,3: Ethernet MAC connected to SMII phy"
    group.long 0x0C++0x03
        line.long 0x00 "SP_MAIN_CFG,Supervisory Processor Main Configuration Register"
            hexmask.long.word 0x00 16.--26. 1. "CFGPERIPHBASE,Base address of the GIC Distributor Unit (GDU) registers"
            newline
            bitfld.long 0x00 1. "CFGRAMPROTEN,RAM (caches and TCMs) memory protection enable out of reset" "0,1"
            newline
            bitfld.long 0x00 0. "ETM_TS_DISABLE,When set tie the ETM TS binary value (TSVALUEB) to zero" "0,1"
    group.long 0x10++0x03
        line.long 0x00 "SP0_CFG0,Supervisory Processor 0 Configuration Register 0"
            hexmask.long 0x00 5.--31. 1. "CFGVECTABLE0,Vector table base address out of reset"
            newline
            bitfld.long 0x00 3. "CFGTHUMBEXCEPTIONS0,Instruction set state (A32 or T32) and value of HSCTLR.TE out of reset" "0,1"
            newline
            bitfld.long 0x00 2. "CFGTCMBOOT0,ATCM enabled and at address 0x0 out of reset" "0,1"
            newline
            bitfld.long 0x00 1. "CFGL1CACHEINVDIS0,Automatic post-reset L1 cache invalidate disable" "0,1"
            newline
            bitfld.long 0x00 0. "CPUHALT0,Core 0 waits out of reset before taking reset exception and fetching instructions" "0,1"

    rgroup.long 0x14++0x03
        line.long 0x00 "SP0_STATUS,Supervisory Processor 0 Status Register"
            bitfld.long 0x00 4. "STANDBYWFE0,Core 0 is in WFE low-power state" "0,1"
            newline
            bitfld.long 0x00 0. "STANDBYWFI0,Core 0 is in WFI low-power state" "0,1"

    group.long 0x18++0x03
        line.long 0x00 "DCLS_CTRL,Dual-Core Lock-Step Control Register"
            bitfld.long 0x00 19. "DCLSCOMPIN87,Global: Governor to core Force" "0,1"
            newline
            bitfld.long 0x00 18. "DCLSCOMPIN86,Global: Governor to core Enable" "0,1"
            newline
            bitfld.long 0x00 17. "DCLSCOMPIN85,Global: Governor to top-level logic Force" "0,1"
            newline
            bitfld.long 0x00 16. "DCLSCOMPIN84,Global: Governor to top-level logic Enable" "0,1"
            newline
            bitfld.long 0x00 13. "DCLSCOMPIN13,Core0: Activity checking of non-compared governor signals Force" "0,1"
            newline
            bitfld.long 0x00 12. "DCLSCOMPIN12,Core0: Activity checking of non-compared governor signals Enable" "0,1"
            newline
            bitfld.long 0x00 11. "DCLSCOMPIN11,Core0: Activity checking of non-compared core signals Force" "0,1"
            newline
            bitfld.long 0x00 10. "DCLSCOMPIN10,Core0: Activity checking of non-compared core signals Enable" "0,1"
            newline
            bitfld.long 0x00 9. "DCLSCOMPIN9,Core0: Governor to core Force" "0,1"
            newline
            bitfld.long 0x00 8. "DCLSCOMPIN8,Core0: Governor to core Enable" "0,1"
            newline
            bitfld.long 0x00 7. "DCLSCOMPIN7,Core0: Governor to top-level logic Force" "0,1"
            newline
            bitfld.long 0x00 6. "DCLSCOMPIN6,Core0: Governor to top-level logic Enable" "0,1"
            newline
            bitfld.long 0x00 5. "DCLSCOMPIN5,Core0: Core to RAM Force" "0,1"
            newline
            bitfld.long 0x00 4. "DCLSCOMPIN4,Core0: Core to RAM Enable" "0,1"
            newline
            bitfld.long 0x00 3. "DCLSCOMPIN3,Core0: Core to governor Force" "0,1"
            newline
            bitfld.long 0x00 2. "DCLSCOMPIN2,Core0: Core to governor Enable" "0,1"
            newline
            bitfld.long 0x00 1. "DCLSCOMPIN1,Core0: Core to top-level logic Force" "0,1"
            newline
            bitfld.long 0x00 0. "DCLSCOMPIN0,Core0: Core to top-level logic Enable" "0,1"
    group.long 0x1C++0x03
        line.long 0x00 "OTP_CTRL0,OTP Control Register 0"
            bitfld.long 0x00 0. "PARAM_SEL,This field selects the set of parameters values to time the OTP read/write operations" "0: All the timing parameters are controlled by..,1: All the timing parameters are set to be.."
    group.long 0x20++0x03
        line.long 0x00 "OTP_CTRL1,OTP Control Register 1"
            bitfld.long 0x00 16.--21. "WAIT_ST_CNT,wait_st_cnt" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            hexmask.long.word 0x00 0.--13. 1. "TRST_LOW_WR,trst_low_wr"
    group.long 0x24++0x03
        line.long 0x00 "OTP_CTRL2,OTP Control Register 2"
            hexmask.long.word 0x00 16.--29. 1. "TVPP_WR,tvpp_wr"
            newline
            hexmask.long.word 0x00 0.--13. 1. "TRST_HIGH_WR,trst_high_wr"
    group.long 0x28++0x03
        line.long 0x00 "OTP_CTRL3,OTP Control Register 3"
            hexmask.long.word 0x00 16.--29. 1. "WEB_LOW_WR,web_low_wr"
            newline
            hexmask.long.word 0x00 0.--13. 1. "TDLE_HIGH_WR,tdle_high_wr"
    group.long 0x2C++0x03
        line.long 0x00 "OTP_CTRL4,OTP Control Register 4"
            hexmask.long.word 0x00 16.--29. 1. "DLE_LOW_WR,dle_low_wr"
            newline
            hexmask.long.word 0x00 0.--13. 1. "WEB_HIGH_WR,web_high_wr"
    group.long 0x30++0x03
        line.long 0x00 "OTP_CTRL5,OTP Control Register 5"
            hexmask.long.word 0x00 16.--29. 1. "CPUMPEN_HIGH_WR,cpumpen_high_wr"
            newline
            hexmask.long.word 0x00 0.--13. 1. "PGMEN_HIGH_WR,pgmen_high_wr"
    group.long 0x34++0x03
        line.long 0x00 "OTP_CTRL6,OTP Control Register 6"
            hexmask.long.word 0x00 16.--29. 1. "WEB2_HIGH_WR,web2_high_wr"
            newline
            hexmask.long.word 0x00 0.--13. 1. "WEB2_LOW_WR,web2_low_wr"
    group.long 0x38++0x03
        line.long 0x00 "OTP_CTRL7,OTP Control Register 7"
            hexmask.long.word 0x00 16.--29. 1. "PGMEN_LOW_WR,pgmen_low_wr"
            newline
            hexmask.long.word 0x00 0.--13. 1. "CPUMPEN_LOW_WR,cpumpen_low_wr"
    group.long 0x3C++0x03
        line.long 0x00 "OTP_CTRL8,OTP Control Register 8"
            hexmask.long.word 0x00 16.--29. 1. "CPUMPEN2_HIGH_WR,cpumpen2_high_wr"
            newline
            hexmask.long.word 0x00 0.--13. 1. "PGMEN2_HIGH_WR,pgmen2_high_wr"
    group.long 0x40++0x03
        line.long 0x00 "OTP_CTRL9,OTP Control Register 9"
            hexmask.long.word 0x00 16.--29. 1. "WEB3_HIGH_WR,web3_high_wr"
            newline
            hexmask.long.word 0x00 0.--13. 1. "WEB3_LOW_WR,web3_low_wr"
    group.long 0x44++0x03
        line.long 0x00 "OTP_CTRL10,OTP Control Register 10"
            hexmask.long.word 0x00 16.--29. 1. "PGMEN2_LOW_WR,pgmen2_low_wr"
            newline
            hexmask.long.word 0x00 0.--13. 1. "CPUMPEN2_LOW_WR,cpumpen2_low_wr"
    group.long 0x48++0x03
        line.long 0x00 "OTP_CTRL11,OTP Control Register 11"
            hexmask.long.word 0x00 16.--29. 1. "EXT_COUNT_WR,ext_count_wr"
            newline
            hexmask.long.word 0x00 0.--13. 1. "RESP_WR,resp_wr"
    group.long 0x4C++0x03
        line.long 0x00 "OTP_CTRL12,OTP Control Register 12"
            hexmask.long.word 0x00 16.--29. 1. "TCEB_WIDTH_WR,tceb_width_wr"
            newline
            hexmask.long.word 0x00 0.--13. 1. "TRST_LOW_RD,trst_low_rd"
    group.long 0x50++0x03
        line.long 0x00 "OTP_CTRL13,OTP Control Register 13"
            hexmask.long.word 0x00 16.--29. 1. "READEN_HIGH_RD,readen_high_rd"
            newline
            hexmask.long.word 0x00 0.--13. 1. "TRST_HIGH_RD,trst_high_rd"
    group.long 0x54++0x03
        line.long 0x00 "OTP_CTRL14,OTP Control Register 14"
            hexmask.long.word 0x00 16.--29. 1. "TACC_HIGH_RD,tacc_high_rd"
            newline
            hexmask.long.word 0x00 0.--13. 1. "TDLE_HIGH_RD,tdle_high_rd"
    group.long 0x58++0x03
        line.long 0x00 "OTP_CTRL15,OTP Control Register 15"
            hexmask.long.word 0x00 16.--29. 1. "TACC_HIGH_2_RD,tacc_high_2_rd"
            newline
            hexmask.long.word 0x00 0.--13. 1. "TACC_HIGH_1_RD,tacc_high_1_rd"
    group.long 0x5C++0x03
        line.long 0x00 "OTP_CTRL16,OTP Control Register 16"
            hexmask.long.word 0x00 0.--13. 1. "LOOP_BACK_CNT_RD,loop_back_cnt_rd"
    group.long 0x60++0x03
        line.long 0x00 "OTP_CTRL17,OTP Control Register 17"
            hexmask.long.word 0x00 16.--29. 1. "TRS_RD,trs_rd"
            newline
            hexmask.long.word 0x00 0.--13. 1. "TDS_WR,tds_wr"

    rgroup.long 0x64++0x03
        line.long 0x00 "OTP_STATUS,OTP Status Register"
            bitfld.long 0x00 29. "OTP_TM_STAT,When set Chandra is in OTP test mode" "0,1"
            newline
            bitfld.long 0x00 28. "OTP_LOCK,When the OTP lock is set programming is not allowed" "0,1"
            newline
            bitfld.long 0x00 24.--27. "OTP_ACCESS_ERR,OTP access error code" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 23. "OTP_PWRRDY,OTP power-ready request in 0.8V domain" "0,1"
            newline
            hexmask.long.tbyte 0x00 0.--22. 1. "OTP_STATUS,OTP debug signals"

    group.long 0x68++0x03
        line.long 0x00 "OTP_TM_CTRL,OTP Test Mode control"
            bitfld.long 0x00 0. "OTP_TESTMODE,Set this bit to put the OTM in test mode" "0,1"
    group.long 0x6C++0x03
        line.long 0x00 "CLKGEN_CTRL0,Artie Clock control register"
            bitfld.long 0x00 19. "CTL_CKSER_DET_FAIL_CLR,Register to clear Serial Clock failure flag" "0,1"
            newline
            bitfld.long 0x00 18. "CTL_CKSER_DET_ENA,Register to enable clock failure detection on Serial Clock" "0,1"
            newline
            bitfld.long 0x00 17. "CTL_RMON_SER_FRC,Set to force testing of reset monitor of the serial reset" "0,1"
            newline
            bitfld.long 0x00 16. "CTL_RMON_SER_ENA,Set to enable reset monitor for serial reset" "0,1"
            newline
            bitfld.long 0x00 9. "CTL_RG_REQ_GPADC,Reset request for GPADC controller" "0,1"
            newline
            bitfld.long 0x00 8. "CTL_RG_REQ_CAN,Reset request for CAN blocks" "0,1"
            newline
            bitfld.long 0x00 4. "CTL_CG_CAN_ENA_CK,Enable for CAN clock" "0,1"
            newline
            bitfld.long 0x00 1. "CTL_CG_SRDS_RX0_ENA_CK,Enable for SERDES Rx0 clock - digital only" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_CG_SRDS_TX0_ENA_CK,Enable for SERDES Tx0 clock - digital only" "0,1"
    group.long 0x70++0x03
        line.long 0x00 "CLKGEN_CTRL1,Ethernet Clocks control register"
            bitfld.long 0x00 25. "CTL_CG_MAC_SPEED_VAL,Value to override 'eth_mac_speed[1]' with when override is set" "0,1"
            newline
            bitfld.long 0x00 24. "CTL_CG_MAC_SPEED_OVR,Set to '1' to override 'eth_mac_speed[1]' from Ethernet MAC hardware" "0,1"
            newline
            bitfld.long 0x00 16. "CTL_CG_E_TX_DVEN,Enable for Tx clock dividers" "0,1"
            newline
            bitfld.long 0x00 12.--13. "CTL_CG_E_TX_DIV,Divide for 'e_tx' clock" "?,1: =5/20,2: =50/200 default,?..."
            newline
            bitfld.long 0x00 8.--11. "CTL_CG_E_RX_DIV,Divide for 'e_rx' clock" "?,1: =2,2: =5,3: =20,4: =50,?..."
    group.long 0x74++0x03
        line.long 0x00 "MEM_CTRL,Artie Memory Control Register"
            bitfld.long 0x00 12.--15. "CYCLES_TO_DS,No" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 8.--11. "CYCLES_TO_LS,No" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 4. "RMW_DISABLE,Disable read-modify-write of Artie Mem" "0,1"
            newline
            bitfld.long 0x00 1. "ECC_DECODER_BYPASS,Bypass the ECC decoder when set to one" "0,1"
            newline
            bitfld.long 0x00 0. "ECC_ENCODER_BYPASS,Bypass the ECC encoder when set to one" "0,1"
    group.long 0x78++0x03
        line.long 0x00 "MEM_INIT_CTRL,Artie Memory Initialization Control Register"
            rbitfld.long 0x00 8. "MEM_INIT_ONGOING,The Memory ECC Initialization is done when this bit is zero" "0,1"
            newline
            bitfld.long 0x00 0. "MEM_INIT,Start the initialization of the memory" "0,1"
    group.long 0x7C++0x03
        line.long 0x00 "WDT_TOP_CTRL,Watchdog Top Control Register"
            bitfld.long 0x00 8.--11. "CTL_WDT_SYS_RST_ENA,Enable WatchDog Timer's sys_rst output to the FCRU" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 4.--7. "CTL_WDT_SPEED_UP,Speed-up WatchDog Timer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0.--3. "CTL_WDT_PAUSE,Pause WatchDog Timer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x80++0x03
        line.long 0x00 "TIMERS_TOP_CTRL,General Purpose Timers (first group of 8 timers) Control Register"
            hexmask.long.byte 0x00 0.--7. 1. "CTL_TIMERS_PAUSE,Pause Timers count"
    group.long 0x84++0x03
        line.long 0x00 "HSM_SRAM_CTRL,HSM SRAM supplemental controls"
            rbitfld.long 0x00 4.--7. "STS_CM_SRAM_PARITY_ERR,If this status signal is '1' then there has been a parity error from HSM SRAM controller" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0. "CTL_CM_SRAM_PARITY_CLR,Set (1) to clear parity error from HSM SRAM controller" "0,1"
    group.long 0x88++0x03
        line.long 0x00 "HSM_MISC_CTRL,Interrupt to HSM control"
            bitfld.long 0x00 8.--13. "CTL_HSM_ENV_ALARM_ENA,Set bits to '1' to enable the respective alarm: [0] 0.8V Brown Out [1] 1.8V Brown Out [2] PVT Monitor 0 alarm 0 [3] PVT Monitor 0 alarm 1 [4] PVT Monitor 1 alarm 0 [5] PVT Monitor 1 alarm 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "TO_HSM_INTR,Direct control over interrupt going to HSM"
    group.long 0x8C++0x03
        line.long 0x00 "SPI_RXD_CTRL,SPI Rx data-in selection mux control"
            bitfld.long 0x00 25. "CTL_QSPI_MMIC_XIP_EN,Enable XIP for QSPI MMIC" "0,1"
            newline
            bitfld.long 0x00 24. "CTL_QSPI_FLASH_XIP_EN,Enable XIP for QSPI FLASH" "0,1"
            newline
            bitfld.long 0x00 22.--23. "CTL_QSPI_GP_RXD3_SEL,IO selection control for RXD3 of QSPI GP" "0,1,2,3"
            newline
            bitfld.long 0x00 20.--21. "CTL_QSPI_GP_RXD2_SEL,IO selection control for RXD2 of QSPI GP" "0,1,2,3"
            newline
            bitfld.long 0x00 18.--19. "CTL_QSPI_GP_RXD1_SEL,IO selection control for RXD1 of QSPI GP" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "CTL_QSPI_GP_RXD0_SEL,IO selection control for RXD0 of QSPI GP" "0,1,2,3"
            newline
            bitfld.long 0x00 14.--15. "CTL_QSPI_MMIC_RXD3_SEL,IO selection control for RXD3 of QSPI MMIC" "0,1,2,3"
            newline
            bitfld.long 0x00 12.--13. "CTL_QSPI_MMIC_RXD2_SEL,IO selection control for RXD2 of QSPI MMIC" "0,1,2,3"
            newline
            bitfld.long 0x00 10.--11. "CTL_QSPI_MMIC_RXD1_SEL,IO selection control for RXD1 of QSPI MMIC" "0,1,2,3"
            newline
            bitfld.long 0x00 8.--9. "CTL_QSPI_MMIC_RXD0_SEL,IO selection control for RXD0 of QSPI MMIC" "0,1,2,3"
            newline
            bitfld.long 0x00 6.--7. "CTL_QSPI_FLASH_RXD3_SEL,IO selection control for RXD3 of QSPI FLASH" "0,1,2,3"
            newline
            bitfld.long 0x00 4.--5. "CTL_QSPI_FLASH_RXD2_SEL,IO selection control for RXD2 of QSPI FLASH" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "CTL_QSPI_FLASH_RXD1_SEL,IO selection control for RXD1 of QSPI FLASH" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--1. "CTL_QSPI_FLASH_RXD0_SEL,IO selection control for RXD0 of QSPI FLASH" "0,1,2,3"
    group.long 0x90++0x03
        line.long 0x00 "PWM_TOP_CTRL0,PWM top control register 0"
            bitfld.long 0x00 28.--31. "CTL_PWM3_EOF_LIM,Duration of EoF pulse to PWM3 in clock cycles" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 24.--27. "CTL_PWM2_EOF_LIM,Duration of EoF pulse to PWM2 in clock cycles" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 20.--23. "CTL_PWM1_EOF_LIM,Duration of EoF pulse to PWM1 in clock cycles" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 16.--19. "CTL_PWM0_EOF_LIM,Duration of EoF pulse to PWM0 in clock cycles" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 12.--15. "CTL_PWM3_EOC_LIM,Duration of EoC pulse to PWM3 in clock cycles" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 8.--11. "CTL_PWM2_EOC_LIM,Duration of EoC pulse to PWM2 in clock cycles" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 4.--7. "CTL_PWM1_EOC_LIM,Duration of EoC pulse to PWM1 in clock cycles" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0.--3. "CTL_PWM0_EOC_LIM,Duration of EoC pulse to PWM0 in clock cycles" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x94++0x03
        line.long 0x00 "PWM_TOP_CTRL1,PWM top control register 1"
            bitfld.long 0x00 7. "CTL_PWM3_EOF_SEL,Selection of PWM3's EoF source" "0: Direct from MIPI Wrapper,1: From System Time Counter alarm 1"
            newline
            bitfld.long 0x00 6. "CTL_PWM2_EOF_SEL,Selection of PWM2's EoF source" "0: Direct from MIPI Wrapper,1: From System Time Counter alarm 1"
            newline
            bitfld.long 0x00 5. "CTL_PWM1_EOF_SEL,Selection of PWM1's EoF source" "0: Direct from MIPI Wrapper,1: From System Time Counter alarm 1"
            newline
            bitfld.long 0x00 4. "CTL_PWM0_EOF_SEL,Selection of PWM0's EoF source" "0: Direct from MIPI Wrapper,1: From System Time Counter alarm 1"
            newline
            bitfld.long 0x00 3. "CTL_PWM3_EOC_SEL,Selection of PWM3's EoC source" "0: Direct from MIPI Wrapper,1: From System Time Counter alarm 0"
            newline
            bitfld.long 0x00 2. "CTL_PWM2_EOC_SEL,Selection of PWM2's EoC source" "0: Direct from MIPI Wrapper,1: From System Time Counter alarm 0"
            newline
            bitfld.long 0x00 1. "CTL_PWM1_EOC_SEL,Selection of PWM1's EoC source" "0: Direct from MIPI Wrapper,1: From System Time Counter alarm 0"
            newline
            bitfld.long 0x00 0. "CTL_PWM0_EOC_SEL,Selection of PWM0's EoC source" "0: Direct from MIPI Wrapper,1: From System Time Counter alarm 0"

    rgroup.long 0x98++0x03
        line.long 0x00 "CAN0_TIMER_STAT,CAN0 Timer Status"
            hexmask.long 0x00 0.--31. 1. "STS_CAN0_TIMER,CAN0 timer"
    rgroup.long 0x9C++0x03
        line.long 0x00 "CAN1_TIMER_STAT,CAN1 Timer Status"
            hexmask.long 0x00 0.--31. 1. "STS_CAN1_TIMER,CAN1 timer"

    group.long 0xA0++0x03
        line.long 0x00 "SERDES_IRQ_ENA,SERDES Interrupt Event Enable Control"
            bitfld.long 0x00 10. "RXPLL_FLOCK_LVL_IRQ_ENA,When set RXPLL FLock Sticky IRQ is disabled" "0,1"
            newline
            bitfld.long 0x00 9. "RXPLL_FLOCK_FE_IRQ_ENA,When set RXPLL FLock Falling edge IRQ is disabled" "0,1"
            newline
            bitfld.long 0x00 8. "RXPLL_FLOCK_RE_IRQ_ENA,When set RXPLL FLock Rising edge IRQ is disabled" "0,1"
            newline
            bitfld.long 0x00 6. "RXPLL_LOCK_LVL_IRQ_ENA,When set RXPLL Lock Sticky IRQ is disabled" "0,1"
            newline
            bitfld.long 0x00 5. "RXPLL_LOCK_FE_IRQ_ENA,When set RXPLL Lock Falling edge IRQ is disabled" "0,1"
            newline
            bitfld.long 0x00 4. "RXPLL_LOCK_RE_IRQ_ENA,When set RXPLL Lock Rising edge IRQ is disabled" "0,1"
            newline
            bitfld.long 0x00 2. "TXPLL_LOCK_LVL_IRQ_ENA,When set TXPLL Lock Sticky IRQ is disabled" "0,1"
            newline
            bitfld.long 0x00 1. "TXPLL_LOCK_FE_IRQ_ENA,When set TXPLL Lock Falling edge IRQ is disabled" "0,1"
            newline
            bitfld.long 0x00 0. "TXPLL_LOCK_RE_IRQ_ENA,When set TXPLL Lock Rising edge IRQ is disabled" "0,1"
    group.long 0xA4++0x03
        line.long 0x00 "SERDES_IRQ_CLR,SERDES Interrupt Event Clear Control"
            bitfld.long 0x00 10. "RXPLL_FLOCK_LVL_IRQ_CLR,Write 1 to clear RXPLL FLOCK Status Change IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 9. "RXPLL_FLOCK_FE_IRQ_CLR,Write 1 to clear RXPLL FLOCK Status Change IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 8. "RXPLL_FLOCK_RE_IRQ_CLR,Write 1 to clear RXPLL FLOCK Status Change IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 6. "RXPLL_LOCK_LVL_IRQ_CLR,Write 1 to clear RXPLL LOCK Status Change IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 5. "RXPLL_LOCK_FE_IRQ_CLR,Write 1 to clear RXPLL LOCK Status Change IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 4. "RXPLL_LOCK_RE_IRQ_CLR,Write 1 to clear RXPLL LOCK Status Change IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 2. "TXPLL_LOCK_LVL_IRQ_CLR,Write 1 to clear TXPLL LOCK Status Change IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 1. "TXPLL_LOCK_FE_IRQ_CLR,Write 1 to clear TXPLL LOCK Status Change IRQ Flag" "0,1"
            newline
            bitfld.long 0x00 0. "TXPLL_LOCK_RE_IRQ_CLR,Write 1 to clear TXPLL LOCK Status Change IRQ Flag" "0,1"

    rgroup.long 0xA8++0x03
        line.long 0x00 "SERDES_EVENT_STATUS,SERDES Event Status"
            bitfld.long 0x00 10. "RXPLL_FLOCK_LVL_IRQ_FIRED,Indicates RXPLL FLOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 9. "RXPLL_FLOCK_FE_IRQ_FIRED,Indicates RXPLL FLOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 8. "RXPLL_FLOCK_RE_IRQ_FIRED,Indicates RXPLL FLOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 6. "RXPLL_LOCK_LVL_IRQ_FIRED,Indicates RXPLL LOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 5. "RXPLL_LOCK_FE_IRQ_FIRED,Indicates RXPLL LOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 4. "RXPLL_LOCK_RE_IRQ_FIRED,Indicates RXPLL LOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 2. "TXPLL_LOCK_LVL_IRQ_FIRED,Indicates TXPLL LOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 1. "TXPLL_LOCK_FE_IRQ_FIRED,Indicates TXPLL LOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 0. "TXPLL_LOCK_RE_IRQ_FIRED,Indicates TXPLL LOCK status change event has occured" "0,1"
    rgroup.long 0xAC++0x03
        line.long 0x00 "SERDES_EVENT_STATUS_MASKED,SERDES Event Status Masked"
            bitfld.long 0x00 10. "RXPLL_FLOCK_LVL_IRQ_FIRED_MASKED,Indicates RXPLL FLOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 9. "RXPLL_FLOCK_FE_IRQ_FIRED_MASKED,Indicates RXPLL FLOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 8. "RXPLL_FLOCK_RE_IRQ_FIRED_MASKED,Indicates RXPLL FLOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 6. "RXPLL_LOCK_LVL_IRQ_FIRED_MASKED,Indicates RXPLL LOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 5. "RXPLL_LOCK_FE_IRQ_FIRED_MASKED,Indicates RXPLL LOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 4. "RXPLL_LOCK_RE_IRQ_FIRED_MASKED,Indicates RXPLL LOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 2. "TXPLL_LOCK_LVL_IRQ_FIRED_MASKED,Indicates TXPLL LOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 1. "TXPLL_LOCK_FE_IRQ_FIRED_MASKED,Indicates TXPLL LOCK status change event has occured" "0,1"
            newline
            bitfld.long 0x00 0. "TXPLL_LOCK_RE_IRQ_FIRED_MASKED,Indicates TXPLL LOCK status change event has occured" "0,1"

    group.long 0xB0++0x03
        line.long 0x00 "TRNG_CHAR_CTRL,HSM TRNG Characterization control"
            bitfld.long 0x00 16.--18. "HSM_TRNG_CLK_SEL,Select which one of the cm_sys_fro_clk_nosync 8 outputs of the HSM goes to the external pin/ball" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 8.--12. "HSM_TRNG_FRO_SEL,FRO selection allows for values of 0 to 7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 7. "HSM_TRNG_FRO_CTRL_ENA,Active high enable signal for FRO characterization" "0,1"
            newline
            bitfld.long 0x00 6. "HSM_TRNG_FRO_DLY,Delay chain length selection for FRO selected by the HSM_TRNG_FRO_SEL" "0,1"
            newline
            bitfld.long 0x00 5. "HSM_TRNG_FRO_ENA,Enable the FROs (Free Running Osc)" "0,1"
            newline
            bitfld.long 0x00 4. "HSM_TRNG_FRO_IDDQ,Disables all FROs (Free Running Osc) to allow leakage power testing" "0,1"
            newline
            bitfld.long 0x00 0. "HSM_TRNG_CHAR_MODE,Set this bit to put the TRNG in Characterization mode" "0,1"

    rgroup.long 0xB4++0x03
        line.long 0x00 "TRNG_CHAR_STAT,HSM TRNG Characterization Status"
            bitfld.long 0x00 0. "TRNG_CHAR_ACCESS_STATUS,A status flag that is set when TRNG Characterization control is enabled" "0,1"

    group.long 0xB8++0x03
        line.long 0x00 "TRNG_VAL_CTRL,HSM TRNG Validation control"
            bitfld.long 0x00 29. "HSM_TRNG_RNG_READ,Active high read enable signal for register accesses" "0,1"
            newline
            bitfld.long 0x00 28. "HSM_TRNG_RNG_SEL,Active high general enable signal for register accesses" "0,1"
            newline
            bitfld.long 0x00 24.--27. "HSM_TRNG_RNG_WRITE,Active high (byte) write enable signal for register accesses" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 16.--20. "HSM_TRNG_RNG_ADDR,Address for reading and writing registers" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 0. "HSM_TRNG_VAL_MODE,Set this bit to put the TRNG in Validation mode" "0,1"
    group.long 0xBC++0x03
        line.long 0x00 "TRNG_VAL_DATA_IN,HSM TRNG Validation interface data to"
            hexmask.long 0x00 0.--31. 1. "HSM_TRNG_VAL_DATA_IN,Data to be written to a register"

    rgroup.long 0xC0++0x03
        line.long 0x00 "TRNG_VAL_DATA_OUT,HSM TRNG Validation interface read data"
            hexmask.long 0x00 0.--31. 1. "HSM_TRNG_VAL_DATA_OUT,Data read from a register"
    rgroup.long 0xC4++0x03
        line.long 0x00 "TRNG_VAL_STAT,HSM TRNG Validation Status"
            bitfld.long 0x00 0. "TRNG_VAL_ACCESS_STATUS,A status flag that is set when TRNG Validation control is enabled" "0,1"

    group.long 0xC8++0x03
        line.long 0x00 "SEC_CNT_CTRL,Artie Mem SEC Control"
            bitfld.long 0x00 16. "CTL_SNAP_SEC_CNT,Toggle to '1' then back to '0' to take a snapshot of the SEC counter" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_ERR_SEC_LIM,If SEC count exceeds the value of this field then trigger an interrrupt request"

    rgroup.long 0xCC++0x03
        line.long 0x00 "SEC_DED_STAT,Artie Mem SEC DED Status"
            hexmask.long.word 0x00 16.--31. 1. "STS_ECC_SEC_CNT,Counter of all SEC events in this port"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "STS_ECC_SEC_STICKY,Keep track of which RAM instances has had a SEC error"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "STS_ECC_DED_STICKY,Keep track of which RAM instances has had a DED error"

    group.long 0xD0++0x03
        line.long 0x00 "CLEAR_ERR_CTRL,Artie Mem Clear Sticky Error Control"
            bitfld.long 0x00 2. "CLR_ECC_SEC_CNT,Toggle to '1' to clear SEC counter" "0,1"
            newline
            bitfld.long 0x00 1. "CLR_ECC_SEC_STICKY,Toggle to '1' to clear SEC sticky tracker" "0,1"
            newline
            bitfld.long 0x00 0. "CLR_ECC_DED_STICKY,Toggle to '1' to clear DED sticky tracker" "0,1"
    group.long 0xD4++0x03
        line.long 0x00 "AMEM_IRQ_ENA,Artie Mem Interrupt Event Enable Control"
            bitfld.long 0x00 3.--5. "AMEM_SWIF_IRQ_ENA,AXI Interface error Interrupt Enable" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 2. "AMEM_ECCE_IRQ_ENA,Error in ECC engine Interrupt Enable" "0,1"
            newline
            bitfld.long 0x00 1. "AMEM_SEC_IRQ_ENA,Single Bit ECC error (count above limit) Interrupt Enable" "0,1"
            newline
            bitfld.long 0x00 0. "AMEM_DED_IRQ_ENA,Double Bit ECC error Interrupt Enable" "0,1"
    group.long 0xD8++0x03
        line.long 0x00 "AMEM_IRQ_CLR,Artie Mem Interrupt Event Clear Control"
            bitfld.long 0x00 3.--5. "AMEM_SWIF_IRQ_CLR,Write 1 to clear AXI Interface error Interrupt Flag" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 2. "AMEM_ECCE_IRQ_CLR,Write 1 to clear Error in ECC engine Interrupt Flag" "0,1"
            newline
            bitfld.long 0x00 1. "AMEM_SEC_IRQ_CLR,Write 1 to clear Single Bit ECC error (count above limit) Interrupt Flag" "0,1"
            newline
            bitfld.long 0x00 0. "AMEM_DED_IRQ_CLR,Write 1 to clear Double Bit ECC error Interrupt Flag" "0,1"

    rgroup.long 0xDC++0x03
        line.long 0x00 "AMEM_IRQ_STATUS,Artie Mem IRQ Status"
            bitfld.long 0x00 3.--5. "AMEM_SWIF_IRQ_FIRED,Indicates AXI Interface error has occured" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 2. "AMEM_ECCE_IRQ_FIRED,Indicates Error in ECC engine Interrupt has occured" "0,1"
            newline
            bitfld.long 0x00 1. "AMEM_SEC_IRQ_FIRED,Indicates Single Bit ECC error (count above limit) Interrupt has occured" "0,1"
            newline
            bitfld.long 0x00 0. "AMEM_DED_IRQ_FIRED,Indicates Double Bit ECC error Interrupt has occured" "0,1"
    rgroup.long 0xE0++0x03
        line.long 0x00 "AMEM_IRQ_STATUS_MASKED,Artie Mem IRQ Status Masked"
            bitfld.long 0x00 3.--5. "AMEM_SWIF_IRQ_FIRED_MASKED,Indicates AXI Interface error after Mask/Enable has occured" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 2. "AMEM_ECCE_IRQ_FIRED_MASKED,Indicates Error in ECC engine Interrupt after Mask/Enable has occured" "0,1"
            newline
            bitfld.long 0x00 1. "AMEM_SEC_IRQ_FIRED_MASKED,Indicates Single Bit ECC error (count above limit) Interrupt after Mask/Enable has occured" "0,1"
            newline
            bitfld.long 0x00 0. "AMEM_DED_IRQ_FIRED_MASKED,Indicates Double Bit ECC error Interrupt after Mask/Enable has occured" "0,1"
    rgroup.long 0xE4++0x03
        line.long 0x00 "ETHERNET_PCS_STATUS,Ethernet PCS status Register"
            bitfld.long 0x00 3. "PCS_LOCK_REF,Indicates PCS lock to reference clock" "0,1"
            newline
            bitfld.long 0x00 2. "PCS_DETECT_ENA,Indicates PCS detection enabled" "0,1"
            newline
            bitfld.long 0x00 1. "PCS_WRAP_ENA,Indicates PHY should be ready for loopback between transmitted serialized data to the receive path" "0,1"
            newline
            bitfld.long 0x00 0. "PCS_ACQUIRED,Indicates PCS interface has synchronized to the running disparity of the receive code groups" "0,1"

    group.long 0xE8++0x03
        line.long 0x00 "ETHERNET_PTP_EXT_TRIGGER,Ethernet PTP external auxillary trigger Register"
            bitfld.long 0x00 0.--1. "PTP_EXT_TRIG,When this signal goes high (rising edge) a snapshot of the System Time is taken and stored in the auxiliary timestamp FIFO" "0,1,2,3"
    group.long 0xEC++0x03
        line.long 0x00 "ETHERNET_MCGR_CTRL,Ethernet Media Clock Generation Register"
            bitfld.long 0x00 8.--11. "MCGR_DMA_ACK,Indicates the target presentation request is accepted" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 4.--7. "MCGR_DMA_REQ,Used to request a target presentation time value when running in recovery mode" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0.--3. "MCG_PST_TRIG,Trigger input to capture presentation time" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0xF0++0x03
        line.long 0x00 "NOC_MISC_CTRL,NoC Misc"
            bitfld.long 0x00 0.--2. "CTL_NOC_EXTREF_SEL,Select prescaler for Artie core and wrapper NoC's timeout counter" "0: sys clock divide-by-4,1: sys clock divide-by-8,2: sys clock divide-by-16,3: sys clock divide-by-32,4: sys clock divide-by-64,5: sys clock divide-by-128,6: sys clock divide-by-256,7: sys clock divide-by-512"

    rgroup.long 0xF4++0x03
        line.long 0x00 "ARTIE_MISC_STAT0,Artie Misc"
            bitfld.long 0x00 28.--31. "STS_CM_SRAM_DED,Each bit corresponds to detecting a DED error on one of the RT-640's SRAM instances" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 25. "STS_CM_SYS_HALT_STATE,RT-640 in halt state" "0,1"
            newline
            bitfld.long 0x00 24. "STS_CM_SYS_INIT_DONE,RT-640 initialization done" "0,1"
            newline
            bitfld.long 0x00 23. "STS_QSPI_MMIC_SLEEP,MMIC QSPI Sleeping" "0,1"
            newline
            bitfld.long 0x00 22. "STS_QSPI_MMIC_BUSY,MMIC QSPI Busy" "0,1"
            newline
            bitfld.long 0x00 20.--21. "STS_QSPI_MMIC_MODE,MMIC QSPI Mode selected" "0,1,2,3"
            newline
            bitfld.long 0x00 19. "STS_QSPI_FLASH_SLEEP,FLASH QSPI Sleeping" "0,1"
            newline
            bitfld.long 0x00 18. "STS_QSPI_FLASH_BUSY,FLASH QSPI Busy" "0,1"
            newline
            bitfld.long 0x00 16.--17. "STS_QSPI_FLASH_MODE,FLASH QSPI Mode selected" "0,1,2,3"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "STS_TIMERS_TOGGLE,Timers Toggled"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "STS_TIMERS_EN,Timers Enabled"

    group.long 0xF8++0x03
        line.long 0x00 "TEST_BUS_CTRL,Artie Test Bus Select Control Register"
            bitfld.long 0x00 0.--4. "SEL,Select one 24-bit bus to connect to the Artie Test Bus" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

    rgroup.long 0xFC++0x03
        line.long 0x00 "R52_CEE_SINGLE_STAT0,R52 Correctable Error Event firing status"
            hexmask.long.byte 0x00 0.--6. 1. "STS_R52_CEE_FIRED,Each bit corresponds to an R52 correctable error event"

    group.long 0x100++0x03
        line.long 0x00 "R52_CEE_LIM_CTRL0,R52 Correctable Error Event Counter Limit control"
            hexmask.long.word 0x00 16.--31. 1. "CTL_R52_CEE_LIM1,If correctable error counter for R52 errevent0[0] is greater than this value then trigger fault interrupt"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_R52_CEE_LIM0,If correctable error counter for R52 errevent[0] is greater than this value then trigger fault interrupt"
    group.long 0x104++0x03
        line.long 0x00 "R52_CEE_LIM_CTRL1,R52 Correctable Error Event Counter Limit control"
            hexmask.long.word 0x00 16.--31. 1. "CTL_R52_CEE_LIM3,If correctable error counter for R52 errevent0[7] is greater than this value then trigger fault interrupt"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_R52_CEE_LIM2,If correctable error counter for R52 errevent0[2] is greater than this value then trigger fault interrupt"
    group.long 0x108++0x03
        line.long 0x00 "R52_CEE_LIM_CTRL2,R52 Correctable Error Event Counter Limit control"
            hexmask.long.word 0x00 16.--31. 1. "CTL_R52_CEE_LIM5,If correctable error counter for R52 errevent0[9] is greater than this value then trigger fault interrupt"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_R52_CEE_LIM4,If correctable error counter for R52 errevent0[8] is greater than this value then trigger fault interrupt"
    group.long 0x10C++0x03
        line.long 0x00 "R52_CEE_LIM_CTRL3,R52 Correctable Error Event Counter Limit control"
            hexmask.long.word 0x00 0.--15. 1. "CTL_R52_CEE_LIM6,If correctable error counter for R52 errevent0[16] is greater than this value then trigger fault interrupt"
    group.long 0x110++0x03
        line.long 0x00 "R52_CEE_SNAP_CTRL,R52 Correctable Error Event Counter Limit control"
            hexmask.long.byte 0x00 0.--6. 1. "CTL_R52_CEE_CNT_SNAP,Toggle corresponding bit to '1' then back to '0' to take a snapshot of respective correctable counter"

    rgroup.long 0x114++0x03
        line.long 0x00 "R52_CEE_CNT_STAT0,R52 Correctable Error Event Counter counter status"
            hexmask.long.word 0x00 16.--31. 1. "STS_R52_CEE_CNT1,Count for correctable error source 1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "STS_R52_CEE_CNT0,Count for correctable error source 0"
    rgroup.long 0x118++0x03
        line.long 0x00 "R52_CEE_CNT_STAT1,R52 Correctable Error Event Counter counter status"
            hexmask.long.word 0x00 16.--31. 1. "STS_R52_CEE_CNT3,Count for correctable error source 3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "STS_R52_CEE_CNT2,Count for correctable error source 2"
    rgroup.long 0x11C++0x03
        line.long 0x00 "R52_CEE_CNT_STAT2,R52 Correctable Error Event Counter counter status"
            hexmask.long.word 0x00 16.--31. 1. "STS_R52_CEE_CNT5,Count for correctable error source 5"
            newline
            hexmask.long.word 0x00 0.--15. 1. "STS_R52_CEE_CNT4,Count for correctable error source 4"
    rgroup.long 0x120++0x03
        line.long 0x00 "R52_CEE_CNT_STAT3,R52 Correctable Error Event Counter counter status"
            hexmask.long.word 0x00 0.--15. 1. "STS_R52_CEE_CNT6,Count for correctable error source 6"

    group.long 0x124++0x03
        line.long 0x00 "R52_CEE_IRQ_ENA_CTRL,R52 Correctable Error Event Counter IRQ Enable Control"
            hexmask.long.byte 0x00 0.--6. 1. "CTL_R52_CEE_IRQ_ENA,Set corresponding bit to '1' to enable fault generation if the correctable error event counter goes above the limit"
    group.long 0x128++0x03
        line.long 0x00 "R52_CEE_CLEAR_CTRL,R52 Correctable Error Event Counter Clearing Control"
            hexmask.long.byte 0x00 16.--22. 1. "CTL_R52_CEE_IRQ_CLR,Set corresponding bit to '1' to clear STS_R52_CEE_IRQ_FIRED bits"
            newline
            hexmask.long.byte 0x00 8.--14. 1. "CTL_R52_CEE_CNT_CLR,Set corresponding bit to '1' to clear Correctable Error Event counters"
            newline
            hexmask.long.byte 0x00 0.--6. 1. "CTL_R52_CEE_CLR,Set corresponding bit to '1' to clear STS_R52_CEE_FIRED bits"

    rgroup.long 0x12C++0x03
        line.long 0x00 "R52_CEE_IRQ_STAT,R52 Correctable Error Event Counter IRQ Status"
            hexmask.long.byte 0x00 0.--6. 1. "STS_R52_CEE_IRQ_FIRED,Correctable Error Event IRQ firing status"
    rgroup.long 0x130++0x03
        line.long 0x00 "MCE_SINGLE_STAT0,Miscellaneous Correctable Error firing status"
            bitfld.long 0x00 4. "STS_MCE_FIRED1,Secure OTP correctable error" "0,1"
            newline
            bitfld.long 0x00 0.--3. "STS_MCE_FIRED0,HSM SRAM read correctable error" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0x134++0x03
        line.long 0x00 "MCE_LIM_CTRL0,Miscellaneous Correctable Error Counter Limit control"
            hexmask.long.word 0x00 16.--31. 1. "CTL_MCE_LIM1,If correctable error counter for HSM SRAM read correctable errors is greater than this value then trigger fault interrupt"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_MCE_LIM0,If correctable error counter for Secure OTP correctable errors is greater than this value then trigger fault interrupt"
    group.long 0x138++0x03
        line.long 0x00 "MCE_SNAP_CTRL,Miscellaneous Correctable Error Counter Limit control"
            bitfld.long 0x00 0.--1. "CTL_MCE_CNT_SNAP,Toggle corresponding bit to '1' then back to '0' to take a snapshot of respective correctable counter" "0,1,2,3"

    rgroup.long 0x13C++0x03
        line.long 0x00 "MCE_CNT_STAT0,Miscellaneous Correctable Error Counter counter status"
            hexmask.long.word 0x00 16.--31. 1. "STS_MCE_CNT1,Count for correctable error source 1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "STS_MCE_CNT0,Count for correctable error source 0"

    group.long 0x140++0x03
        line.long 0x00 "MCE_IRQ_ENA_CTRL,Miscellaneous Correctable Error Counter IRQ Enable Control"
            bitfld.long 0x00 0.--1. "CTL_MCE_IRQ_ENA,Set corresponding bit to '1' to enable fault generation if the correctable error event counter goes above the limit" "0,1,2,3"
    group.long 0x144++0x03
        line.long 0x00 "MCE_CLEAR_CTRL,Miscellaneous Correctable Error Counter Clearing Control"
            bitfld.long 0x00 16.--17. "CTL_MCE_IRQ_CLR,Set corresponding bit to '1' to clear STS_MCE_IRQ_FIRED bits" "0,1,2,3"
            newline
            bitfld.long 0x00 8.--9. "CTL_MCE_CNT_CLR,Set corresponding bit to '1' to clear Correctable Error Event counters" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--1. "CTL_MCE_CLR,Set corresponding bit to '1' to clear STS_MCE_FIRED0 and STS_MCE_FIRED1" "0,1,2,3"

    rgroup.long 0x148++0x03
        line.long 0x00 "MCE_IRQ_STAT,Miscellaneous Correctable Error Counter IRQ Status"
            bitfld.long 0x00 0.--1. "STS_MCE_IRQ_FIRED,Correctable Error Event IRQ firing status" "0,1,2,3"

    group.long 0x14C++0x03
        line.long 0x00 "R52_TMR_CTRL,R52 Generic Timer Control"
            bitfld.long 0x00 4. "CTL_R52_TMR_RST,Reset the 64-bit counter that is used to feed CNTVALUEB" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_R52_TMR_ENA,Enable the 64-bit counter that is used to feed CNTVALUEB" "0,1"
    group.long 0x150++0x03
        line.long 0x00 "OTP_WR_CTRL,OTP write Control"
            hexmask.long 0x00 0.--31. 1. "OTP_WR_ENA_KEY,Enable write access to the OTP non-secure area when set to 0x1973ACDC"
    group.long 0x154++0x03
        line.long 0x00 "HSM_TOP_CTRL,HSM Top Control"
            bitfld.long 0x00 0. "CTL_HSM_HRESET_REQ,Reset request for HResetN of HSM" "0,1"
    group.long 0x158++0x03
        line.long 0x00 "ARTIEMEM_ROC_A_CTRL0,Artie Memory Read-Only-Check Control Region A Register 0"
            bitfld.long 0x00 24. "CTL_ROC_A_ENA,If set (1) read-only-check region A is enabled" "0,1"
            newline
            hexmask.long.word 0x00 0.--12. 1. "CTL_ROC_A_BEG_ADDR,Read-Only-Check region A is defined by this field and ending address: beg_addr <= read-only-check region <= end_addr"
    group.long 0x15C++0x03
        line.long 0x00 "ARTIEMEM_ROC_A_CTRL1,Artie Memory Read-Only-Check Control Region A Register 1"
            hexmask.long.word 0x00 0.--12. 1. "CTL_ROC_A_END_ADDR,Read-Only-Check region A is defined by this field and beginning address: beg_addr <= read-only-check region <= end_addr"
    group.long 0x160++0x03
        line.long 0x00 "ARTIEMEM_ROC_B_CTRL0,Artie Memory Read-Only-Check Control Region A Register 0"
            bitfld.long 0x00 24. "CTL_ROC_B_ENA,If set (1) read-only-check region A is enabled" "0,1"
            newline
            hexmask.long.word 0x00 0.--12. 1. "CTL_ROC_B_BEG_ADDR,Read-Only-Check region A is defined by this field and ending address: beg_addr <= read-only-check region <= end_addr"
    group.long 0x164++0x03
        line.long 0x00 "ARTIEMEM_ROC_B_CTRL1,Artie Memory Read-Only-Check Control Region A Register 1"
            hexmask.long.word 0x00 0.--12. 1. "CTL_ROC_B_END_ADDR,Read-Only-Check region A is defined by this field and beginning address: beg_addr <= read-only-check region <= end_addr"
    group.long 0x168++0x03
        line.long 0x00 "ARTIEMEM_ROC_IRQ_ENA_CTRL,Artie Memory read-only-check Interrupt Request Control"
            bitfld.long 0x00 0.--1. "CTL_ROC_IRQ_ENA,Bit[0]: Set (1) to enable interrupt trigger from a write into read-only-check region A of Artie Memory" "0,1,2,3"
    group.long 0x16C++0x03
        line.long 0x00 "ARTIEMEM_ROC_IRQ_CLR_CTRL,Artie Memory read-only-check Interrupt Clearing Control"
            bitfld.long 0x00 0.--1. "CTL_ROC_IRQ_CLR,Write a '1' to corresponding bit to clear the interrupt" "0,1,2,3"

    rgroup.long 0x170++0x03
        line.long 0x00 "ARTIEMEM_ROC_IRQ_STAT,Artie Memory read-only-check Interrupt Clearing Status"
            bitfld.long 0x00 8.--9. "STS_ROC_IRQ_FIRED_MASKED,Artie Memory Read-Only-Check IRQ status" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--1. "STS_ROC_IRQ_FIRED,Artie Memory Read-Only-Check IRQ status" "0,1,2,3"

    group.long 0x174++0x03
        line.long 0x00 "MISC0_IRQ_ENA_CTRL,Additional Interrupt Request Control"
            bitfld.long 0x00 0.--5. "CTL_CRCIF_IRQ_ENA,Bit[0]: Set (1) to enable interrupt trigger from CRC bus interface seeing a malformed unaligned bus access" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0x178++0x03
        line.long 0x00 "MISC0_IRQ_CLR_CTRL,Additional Interrupt Clearing Control"
            bitfld.long 0x00 0.--5. "CTL_CRCIF_IRQ_CLR,Write a '1' to corresponding bit to clear the interrupt" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"

    rgroup.long 0x17C++0x03
        line.long 0x00 "MISC0_IRQ_NOMASK_STAT,Additional Interrupt Status with no effect from mask"
            bitfld.long 0x00 8. "STS_RMON_SER_NOMASK,Interrupt sources for Serial reset monitor without masking" "0,1"
            newline
            bitfld.long 0x00 0.--5. "STS_CRCIF_IRQ_FIRED,CRC bus interface IRQ status" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"

    group.long 0x180++0x03
        line.long 0x00 "MISC0_IRQ_MASKED_STAT,Additional Interrupt Status after masking"
            rbitfld.long 0x00 9. "STS_CKSER_DET_FAIL_FLAG,Register indicating clock failure on System Clock" "0,1"
            newline
            bitfld.long 0x00 8. "STS_RMON_SER,Interrupt sources for Serial reset monitor" "0,1"
            newline
            rbitfld.long 0x00 0.--5. "STS_CRCIF_IRQ_FIRED_MASKED,CRC bus interface IRQ status" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0x184++0x03
        line.long 0x00 "HSM_INFO0,Register for HSM 0"
            hexmask.long.byte 0x00 24.--31. 1. "CTL_HSM_INFO_03,Reserved"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CTL_HSM_INFO_02,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "CTL_HSM_INFO_01,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_HSM_INFO_00,Reserved"
    group.long 0x188++0x03
        line.long 0x00 "HSM_INFO1,Register for HSM 1"
            hexmask.long.byte 0x00 24.--31. 1. "CTL_HSM_INFO_13,Reserved"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CTL_HSM_INFO_12,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "CTL_HSM_INFO_11,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_HSM_INFO_10,Reserved"
    group.long 0x18C++0x03
        line.long 0x00 "HSM_INFO2,Register for HSM 2"
            hexmask.long.byte 0x00 24.--31. 1. "CTL_HSM_INFO_23,Reserved"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CTL_HSM_INFO_22,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "CTL_HSM_INFO_21,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_HSM_INFO_20,Reserved"
    group.long 0x190++0x03
        line.long 0x00 "HSM_INFO3,Register for HSM 3"
            hexmask.long.byte 0x00 24.--31. 1. "CTL_HSM_INFO_33,Reserved"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CTL_HSM_INFO_32,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "CTL_HSM_INFO_31,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_HSM_INFO_30,Reserved"
    group.long 0x194++0x03
        line.long 0x00 "HSM_INFO4,Register for HSM 4"
            hexmask.long.byte 0x00 24.--31. 1. "CTL_HSM_INFO_43,Reserved"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CTL_HSM_INFO_42,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "CTL_HSM_INFO_41,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_HSM_INFO_40,Reserved"
    group.long 0x198++0x03
        line.long 0x00 "HSM_INFO5,Register for HSM 5"
            hexmask.long.byte 0x00 24.--31. 1. "CTL_HSM_INFO_53,Reserved"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CTL_HSM_INFO_52,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "CTL_HSM_INFO_51,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_HSM_INFO_50,Reserved"
    group.long 0x19C++0x03
        line.long 0x00 "HSM_INFO6,Register for HSM 6"
            hexmask.long.byte 0x00 24.--31. 1. "CTL_HSM_INFO_63,Reserved"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CTL_HSM_INFO_62,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "CTL_HSM_INFO_61,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_HSM_INFO_60,Reserved"
    group.long 0x1A0++0x03
        line.long 0x00 "HSM_INFO7,Register for HSM 7"
            hexmask.long.byte 0x00 24.--31. 1. "CTL_HSM_INFO_73,Reserved"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "CTL_HSM_INFO_72,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "CTL_HSM_INFO_71,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_HSM_INFO_70,Reserved"
    group.long 0x1A4++0x03
        line.long 0x00 "TIMERS1_TOP_CTRL,General Purpose Timers (second group of 8 timers) Control Register"
            bitfld.long 0x00 8.--11. "CTL_BBE_TIMER_INTR_SEL,Select which of the two groups of timers should drive timer interrupt source of the BBE" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_TIMERS1_PAUSE,Pause Timers count"

    rgroup.long 0x1A8++0x03
        line.long 0x00 "TIMERS1_STAT0,General Purpose Timers (second group of 8 timers) Status Register"
            hexmask.long.byte 0x00 8.--15. 1. "STS_TIMERS1_TOGGLE,Timers Toggled"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "STS_TIMERS1_EN,Timers Enabled"

    group.long 0x1AC++0x03
        line.long 0x00 "R52_BYP_PROT_CTRL,R52 AXI Slave Bypass Control"
            bitfld.long 0x00 24. "CTL_R52_BYP_AWPROTS_ENA,When set the bypass R52 AXI slave Write PROT value and ECC bits are used on the next read transaction" "0,1"
            newline
            bitfld.long 0x00 20.--22. "CTL_R52_BYP_AWPROTS_ECC,When bypassed this is the ECC for R52 AXI slave Write PROT bits" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 16.--18. "CTL_R52_BYP_AWPROTS_VAL,When bypassed this is the value of R52 AXI slave Write PROT bits" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 8. "CTL_R52_BYP_ARPROTS_ENA,When set the bypass R52 AXI slave Read PROT value and ECC bits are used on the next read transaction" "0,1"
            newline
            bitfld.long 0x00 4.--6. "CTL_R52_BYP_ARPROTS_ECC,When bypassed this is the ECC for R52 AXI slave Read PROT bits" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0.--2. "CTL_R52_BYP_ARPROTS_VAL,When bypassed this is the value of R52 AXI slave Read PROT bits" "0: User,1: Privileged,?..."

    rgroup.long 0x1B0++0x03
        line.long 0x00 "R52_BYP_PROT_STAT,R52 AXI Slave Bypass Status"
            bitfld.long 0x00 1. "STS_R52_BYP_AWPROTS_USE,If the bypass for R52 AXI slave Write PROT is being applied then this field shall read as 1 otherwise 0" "0,1"
            newline
            bitfld.long 0x00 0. "STS_R52_BYP_ARPROTS_USE,If the bypass for R52 AXI slave Read PROT is being applied then this field shall read as 1 otherwise 0" "0,1"

    group.long 0x1B4++0x03
        line.long 0x00 "OTP_CTRL18,OTP Control Register 18"
            hexmask.long.byte 0x00 16.--23. 1. "TPRMIN,Timing value for minimum PWRRDY low pulse when Clock Sys has switched to faster frequency"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "TCEBPRY,Timing value for CEB-to-PWRRDY hold time when Clock Sys has switched to faster frequency"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "TPRYCEB,Timing value for PWRRDY-to-CEB setup time when Clock Sys has switched to faster frequency"
    group.long 0x1B8++0x03
        line.long 0x00 "SPARE,Spare Register"
            hexmask.long 0x00 0.--31. 1. "SPARE,Spare registers"
    group.long 0x1BC++0x03
        line.long 0x00 "CTL_LOCK,Lock control"
            hexmask.long 0x00 0.--31. 1. "CTL_ARTIE_LOCK_KEY,Write 0x247136a2 to allow write access to this SFR bank"

    rgroup.long 0x1C0++0x03
        line.long 0x00 "STS_LOCK,Lock status"
            bitfld.long 0x00 4. "STS_HSM_INFO_LOCK_N,Lock status for this HSM info" "0,1"
            newline
            bitfld.long 0x00 0. "STS_ARTIE_LOCK_N,Lock status for this SFR bank" "0,1"
tree.end

tree "ARTIE_NOC ()"
    base ad:0x91910000
    rgroup.long 0x00++0x03
        line.long 0x00 "Id_CoreId,Stores the Core Id and its checksum"
            hexmask.long.tbyte 0x00 8.--31. 1. "CORECHECKSUM,Field containing a checksum of the parameters of the IP"
            hexmask.long.byte 0x00 0.--7. 1. "CORETYPEID,Field identifying the type of IP"
    rgroup.long 0x04++0x03
        line.long 0x00 "Id_RevisionId,Stores a user-defined Id and the software revision"
            hexmask.long.tbyte 0x00 8.--31. 1. "FLEXNOCID,Field containing the build revision of the software used to generate the IP HDL code"
            hexmask.long.byte 0x00 0.--7. 1. "USERID,Field containing a user defined value not used anywhere inside the IP itself"

    group.long 0x08++0x03
        line.long 0x00 "FreezeEn,Register FreezeEn"
            hexmask.long.byte 0x00 0.--7. 1. "FREEZEEN,This 8 bits register enable/disable the Write operation on the RegBank when set"
    group.long 0x0C++0x03
        line.long 0x00 "Clear,clear"
            bitfld.long 0x00 1. "BISTCLEAR,Clear all BIST related registers" "0,1"
            bitfld.long 0x00 0. "MISSIONCLEAR,Clear Mission Faults" "0,1"
    group.long 0x10++0x03
        line.long 0x00 "BistControl,bistcontrol"
            bitfld.long 0x00 24. "AUTOMISSION,BIST AutoMission - Automaticaly go back into mission mode when BIST is done" "0,1"
            hexmask.long.byte 0x00 16.--23. 1. "TIMEOUT1,BIST TimeOut1 value"
            hexmask.long.word 0x00 0.--15. 1. "TIMEOUT0,BIST TimeOut0 value"

    rgroup.long 0x14++0x03
        line.long 0x00 "BistStatus,biststatus"
            bitfld.long 0x00 1. "FAILED,BIST Status (1=Failed)" "0,1"
            bitfld.long 0x00 0. "DONE,BIST Done" "0,1"

    group.long 0x18++0x03
        line.long 0x00 "BistStart,Register BistStart"
            hexmask.long.byte 0x00 0.--7. 1. "BISTSTART,Start BIST mode only with code word 0xB5"
    group.long 0x20++0x03
        line.long 0x00 "FaultTypeReg0,faulttypereg0"
            bitfld.long 0x00 30.--31. "FAULTTYPE15,Fault Type 15" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE14,Fault Type 14" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE13,Fault Type 13" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE12,Fault Type 12" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE11,Fault Type 11" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE10,Fault Type 10" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE9,Fault Type 9" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE8,Fault Type 8" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE7,Fault Type 7" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE6,Fault Type 6" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE5,Fault Type 5" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE4,Fault Type 4" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE3,Fault Type 3" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE2,Fault Type 2" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE1,Fault Type 1" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE0,Fault Type 0" "0,1,2,3"
    group.long 0x24++0x03
        line.long 0x00 "FaultTypeReg1,faulttypereg1"
            bitfld.long 0x00 30.--31. "FAULTTYPE31,Fault Type 31" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE30,Fault Type 30" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE29,Fault Type 29" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE28,Fault Type 28" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE27,Fault Type 27" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE26,Fault Type 26" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE25,Fault Type 25" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE24,Fault Type 24" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE23,Fault Type 23" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE22,Fault Type 22" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE21,Fault Type 21" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE20,Fault Type 20" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE19,Fault Type 19" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE18,Fault Type 18" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE17,Fault Type 17" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE16,Fault Type 16" "0,1,2,3"
    group.long 0x28++0x03
        line.long 0x00 "FaultTypeReg2,faulttypereg2"
            bitfld.long 0x00 30.--31. "FAULTTYPE47,Fault Type 47" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE46,Fault Type 46" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE45,Fault Type 45" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE44,Fault Type 44" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE43,Fault Type 43" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE42,Fault Type 42" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE41,Fault Type 41" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE40,Fault Type 40" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE39,Fault Type 39" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE38,Fault Type 38" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE37,Fault Type 37" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE36,Fault Type 36" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE35,Fault Type 35" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE34,Fault Type 34" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE33,Fault Type 33" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE32,Fault Type 32" "0,1,2,3"
    group.long 0x2C++0x03
        line.long 0x00 "FaultTypeReg3,faulttypereg3"
            bitfld.long 0x00 30.--31. "FAULTTYPE63,Fault Type 63" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE62,Fault Type 62" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE61,Fault Type 61" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE60,Fault Type 60" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE59,Fault Type 59" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE58,Fault Type 58" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE57,Fault Type 57" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE56,Fault Type 56" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE55,Fault Type 55" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE54,Fault Type 54" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE53,Fault Type 53" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE52,Fault Type 52" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE51,Fault Type 51" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE50,Fault Type 50" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE49,Fault Type 49" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE48,Fault Type 48" "0,1,2,3"
    group.long 0x30++0x03
        line.long 0x00 "FaultTypeReg4,faulttypereg4"
            bitfld.long 0x00 30.--31. "FAULTTYPE79,Fault Type 79" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE78,Fault Type 78" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE77,Fault Type 77" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE76,Fault Type 76" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE75,Fault Type 75" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE74,Fault Type 74" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE73,Fault Type 73" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE72,Fault Type 72" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE71,Fault Type 71" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE70,Fault Type 70" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE69,Fault Type 69" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE68,Fault Type 68" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE67,Fault Type 67" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE66,Fault Type 66" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE65,Fault Type 65" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE64,Fault Type 64" "0,1,2,3"
    group.long 0x34++0x03
        line.long 0x00 "FaultTypeReg5,faulttypereg5"
            bitfld.long 0x00 30.--31. "FAULTTYPE95,Fault Type 95" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE94,Fault Type 94" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE93,Fault Type 93" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE92,Fault Type 92" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE91,Fault Type 91" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE90,Fault Type 90" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE89,Fault Type 89" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE88,Fault Type 88" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE87,Fault Type 87" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE86,Fault Type 86" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE85,Fault Type 85" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE84,Fault Type 84" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE83,Fault Type 83" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE82,Fault Type 82" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE81,Fault Type 81" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE80,Fault Type 80" "0,1,2,3"
    group.long 0x38++0x03
        line.long 0x00 "FaultTypeReg6,faulttypereg6"
            bitfld.long 0x00 30.--31. "FAULTTYPE111,Fault Type 111" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE110,Fault Type 110" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE109,Fault Type 109" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE108,Fault Type 108" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE107,Fault Type 107" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE106,Fault Type 106" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE105,Fault Type 105" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE104,Fault Type 104" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE103,Fault Type 103" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE102,Fault Type 102" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE101,Fault Type 101" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE100,Fault Type 100" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE99,Fault Type 99" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE98,Fault Type 98" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE97,Fault Type 97" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE96,Fault Type 96" "0,1,2,3"

    rgroup.long 0x40++0x03
        line.long 0x00 "MissionFault0,missionfault0"
            bitfld.long 0x00 31. "FAULT31,Fault 31" "0,1"
            bitfld.long 0x00 30. "FAULT30,Fault 30" "0,1"
            bitfld.long 0x00 29. "FAULT29,Fault 29" "0,1"
            bitfld.long 0x00 28. "FAULT28,Fault 28" "0,1"
            bitfld.long 0x00 27. "FAULT27,Fault 27" "0,1"
            bitfld.long 0x00 26. "FAULT26,Fault 26" "0,1"
            bitfld.long 0x00 25. "FAULT25,Fault 25" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT24,Fault 24" "0,1"
            bitfld.long 0x00 23. "FAULT23,Fault 23" "0,1"
            bitfld.long 0x00 22. "FAULT22,Fault 22" "0,1"
            bitfld.long 0x00 21. "FAULT21,Fault 21" "0,1"
            bitfld.long 0x00 20. "FAULT20,Fault 20" "0,1"
            bitfld.long 0x00 19. "FAULT19,Fault 19" "0,1"
            bitfld.long 0x00 18. "FAULT18,Fault 18" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT17,Fault 17" "0,1"
            bitfld.long 0x00 16. "FAULT16,Fault 16" "0,1"
            bitfld.long 0x00 15. "FAULT15,Fault 15" "0,1"
            bitfld.long 0x00 14. "FAULT14,Fault 14" "0,1"
            bitfld.long 0x00 13. "FAULT13,Fault 13" "0,1"
            bitfld.long 0x00 12. "FAULT12,Fault 12" "0,1"
            bitfld.long 0x00 11. "FAULT11,Fault 11" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT10,Fault 10" "0,1"
            bitfld.long 0x00 9. "FAULT9,Fault 9" "0,1"
            bitfld.long 0x00 8. "FAULT8,Fault 8" "0,1"
            bitfld.long 0x00 7. "FAULT7,Fault 7" "0,1"
            bitfld.long 0x00 6. "FAULT6,Fault 6" "0,1"
            bitfld.long 0x00 5. "FAULT5,Fault 5" "0,1"
            bitfld.long 0x00 4. "FAULT4,Fault 4" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT3,Fault 3" "0,1"
            bitfld.long 0x00 2. "FAULT2,Fault 2" "0,1"
            bitfld.long 0x00 1. "FAULT1,Fault 1" "0,1"
            bitfld.long 0x00 0. "FAULT0,Fault 0" "0,1"
    rgroup.long 0x44++0x03
        line.long 0x00 "MissionFault1,missionfault1"
            bitfld.long 0x00 31. "FAULT63,Fault 63" "0,1"
            bitfld.long 0x00 30. "FAULT62,Fault 62" "0,1"
            bitfld.long 0x00 29. "FAULT61,Fault 61" "0,1"
            bitfld.long 0x00 28. "FAULT60,Fault 60" "0,1"
            bitfld.long 0x00 27. "FAULT59,Fault 59" "0,1"
            bitfld.long 0x00 26. "FAULT58,Fault 58" "0,1"
            bitfld.long 0x00 25. "FAULT57,Fault 57" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT56,Fault 56" "0,1"
            bitfld.long 0x00 23. "FAULT55,Fault 55" "0,1"
            bitfld.long 0x00 22. "FAULT54,Fault 54" "0,1"
            bitfld.long 0x00 21. "FAULT53,Fault 53" "0,1"
            bitfld.long 0x00 20. "FAULT52,Fault 52" "0,1"
            bitfld.long 0x00 19. "FAULT51,Fault 51" "0,1"
            bitfld.long 0x00 18. "FAULT50,Fault 50" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT49,Fault 49" "0,1"
            bitfld.long 0x00 16. "FAULT48,Fault 48" "0,1"
            bitfld.long 0x00 15. "FAULT47,Fault 47" "0,1"
            bitfld.long 0x00 14. "FAULT46,Fault 46" "0,1"
            bitfld.long 0x00 13. "FAULT45,Fault 45" "0,1"
            bitfld.long 0x00 12. "FAULT44,Fault 44" "0,1"
            bitfld.long 0x00 11. "FAULT43,Fault 43" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT42,Fault 42" "0,1"
            bitfld.long 0x00 9. "FAULT41,Fault 41" "0,1"
            bitfld.long 0x00 8. "FAULT40,Fault 40" "0,1"
            bitfld.long 0x00 7. "FAULT39,Fault 39" "0,1"
            bitfld.long 0x00 6. "FAULT38,Fault 38" "0,1"
            bitfld.long 0x00 5. "FAULT37,Fault 37" "0,1"
            bitfld.long 0x00 4. "FAULT36,Fault 36" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT35,Fault 35" "0,1"
            bitfld.long 0x00 2. "FAULT34,Fault 34" "0,1"
            bitfld.long 0x00 1. "FAULT33,Fault 33" "0,1"
            bitfld.long 0x00 0. "FAULT32,Fault 32" "0,1"
    rgroup.long 0x48++0x03
        line.long 0x00 "MissionFault2,missionfault2"
            bitfld.long 0x00 31. "FAULT95,Fault 95" "0,1"
            bitfld.long 0x00 30. "FAULT94,Fault 94" "0,1"
            bitfld.long 0x00 29. "FAULT93,Fault 93" "0,1"
            bitfld.long 0x00 28. "FAULT92,Fault 92" "0,1"
            bitfld.long 0x00 27. "FAULT91,Fault 91" "0,1"
            bitfld.long 0x00 26. "FAULT90,Fault 90" "0,1"
            bitfld.long 0x00 25. "FAULT89,Fault 89" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT88,Fault 88" "0,1"
            bitfld.long 0x00 23. "FAULT87,Fault 87" "0,1"
            bitfld.long 0x00 22. "FAULT86,Fault 86" "0,1"
            bitfld.long 0x00 21. "FAULT85,Fault 85" "0,1"
            bitfld.long 0x00 20. "FAULT84,Fault 84" "0,1"
            bitfld.long 0x00 19. "FAULT83,Fault 83" "0,1"
            bitfld.long 0x00 18. "FAULT82,Fault 82" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT81,Fault 81" "0,1"
            bitfld.long 0x00 16. "FAULT80,Fault 80" "0,1"
            bitfld.long 0x00 15. "FAULT79,Fault 79" "0,1"
            bitfld.long 0x00 14. "FAULT78,Fault 78" "0,1"
            bitfld.long 0x00 13. "FAULT77,Fault 77" "0,1"
            bitfld.long 0x00 12. "FAULT76,Fault 76" "0,1"
            bitfld.long 0x00 11. "FAULT75,Fault 75" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT74,Fault 74" "0,1"
            bitfld.long 0x00 9. "FAULT73,Fault 73" "0,1"
            bitfld.long 0x00 8. "FAULT72,Fault 72" "0,1"
            bitfld.long 0x00 7. "FAULT71,Fault 71" "0,1"
            bitfld.long 0x00 6. "FAULT70,Fault 70" "0,1"
            bitfld.long 0x00 5. "FAULT69,Fault 69" "0,1"
            bitfld.long 0x00 4. "FAULT68,Fault 68" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT67,Fault 67" "0,1"
            bitfld.long 0x00 2. "FAULT66,Fault 66" "0,1"
            bitfld.long 0x00 1. "FAULT65,Fault 65" "0,1"
            bitfld.long 0x00 0. "FAULT64,Fault 64" "0,1"
    rgroup.long 0x4C++0x03
        line.long 0x00 "MissionFault3,missionfault3"
            bitfld.long 0x00 31. "CONSTANT_0_127,Reserved bit" "0,1"
            bitfld.long 0x00 30. "CONSTANT_0_126,Reserved bit" "0,1"
            bitfld.long 0x00 29. "CONSTANT_0_125,Reserved bit" "0,1"
            bitfld.long 0x00 28. "CONSTANT_0_124,Reserved bit" "0,1"
            bitfld.long 0x00 27. "CONSTANT_0_123,Reserved bit" "0,1"
            bitfld.long 0x00 26. "CONSTANT_0_122,Reserved bit" "0,1"
            bitfld.long 0x00 25. "CONSTANT_0_121,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 24. "CONSTANT_0_120,Reserved bit" "0,1"
            bitfld.long 0x00 23. "CONSTANT_0_119,Reserved bit" "0,1"
            bitfld.long 0x00 22. "CONSTANT_0_118,Reserved bit" "0,1"
            bitfld.long 0x00 21. "CONSTANT_0_117,Reserved bit" "0,1"
            bitfld.long 0x00 20. "CONSTANT_0_116,Reserved bit" "0,1"
            bitfld.long 0x00 19. "CONSTANT_0_115,Reserved bit" "0,1"
            bitfld.long 0x00 18. "CONSTANT_0_114,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 17. "CONSTANT_0_113,Reserved bit" "0,1"
            bitfld.long 0x00 16. "CONSTANT_0_112,Reserved bit" "0,1"
            bitfld.long 0x00 15. "FAULT111,Fault 111" "0,1"
            bitfld.long 0x00 14. "FAULT110,Fault 110" "0,1"
            bitfld.long 0x00 13. "FAULT109,Fault 109" "0,1"
            bitfld.long 0x00 12. "FAULT108,Fault 108" "0,1"
            bitfld.long 0x00 11. "FAULT107,Fault 107" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT106,Fault 106" "0,1"
            bitfld.long 0x00 9. "FAULT105,Fault 105" "0,1"
            bitfld.long 0x00 8. "FAULT104,Fault 104" "0,1"
            bitfld.long 0x00 7. "FAULT103,Fault 103" "0,1"
            bitfld.long 0x00 6. "FAULT102,Fault 102" "0,1"
            bitfld.long 0x00 5. "FAULT101,Fault 101" "0,1"
            bitfld.long 0x00 4. "FAULT100,Fault 100" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT99,Fault 99" "0,1"
            bitfld.long 0x00 2. "FAULT98,Fault 98" "0,1"
            bitfld.long 0x00 1. "FAULT97,Fault 97" "0,1"
            bitfld.long 0x00 0. "FAULT96,Fault 96" "0,1"
    rgroup.long 0x50++0x03
        line.long 0x00 "LatentInternalFault,latentinternalfault"
            bitfld.long 0x00 2. "CRITORTREE,Latent internal Fault in Crit OR Tree" "0,1"
            bitfld.long 0x00 1. "MAJORTREE,Latent internal Fault in Maj OR Tree" "0,1"
            bitfld.long 0x00 0. "MINORTREE,Latent internal Fault in Min OR Tree" "0,1"
    rgroup.long 0x54++0x03
        line.long 0x00 "LatentComFault0,latentcomfault0"
            bitfld.long 0x00 31. "FAULT31,Latent communication Fault 31" "0,1"
            bitfld.long 0x00 30. "FAULT30,Latent communication Fault 30" "0,1"
            bitfld.long 0x00 29. "FAULT29,Latent communication Fault 29" "0,1"
            bitfld.long 0x00 28. "FAULT28,Latent communication Fault 28" "0,1"
            bitfld.long 0x00 27. "FAULT27,Latent communication Fault 27" "0,1"
            bitfld.long 0x00 26. "FAULT26,Latent communication Fault 26" "0,1"
            bitfld.long 0x00 25. "FAULT25,Latent communication Fault 25" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT24,Latent communication Fault 24" "0,1"
            bitfld.long 0x00 23. "FAULT23,Latent communication Fault 23" "0,1"
            bitfld.long 0x00 22. "FAULT22,Latent communication Fault 22" "0,1"
            bitfld.long 0x00 21. "FAULT21,Latent communication Fault 21" "0,1"
            bitfld.long 0x00 20. "FAULT20,Latent communication Fault 20" "0,1"
            bitfld.long 0x00 19. "FAULT19,Latent communication Fault 19" "0,1"
            bitfld.long 0x00 18. "FAULT18,Latent communication Fault 18" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT17,Latent communication Fault 17" "0,1"
            bitfld.long 0x00 16. "FAULT16,Latent communication Fault 16" "0,1"
            bitfld.long 0x00 15. "FAULT15,Latent communication Fault 15" "0,1"
            bitfld.long 0x00 14. "FAULT14,Latent communication Fault 14" "0,1"
            bitfld.long 0x00 13. "FAULT13,Latent communication Fault 13" "0,1"
            bitfld.long 0x00 12. "FAULT12,Latent communication Fault 12" "0,1"
            bitfld.long 0x00 11. "FAULT11,Latent communication Fault 11" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT10,Latent communication Fault 10" "0,1"
            bitfld.long 0x00 9. "FAULT9,Latent communication Fault 9" "0,1"
            bitfld.long 0x00 8. "FAULT8,Latent communication Fault 8" "0,1"
            bitfld.long 0x00 7. "FAULT7,Latent communication Fault 7" "0,1"
            bitfld.long 0x00 6. "FAULT6,Latent communication Fault 6" "0,1"
            bitfld.long 0x00 5. "FAULT5,Latent communication Fault 5" "0,1"
            bitfld.long 0x00 4. "FAULT4,Latent communication Fault 4" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT3,Latent communication Fault 3" "0,1"
            bitfld.long 0x00 2. "FAULT2,Latent communication Fault 2" "0,1"
            bitfld.long 0x00 1. "FAULT1,Latent communication Fault 1" "0,1"
            bitfld.long 0x00 0. "FAULT0,Latent communication Fault 0" "0,1"
    rgroup.long 0x58++0x03
        line.long 0x00 "LatentComFault1,latentcomfault1"
            bitfld.long 0x00 31. "FAULT63,Latent communication Fault 63" "0,1"
            bitfld.long 0x00 30. "FAULT62,Latent communication Fault 62" "0,1"
            bitfld.long 0x00 29. "FAULT61,Latent communication Fault 61" "0,1"
            bitfld.long 0x00 28. "FAULT60,Latent communication Fault 60" "0,1"
            bitfld.long 0x00 27. "FAULT59,Latent communication Fault 59" "0,1"
            bitfld.long 0x00 26. "FAULT58,Latent communication Fault 58" "0,1"
            bitfld.long 0x00 25. "FAULT57,Latent communication Fault 57" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT56,Latent communication Fault 56" "0,1"
            bitfld.long 0x00 23. "FAULT55,Latent communication Fault 55" "0,1"
            bitfld.long 0x00 22. "FAULT54,Latent communication Fault 54" "0,1"
            bitfld.long 0x00 21. "FAULT53,Latent communication Fault 53" "0,1"
            bitfld.long 0x00 20. "FAULT52,Latent communication Fault 52" "0,1"
            bitfld.long 0x00 19. "FAULT51,Latent communication Fault 51" "0,1"
            bitfld.long 0x00 18. "FAULT50,Latent communication Fault 50" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT49,Latent communication Fault 49" "0,1"
            bitfld.long 0x00 16. "FAULT48,Latent communication Fault 48" "0,1"
            bitfld.long 0x00 15. "FAULT47,Latent communication Fault 47" "0,1"
            bitfld.long 0x00 14. "FAULT46,Latent communication Fault 46" "0,1"
            bitfld.long 0x00 13. "FAULT45,Latent communication Fault 45" "0,1"
            bitfld.long 0x00 12. "FAULT44,Latent communication Fault 44" "0,1"
            bitfld.long 0x00 11. "FAULT43,Latent communication Fault 43" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT42,Latent communication Fault 42" "0,1"
            bitfld.long 0x00 9. "FAULT41,Latent communication Fault 41" "0,1"
            bitfld.long 0x00 8. "FAULT40,Latent communication Fault 40" "0,1"
            bitfld.long 0x00 7. "FAULT39,Latent communication Fault 39" "0,1"
            bitfld.long 0x00 6. "FAULT38,Latent communication Fault 38" "0,1"
            bitfld.long 0x00 5. "FAULT37,Latent communication Fault 37" "0,1"
            bitfld.long 0x00 4. "FAULT36,Latent communication Fault 36" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT35,Latent communication Fault 35" "0,1"
            bitfld.long 0x00 2. "FAULT34,Latent communication Fault 34" "0,1"
            bitfld.long 0x00 1. "FAULT33,Latent communication Fault 33" "0,1"
            bitfld.long 0x00 0. "FAULT32,Latent communication Fault 32" "0,1"
    rgroup.long 0x5C++0x03
        line.long 0x00 "LatentComFault2,latentcomfault2"
            bitfld.long 0x00 31. "FAULT95,Latent communication Fault 95" "0,1"
            bitfld.long 0x00 30. "FAULT94,Latent communication Fault 94" "0,1"
            bitfld.long 0x00 29. "FAULT93,Latent communication Fault 93" "0,1"
            bitfld.long 0x00 28. "FAULT92,Latent communication Fault 92" "0,1"
            bitfld.long 0x00 27. "FAULT91,Latent communication Fault 91" "0,1"
            bitfld.long 0x00 26. "FAULT90,Latent communication Fault 90" "0,1"
            bitfld.long 0x00 25. "FAULT89,Latent communication Fault 89" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT88,Latent communication Fault 88" "0,1"
            bitfld.long 0x00 23. "FAULT87,Latent communication Fault 87" "0,1"
            bitfld.long 0x00 22. "FAULT86,Latent communication Fault 86" "0,1"
            bitfld.long 0x00 21. "FAULT85,Latent communication Fault 85" "0,1"
            bitfld.long 0x00 20. "FAULT84,Latent communication Fault 84" "0,1"
            bitfld.long 0x00 19. "FAULT83,Latent communication Fault 83" "0,1"
            bitfld.long 0x00 18. "FAULT82,Latent communication Fault 82" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT81,Latent communication Fault 81" "0,1"
            bitfld.long 0x00 16. "FAULT80,Latent communication Fault 80" "0,1"
            bitfld.long 0x00 15. "FAULT79,Latent communication Fault 79" "0,1"
            bitfld.long 0x00 14. "FAULT78,Latent communication Fault 78" "0,1"
            bitfld.long 0x00 13. "FAULT77,Latent communication Fault 77" "0,1"
            bitfld.long 0x00 12. "FAULT76,Latent communication Fault 76" "0,1"
            bitfld.long 0x00 11. "FAULT75,Latent communication Fault 75" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT74,Latent communication Fault 74" "0,1"
            bitfld.long 0x00 9. "FAULT73,Latent communication Fault 73" "0,1"
            bitfld.long 0x00 8. "FAULT72,Latent communication Fault 72" "0,1"
            bitfld.long 0x00 7. "FAULT71,Latent communication Fault 71" "0,1"
            bitfld.long 0x00 6. "FAULT70,Latent communication Fault 70" "0,1"
            bitfld.long 0x00 5. "FAULT69,Latent communication Fault 69" "0,1"
            bitfld.long 0x00 4. "FAULT68,Latent communication Fault 68" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT67,Latent communication Fault 67" "0,1"
            bitfld.long 0x00 2. "FAULT66,Latent communication Fault 66" "0,1"
            bitfld.long 0x00 1. "FAULT65,Latent communication Fault 65" "0,1"
            bitfld.long 0x00 0. "FAULT64,Latent communication Fault 64" "0,1"
    rgroup.long 0x60++0x03
        line.long 0x00 "LatentComFault3,latentcomfault3"
            bitfld.long 0x00 31. "CONSTANT_0_127,Reserved bit" "0,1"
            bitfld.long 0x00 30. "CONSTANT_0_126,Reserved bit" "0,1"
            bitfld.long 0x00 29. "CONSTANT_0_125,Reserved bit" "0,1"
            bitfld.long 0x00 28. "CONSTANT_0_124,Reserved bit" "0,1"
            bitfld.long 0x00 27. "CONSTANT_0_123,Reserved bit" "0,1"
            bitfld.long 0x00 26. "CONSTANT_0_122,Reserved bit" "0,1"
            bitfld.long 0x00 25. "CONSTANT_0_121,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 24. "CONSTANT_0_120,Reserved bit" "0,1"
            bitfld.long 0x00 23. "CONSTANT_0_119,Reserved bit" "0,1"
            bitfld.long 0x00 22. "CONSTANT_0_118,Reserved bit" "0,1"
            bitfld.long 0x00 21. "CONSTANT_0_117,Reserved bit" "0,1"
            bitfld.long 0x00 20. "CONSTANT_0_116,Reserved bit" "0,1"
            bitfld.long 0x00 19. "CONSTANT_0_115,Reserved bit" "0,1"
            bitfld.long 0x00 18. "CONSTANT_0_114,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 17. "CONSTANT_0_113,Reserved bit" "0,1"
            bitfld.long 0x00 16. "CONSTANT_0_112,Reserved bit" "0,1"
            bitfld.long 0x00 15. "CONSTANT_0_111,Reserved bit" "0,1"
            bitfld.long 0x00 14. "FAULT110,Latent communication Fault 110" "0,1"
            bitfld.long 0x00 13. "FAULT109,Latent communication Fault 109" "0,1"
            bitfld.long 0x00 12. "FAULT108,Latent communication Fault 108" "0,1"
            bitfld.long 0x00 11. "FAULT107,Latent communication Fault 107" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT106,Latent communication Fault 106" "0,1"
            bitfld.long 0x00 9. "FAULT105,Latent communication Fault 105" "0,1"
            bitfld.long 0x00 8. "FAULT104,Latent communication Fault 104" "0,1"
            bitfld.long 0x00 7. "FAULT103,Latent communication Fault 103" "0,1"
            bitfld.long 0x00 6. "FAULT102,Latent communication Fault 102" "0,1"
            bitfld.long 0x00 5. "FAULT101,Latent communication Fault 101" "0,1"
            bitfld.long 0x00 4. "FAULT100,Latent communication Fault 100" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT99,Latent communication Fault 99" "0,1"
            bitfld.long 0x00 2. "FAULT98,Latent communication Fault 98" "0,1"
            bitfld.long 0x00 1. "FAULT97,Latent communication Fault 97" "0,1"
            bitfld.long 0x00 0. "FAULT96,Latent communication Fault 96" "0,1"
tree.end

tree "AUX_ACC ()"
    base ad:0x84402000
    group.long 0x00++0x03
        line.long 0x00 "AUX_ACC_BUF0_BLOCK_EXP_CTRL0,Aux Accelerator In Buf0 Block Exponent"
            bitfld.long 0x00 0.--5. "CTL_BUF0_BLOCK_EXP,Block exponent associated with Input Buffer 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0x10++0x03
        line.long 0x00 "AUX_ACC_BUF1_BLOCK_EXP_CTRL0,Aux Accelerator In Buf1 Block Exponent"
            bitfld.long 0x00 0.--5. "CTL_BUF1_BLOCK_EXP,Block exponent associated with Input Buffer 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0x20++0x03
        line.long 0x00 "AUX_ACC_BUF2_BLOCK_EXP_CTRL0,Aux Accelerator In Buf2 Block Exponent"
            bitfld.long 0x00 0.--5. "CTL_BUF2_BLOCK_EXP,Block exponent associated with Input Buffer 2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0x30++0x03
        line.long 0x00 "AUX_ACC_BUF3_BLOCK_EXP_CTRL0,Aux Accelerator In Buf3 Block Exponent"
            bitfld.long 0x00 0.--5. "CTL_BUF3_BLOCK_EXP,Block exponent associated with Input Buffer 3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0x40++0x03
        line.long 0x00 "AUX_ACC_BUFV_BLOCK_EXP_CTRL0,Aux Accelerator Virtual In Buf Block Exponent"
            bitfld.long 0x00 0.--5. "CTL_BUFV_BLOCK_EXP,Virtual Buf Block Exponenent where write pointer corresponds to the one used for Virutal In Buffer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0x50++0x03
        line.long 0x00 "AUX_ACC_MISC_CTRL0,Aux Accelerator Misc"
            bitfld.long 0x00 16. "CTL_INBUF_ENDY," "0,1"
            newline
            bitfld.long 0x00 12.--13. "CTL_NUM_GUARD,Number of Guard cells before and after CUT" "0,1,2,3"
            newline
            bitfld.long 0x00 8.--9. "CTL_SORT_SIZE,0:16 1:32 2:64 3:128 samples in the sorted list" "0,1,2,3"
            newline
            bitfld.long 0x00 4.--5. "CTL_BIN_SIZE,0:128 1:256 2:512 3:1024 samples long" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--1. "CTL_SAMP_MODE,0:16-bit samples do log2 1:16-bit samples skip log2 else:32-bit samples do log2" "0,1,2,3"
    group.long 0x54++0x03
        line.long 0x00 "AUX_ACC_MISC_CTRL1,Aux Accelerator Misc"
            bitfld.long 0x00 0. "CTL_SW_START,Toggle to '1' to start CFAR datapath" "0,1"
    group.long 0x58++0x03
        line.long 0x00 "AUX_ACC_SORT_CTRL0,Aux Accelerator Sort Control"
            bitfld.long 0x00 16. "CTL_SORT_SEL_REC,Select which sorted sample to record" "0: Bth,1: Ath"
            newline
            hexmask.long.byte 0x00 8.--14. 1. "CTL_SORT_SEL_B,Select Sorted List rank index for Output B"
            newline
            hexmask.long.byte 0x00 0.--6. 1. "CTL_SORT_SEL_A,Select Sorted List rank index for Output A"
    group.long 0x5C++0x03
        line.long 0x00 "AUX_ACC_BIN_PTR_CTRL0,Aux Accelerator Bin Pointer Control"
            bitfld.long 0x00 28. "CTL_BIN_WR_PUSH,Toggle to '1' then back to '0' to push value into accelerator hardware" "0,1"
            newline
            bitfld.long 0x00 24.--25. "CTL_BIN_WR_PTR,Value of Write Bin Pointer" "0,1,2,3"
            newline
            bitfld.long 0x00 20. "CTL_BIN_NEXT_PUSH,Toggle to '1' then back to '0' to push value into accelerator hardware" "0,1"
            newline
            bitfld.long 0x00 16.--17. "CTL_BIN_NEXT_PTR,Value of Next Bin Pointer" "0,1,2,3"
            newline
            bitfld.long 0x00 12. "CTL_BIN_CURR_PUSH,Toggle to '1' then back to '0' to push value into accelerator hardware" "0,1"
            newline
            bitfld.long 0x00 8.--9. "CTL_BIN_CURR_PTR,Value of Current Bin Pointer" "0,1,2,3"
            newline
            bitfld.long 0x00 4. "CTL_BIN_PREV_PUSH,Toggle to '1' then back to '0' to push value into accelerator hardware" "0,1"
            newline
            bitfld.long 0x00 0.--1. "CTL_BIN_PREV_PTR,Value of Previous Bin Pointer" "0,1,2,3"

    rgroup.long 0x60++0x03
        line.long 0x00 "AUX_ACC_BIN_STAT0,Aux Accelerator Bin Pointer Status"
            bitfld.long 0x00 24.--25. "STS_BIN_WR_PTR,Used value of write bin pointer" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "STS_BIN_NEXT_PTR,Used value of next bin pointer" "0,1,2,3"
            newline
            bitfld.long 0x00 8.--9. "STS_BIN_CURR_PTR,Used value of current bin pointer" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--1. "STS_BIN_PREV_PTR,Used value of previous bin pointer" "0,1,2,3"

    group.long 0x64++0x03
        line.long 0x00 "AUX_ACC_AUTO_CTRL0,Aux Accelerator Bin Pointer Control"
            bitfld.long 0x00 2. "CTL_AUTO_ADV_WR,If set to '1' datapath automatically advances the Write Doppler Bin Pointers upon completing writing of the 'virtual' Doppler Bin address space" "0,1"
            newline
            bitfld.long 0x00 1. "CTL_AUTO_ADV_RD,If set to '1' datapath automatically advances the 'prev' 'curr' and 'next' Doppler Bin Pointers upon completing processing of one Doppler Bin" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_AUTO_START_EN,If set to '1' datapath automatically starts upon writing to" "0,1"
    group.long 0x68++0x03
        line.long 0x00 "AUX_ACC_PRE_LUT_CTRL0,Aux Accelerator Pre-LUT Processing Control"
            hexmask.long.word 0x00 16.--31. 1. "CTL_PRE_LUT_ADD,Pre-LUT operation addend"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_PRE_LUT_MUL,Pre-LUT operation multiplier"
    group.long 0x6C++0x03
        line.long 0x00 "AUX_ACC_POST_LUT_CTRL0,Aux Accelerator Post-LUT Processing Control"
            bitfld.long 0x00 4. "CTL_THR_SEL_REC,Select which Threshold output to record" "0: raw LUT output,1: After combining with X1"
            newline
            bitfld.long 0x00 0. "CTL_SEL_X1,Select either Ath or Bth sample to use to add to LUT output" "0: Bth,1: Ath"
    group.long 0x70++0x03
        line.long 0x00 "AUX_ACC_2D_MAX_CTRL0,Aux Accelerator 2D Max Control"
            bitfld.long 0x00 9. "CTL_CMEQ_NEXT_EN,If set to '1' enable comparison of sample being equal to corresponding sample from 'next' Doppler Bin" "0,1"
            newline
            bitfld.long 0x00 8. "CTL_CMEQ_PREV_EN,If set to '1' enable comparison of sample being equal to corresponding sample from 'previous' Doppler Bin" "0,1"
            newline
            bitfld.long 0x00 2.--5. "CTL_COMP_CURR_EN,Bit[0] enables compare of sample[n] being greater than sample[n-1]" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 1. "CTL_COMP_NEXT_EN,If set to '1' enable comparison of sample with corresponding sample from 'next' Doppler Bin" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_COMP_PREV_EN,If set to '1' enable comparison of sample with corresponding sample from 'previous' Doppler Bin" "0,1"

    rgroup.long 0x74++0x03
        line.long 0x00 "AUX_ACC_MISC_STAT0,Aux Accelerator Miscellaneous Status"
            bitfld.long 0x00 17. "STS_AMEM_IDLE,Datapath AHB Interface idle" "0,1"
            newline
            bitfld.long 0x00 16. "STS_DP_READY,Datapath ready for next block" "0,1"
            newline
            hexmask.long.word 0x00 0.--10. 1. "STS_NUM_COMP,Number of CUT values that were greater than the threshold and greater than their 2-D neighbors (post-mask)"

    group.long 0x78++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL00,LUT Entries 0 And 1"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY001,LUT Entry 001"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY000,LUT Entry 000"
    group.long 0x7C++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL01,LUT Entries 2 And 3"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY003,LUT Entry 003"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY002,LUT Entry 002"
    group.long 0x80++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL02,LUT Entries 4 And 5"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY005,LUT Entry 005"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY004,LUT Entry 004"
    group.long 0x84++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL03,LUT Entries 6 And 7"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY007,LUT Entry 007"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY006,LUT Entry 006"
    group.long 0x88++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL04,LUT Entries 8 And 9"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY009,LUT Entry 009"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY008,LUT Entry 008"
    group.long 0x8C++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL05,LUT Entries 10 And 11"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY011,LUT Entry 011"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY010,LUT Entry 010"
    group.long 0x90++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL06,LUT Entries 12 And 13"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY013,LUT Entry 013"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY012,LUT Entry 012"
    group.long 0x94++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL07,LUT Entries 14 And 15"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY015,LUT Entry 015"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY014,LUT Entry 014"
    group.long 0x98++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL08,LUT Entries 16 And 17"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY017,LUT Entry 017"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY016,LUT Entry 016"
    group.long 0x9C++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL09,LUT Entries 18 And 19"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY019,LUT Entry 019"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY018,LUT Entry 018"
    group.long 0xA0++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL10,LUT Entries 20 And 21"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY021,LUT Entry 021"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY020,LUT Entry 020"
    group.long 0xA4++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL11,LUT Entries 22 And 23"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY023,LUT Entry 023"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY022,LUT Entry 022"
    group.long 0xA8++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL12,LUT Entries 24 And 25"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY025,LUT Entry 025"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY024,LUT Entry 024"
    group.long 0xAC++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL13,LUT Entries 26 And 27"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY027,LUT Entry 027"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY026,LUT Entry 026"
    group.long 0xB0++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL14,LUT Entries 28 And 29"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY029,LUT Entry 029"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY028,LUT Entry 028"
    group.long 0xB4++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL15,LUT Entries 30 And 31"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY031,LUT Entry 031"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY030,LUT Entry 030"
    group.long 0xB8++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL16,LUT Entries 32 And 33"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY033,LUT Entry 033"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY032,LUT Entry 032"
    group.long 0xBC++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL17,LUT Entries 34 And 35"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY035,LUT Entry 035"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY034,LUT Entry 034"
    group.long 0xC0++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL18,LUT Entries 36 And 37"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY037,LUT Entry 037"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY036,LUT Entry 036"
    group.long 0xC4++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL19,LUT Entries 38 And 39"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY039,LUT Entry 039"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY038,LUT Entry 038"
    group.long 0xC8++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL20,LUT Entries 40 And 41"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY041,LUT Entry 041"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY040,LUT Entry 040"
    group.long 0xCC++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL21,LUT Entries 42 And 43"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY043,LUT Entry 043"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY042,LUT Entry 042"
    group.long 0xD0++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL22,LUT Entries 44 And 45"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY045,LUT Entry 045"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY044,LUT Entry 044"
    group.long 0xD4++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL23,LUT Entries 46 And 47"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY047,LUT Entry 047"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY046,LUT Entry 046"
    group.long 0xD8++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL24,LUT Entries 48 And 49"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY049,LUT Entry 049"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY048,LUT Entry 048"
    group.long 0xDC++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL25,LUT Entries 50 And 51"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY051,LUT Entry 051"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY050,LUT Entry 050"
    group.long 0xE0++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL26,LUT Entries 52 And 53"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY053,LUT Entry 053"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY052,LUT Entry 052"
    group.long 0xE4++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL27,LUT Entries 54 And 55"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY055,LUT Entry 055"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY054,LUT Entry 054"
    group.long 0xE8++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL28,LUT Entries 56 And 57"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY057,LUT Entry 057"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY056,LUT Entry 056"
    group.long 0xEC++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL29,LUT Entries 58 And 59"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY059,LUT Entry 059"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY058,LUT Entry 058"
    group.long 0xF0++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL30,LUT Entries 60 And 61"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY061,LUT Entry 061"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY060,LUT Entry 060"
    group.long 0xF4++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL31,LUT Entries 62 And 63"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY063,LUT Entry 063"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY062,LUT Entry 062"
    group.long 0xF8++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL32,LUT Entries 64 And 65"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY065,LUT Entry 065"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY064,LUT Entry 064"
    group.long 0xFC++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL33,LUT Entries 66 And 67"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY067,LUT Entry 067"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY066,LUT Entry 066"
    group.long 0x100++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL34,LUT Entries 68 And 69"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY069,LUT Entry 069"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY068,LUT Entry 068"
    group.long 0x104++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL35,LUT Entries 70 And 71"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY071,LUT Entry 071"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY070,LUT Entry 070"
    group.long 0x108++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL36,LUT Entries 72 And 73"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY073,LUT Entry 073"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY072,LUT Entry 072"
    group.long 0x10C++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL37,LUT Entries 74 And 75"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY075,LUT Entry 075"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY074,LUT Entry 074"
    group.long 0x110++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL38,LUT Entries 76 And 77"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY077,LUT Entry 077"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY076,LUT Entry 076"
    group.long 0x114++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL39,LUT Entries 78 And 79"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY079,LUT Entry 079"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY078,LUT Entry 078"
    group.long 0x118++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL40,LUT Entries 80 And 81"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY081,LUT Entry 081"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY080,LUT Entry 080"
    group.long 0x11C++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL41,LUT Entries 82 And 83"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY083,LUT Entry 083"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY082,LUT Entry 082"
    group.long 0x120++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL42,LUT Entries 84 And 85"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY085,LUT Entry 085"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY084,LUT Entry 084"
    group.long 0x124++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL43,LUT Entries 86 And 87"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY087,LUT Entry 087"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY086,LUT Entry 086"
    group.long 0x128++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL44,LUT Entries 88 And 89"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY089,LUT Entry 089"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY088,LUT Entry 088"
    group.long 0x12C++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL45,LUT Entries 90 And 91"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY091,LUT Entry 091"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY090,LUT Entry 090"
    group.long 0x130++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL46,LUT Entries 92 And 93"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY093,LUT Entry 093"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY092,LUT Entry 092"
    group.long 0x134++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL47,LUT Entries 94 And 95"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY095,LUT Entry 095"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY094,LUT Entry 094"
    group.long 0x138++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL48,LUT Entries 96 And 97"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY097,LUT Entry 097"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY096,LUT Entry 096"
    group.long 0x13C++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL49,LUT Entries 98 And 99"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY099,LUT Entry 099"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY098,LUT Entry 098"
    group.long 0x140++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL50,LUT Entries 100 And 101"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY101,LUT Entry 101"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY100,LUT Entry 100"
    group.long 0x144++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL51,LUT Entries 102 And 103"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY103,LUT Entry 103"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY102,LUT Entry 102"
    group.long 0x148++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL52,LUT Entries 104 And 105"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY105,LUT Entry 105"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY104,LUT Entry 104"
    group.long 0x14C++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL53,LUT Entries 106 And 107"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY107,LUT Entry 107"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY106,LUT Entry 106"
    group.long 0x150++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL54,LUT Entries 108 And 109"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY109,LUT Entry 109"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY108,LUT Entry 108"
    group.long 0x154++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL55,LUT Entries 110 And 111"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY111,LUT Entry 111"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY110,LUT Entry 110"
    group.long 0x158++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL56,LUT Entries 112 And 113"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY113,LUT Entry 113"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY112,LUT Entry 112"
    group.long 0x15C++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL57,LUT Entries 114 And 115"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY115,LUT Entry 115"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY114,LUT Entry 114"
    group.long 0x160++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL58,LUT Entries 116 And 117"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY117,LUT Entry 117"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY116,LUT Entry 116"
    group.long 0x164++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL59,LUT Entries 118 And 119"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY119,LUT Entry 119"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY118,LUT Entry 118"
    group.long 0x168++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL60,LUT Entries 120 And 121"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY121,LUT Entry 121"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY120,LUT Entry 120"
    group.long 0x16C++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL61,LUT Entries 122 And 123"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY123,LUT Entry 123"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY122,LUT Entry 122"
    group.long 0x170++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL62,LUT Entries 124 And 125"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY125,LUT Entry 125"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY124,LUT Entry 124"
    group.long 0x174++0x03
        line.long 0x00 "AUX_ACC_LUT_CTRL63,LUT Entries 126 And 127"
            hexmask.long.word 0x00 16.--31. 1. "CTL_LUT_ENTRY127,LUT Entry 127"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_LUT_ENTRY126,LUT Entry 126"
    group.long 0x178++0x03
        line.long 0x00 "AUX_ACC_ECC_CTRL0,Aux Accelerator ECC Control Reg 0"
            hexmask.long.word 0x00 16.--24. 1. "CTL_OTBUF_ENC_PARITY,Bypass parity bits for OtBuf ECC encoder"
            newline
            hexmask.long.word 0x00 4.--12. 1. "CTL_INBUF_ENC_PARITY,Bypass parity bits for InBuf ECC encoder"
            newline
            bitfld.long 0x00 3. "CTL_OTBUF_DEC_BYP,If set (1) OtBuf ECC decoder is bypassed" "0,1"
            newline
            bitfld.long 0x00 2. "CTL_OTBUF_ENC_BYP,If set (1) OtBuf ECC encoder is bypassed" "0,1"
            newline
            bitfld.long 0x00 1. "CTL_INBUF_DEC_BYP,If set (1) InBuf ECC decoder is bypassed" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_INBUF_ENC_BYP,If set (1) InBuf ECC encoder is bypassed" "0,1"
    group.long 0x17C++0x03
        line.long 0x00 "AUX_ACC_ECC_CTRL1,Aux Accelerator ECC Control Reg 1"
            bitfld.long 0x00 0. "CLR_ECC_SEC_CNT,Toggle to '1' to clear SEC counter" "0,1"
    group.long 0x180++0x03
        line.long 0x00 "AUX_ACC_ECC_CTRL2,Aux Accelerator ECC Control Reg 2"
            bitfld.long 0x00 16. "CTL_SNAP_SEC_CNT,Toggle to '1' then back to '0' to take a snapshot of the SEC counter" "0,1"
            newline
            hexmask.long.word 0x00 0.--15. 1. "CTL_ERR_SEC_LIM,If SEC count exceeds the value of this field then trigger an interrrupt request"

    rgroup.long 0x184++0x03
        line.long 0x00 "AUX_ACC_ECC_STAT0,Aux Accelerator ECC Status Reg 0"
            hexmask.long.word 0x00 16.--24. 1. "STS_OTBUF_DEC_PARITY,Read out parity bits for InBuf ECC decoder"
            newline
            hexmask.long.word 0x00 0.--8. 1. "STS_INBUF_DEC_PARITY,Read out parity bits for InBuf ECC decoder"
    rgroup.long 0x188++0x03
        line.long 0x00 "AUX_ACC_ECC_STAT1,Aux Accelerator ECC Status Reg 1"
            hexmask.long.word 0x00 0.--15. 1. "STS_ECC_SEC_CNT,Counter of all SEC events in this block"

    group.long 0x18C++0x03
        line.long 0x00 "AUX_ACC_INITFSM_CTRL,Aux Accelerator InitFSM Control"
            rbitfld.long 0x00 16.--20. "STS_AADP_STATE,Aux Acc Datapath current state" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            rbitfld.long 0x00 8.--9. "STS_INITFSM_STATE,Bit [0]: Init FSM scheduled to be run or is running" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--1. "CTL_INITFSM_START,Write both bits to '1' to start Aux Acc RAM initialization FSM" "0,1,2,3"
    group.long 0x190++0x03
        line.long 0x00 "AUX_ACC_RAM_CTRL0,Aux Accelerator RAM Control"
            bitfld.long 0x00 2.--3. "CTL_RTSEL,RAM RT Select" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--1. "CTL_WTSEL,RAM WT Select" "0,1,2,3"
    group.long 0x194++0x03
        line.long 0x00 "IRQ_ERR_ENA_CTRL0,Error IRQ Enable control"
            abitfld.long 0x00 0.--23. "CTL_ERR_ENA,Bit enables of error triggers" "0x000000=0: Attempt made to start datapath..,0x000001=1: reserved,0x000002=2: reserved,0x000003=3: reserved,0x000004=4: Data AHB interface had erroneous..,0x000005=5: Data AHB read FIFO overflow,0x000006=6: Data AHB control signal parity..,0x000007=7: Data AHB write data parity violation,0x000008=8: Data AHB address parity violation,0x000009=9: Data AHB internal control parity..,0x00000A=10: Data AHB internal read data parity..,0x00000B=11: Data AHB internally stored command..,0x00000C=12: Data AHB internal control parity..,0x00000D=13: Data AHB internal read-FIFO control..,0x00000E=14: Narrow writes (< 128-bit) were made..,0x00000F=15: Collision on input buffer,0x000010=16: Collision on output buffer,0x000011=17: Input buffer double-bit error..,0x000012=18: Input buffer single-bit error..,0x000013=19: Output buffer double-bit error..,0x000014=20: Output buffer single-bit error..,0x000015=21: Total number of single errors..,0x000016=22: Input buffer addressing error,0x000017=23: Output buffer addressing error"
    group.long 0x198++0x03
        line.long 0x00 "IRQ_ERR_STAT0,Error IRQ Status"
            hexmask.long.tbyte 0x00 0.--23. 1. "STS_ERR,Each bit corresponds to an error"
    group.long 0x19C++0x03
        line.long 0x00 "IRQ_INFO_ENA_CTRL0,IRQ Enable control"
            bitfld.long 0x00 2.--3. "CTL_IDMA_TRIG_ENA,Bit enables of direct triggering of BBE's IDMA" "0: Finished writing to an input buffer based on..,1: Aux Accelerator datapath finished processing of,?..."
            newline
            bitfld.long 0x00 0.--1. "CTL_INFO_ENA,Bit enables of info interrupt triggers" "0: Finished writing to an input buffer based on..,1: Aux Accelerator datapath finished processing of,?..."
    group.long 0x1A0++0x03
        line.long 0x00 "IRQ_INFO_STAT0,IRQ Info Status"
            bitfld.long 0x00 0.--1. "STS_INFO,Each bit corresponds to an information status" "0,1,2,3"

    rgroup.long 0x1A4++0x03
        line.long 0x00 "IDMA_TRIG_STAT0,iDMA Trigger Status"
            bitfld.long 0x00 0. "STS_IDMA_TRIG,iDMA trigger sent to BBE" "0,1"

    group.long 0x1A8++0x03
        line.long 0x00 "SPARE,Spare Register"
            hexmask.long 0x00 0.--31. 1. "SPARE,Spare registers"
    group.long 0x1AC++0x03
        line.long 0x00 "CTL_LOCK,Lock control"
            hexmask.long 0x00 0.--31. 1. "CTL_AA_LOCK_KEY,Write 0x9bd8ca97 to allow write access to this SFR bank"

    rgroup.long 0x1B0++0x03
        line.long 0x00 "STS_LOCK,Lock status"
            bitfld.long 0x00 0. "STS_AA_LOCK_N,Lock status for this SFR bank" "0,1"
tree.end

tree "CAN ()"
    repeat 2. (list 0. 1.) (list ad:0x91930000 ad:0x91932000)
        tree "CAN$1"
            base $2
            group.long 0x00++0x03
                line.long 0x00 "CAN_WORD_00,CAN Controller WORD 00 Register"
                    bitfld.long 0x00 25. "TSPOS,TSPOS can only be changed if TSEN=0 but it is possible to modify TSPOS with the same write access that sets TSEN=1" "0: SOF,1: EOF"
                    bitfld.long 0x00 24. "TSEN,TIME-stamping Enable" "0: disabled,1: enabled"
                    newline
                    rbitfld.long 0x00 18. "TMSE,TMSE=1 enables to switch the mode of operation of the transceiver inside a CAN XL frame" "0: disabled,1: enabled"
                    bitfld.long 0x00 17. "ROP,ROP cannot be changed while a transmission is active" "0: restricted operation disabled,1: restricted operation enabled"
                    newline
                    rbitfld.long 0x00 16. "CES,If CES=1 then errors are signaled using error flags and the error counters are incremented" "0: error signaling disabled,1: error signaling enabled"
                    hexmask.long.byte 0x00 8.--15. 1. "VER_1,Version of CAN-CTRL given as decimal value"
                    newline
                    hexmask.long.byte 0x00 0.--7. 1. "VER_0,Version of CAN-CTRL given as decimal value"
            group.long 0x04++0x03
                line.long 0x00 "AC_TIME,Arbitration and Classic (Nominal) Bit Timing"
                    hexmask.long.byte 0x00 24.--30. 1. "AC_SJW,The Synchronization Jump Width tSJW = (xSJW + 1) * TQ is the maximum time for shortening or lengthening the Bit Time for resynchronization"
                    hexmask.long.byte 0x00 16.--22. 1. "AC_SEG_2,Time tSEG_2 = (xSEG_2 + 1) * TQ after the sample point to the end of the bit"
                    newline
                    hexmask.long.word 0x00 0.--8. 1. "AC_SEG_1,The sample point will be set to tSEG_1 = (xSEG_1 + 2) * TQ after start of bit time"
            group.long 0x08++0x03
                line.long 0x00 "FD_TIME,CAN FD Bit Timing"
                    hexmask.long.byte 0x00 24.--30. 1. "FD_SJW,The Synchronization Jump Width tSJW = (xSJW + 1) * TQ is the maximum time for shortening or lengthening the Bit Time for resynchronization"
                    hexmask.long.byte 0x00 16.--22. 1. "FD_SEG_2,Time tSEG_2 = (xSEG_2 + 1) * TQ after the sample point to the end of the bit"
                    newline
                    hexmask.long.byte 0x00 0.--7. 1. "FD_SEG_1,The sample point will be set to tSEG_1 = (xSEG_1 + 2) * TQ after start of bit time"

            rgroup.long 0x0C++0x03
                line.long 0x00 "XL_TIME,CAN XL Bit Timing"
                    hexmask.long.byte 0x00 24.--30. 1. "XL_SJW,The Synchronization Jump Width tSJW = (xSJW + 1) * TQ is the maximum time for shortening or lengthening the Bit Time for resynchronization"
                    hexmask.long.byte 0x00 16.--22. 1. "XL_SEG_2,Time tSEG_2 = (xSEG_2 + 1) * TQ after the sample point to the end of the bit"
                    newline
                    hexmask.long.byte 0x00 0.--7. 1. "XL_SEG_1,The sample point will be set to tSEG_1 = (xSEG_1 + 2) * TQ after start of bit time"

            group.long 0x10++0x03
                line.long 0x00 "CAN_WORD_10,CAN Controller WORD 10 Register"
                    bitfld.long 0x00 28.--30. "RETLIM,If there is any error during transmission a CAN node is able to automatically retry it as soon as the bus is idle" "0: 1 attempt (no retransmission),1: X1/X3/X5/X7,2: 3 attempts,?..."
                    bitfld.long 0x00 24.--26. "REALIM,If two or more CAN nodes try to transmit frames simultaneously then the lower-priority frames lose arbitration and silently step back without interrupting the higher-priority frame" "0: 1 attempt (re-arbitration),1: X1/X3/X5/X7,2: 3 attempts,?..."
                    newline
                    hexmask.long.byte 0x00 16.--23. 1. "XL_SSPOFF,Transmitter Delay Compensation (TDC) is enabled if SSPOFF!=0 and CES=1"
                    hexmask.long.byte 0x00 8.--15. 1. "FD_SSPOFF,Transmitter Delay Compensation (TDC) is enabled if SSPOFF!=0 and CES=1"
                    newline
                    bitfld.long 0x00 0.--4. "PRESC,The prescaler divides the system clock to synthesize the time quanta TQ" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            group.long 0x14++0x03
                line.long 0x00 "INTF,Interrupt Flag Register"
                    rbitfld.long 0x00 31. "EWARN,Error Warning Limit Reached" "0: The values in both counters are less than EWL,1: One of the error counters RECNT or TECNT is.."
                    rbitfld.long 0x00 30. "EPASS,Error Passive Status" "0: node is error active,1: node is error passive"
                    newline
                    bitfld.long 0x00 18. "SWIF,If XMREN=1 and if there is a correctable mismatch between the redundant instances then SWIF will be set if SWIE=1" "0,1"
                    bitfld.long 0x00 17. "SEIF,If XMREN=1 and if there is a not correctable mismatch between the redundant instances then SEIF and TXB will be set" "0,1"
                    newline
                    bitfld.long 0x00 16. "MAEIF,MAEIF will be set if memory protection has detected an error in the address" "0,1"
                    bitfld.long 0x00 15. "MDEIF,MDEIF will be set if memory protection has detected an error in the data which was not correctable" "0,1"
                    newline
                    bitfld.long 0x00 14. "MDWIF,MDWIF will be set if MDWIE is set and memory protection has detected an error in the data which has been automatically corrected" "0,1"
                    bitfld.long 0x00 13. "WTIF,WTIF will be set if the cycle count reaches the limited defined by TT_WTRIG and WTIE is set" "0,1"
                    newline
                    bitfld.long 0x00 12. "TEIF,There is no bit to enable or disable the handling of TEIF" "0,1"
                    bitfld.long 0x00 11. "TTIF,TTIF will be set if TTIE is set and the cycle time is equal to the trigger time TT_TRIG" "0,1"
                    newline
                    bitfld.long 0x00 10. "EPIF,EPIF will be activated if EPASS changes and if EPIE=1" "0,1"
                    bitfld.long 0x00 9. "ALIF,Arbitration Lost Interrupt Flag" "0,1"
                    newline
                    bitfld.long 0x00 8. "BEIF,Bus Error Interrupt Flag" "0,1"
                    bitfld.long 0x00 7. "RIF,Receive Interrupt Flag" "0: No frame has been received,1: Data or a remote frame has been received and.."
                    newline
                    bitfld.long 0x00 6. "ROIF,In case of an overrun both ROIF and RFIF will be set" "0: No RB overwritten,1: At least one received message has been.."
                    bitfld.long 0x00 5. "RFIF,RB Full Interrupt Flag" "0: The RB FIFO is not full,1: All RBs are full"
                    newline
                    bitfld.long 0x00 4. "RAFIF,RB Almost-Full Interrupt Flag" "0: number of filled RB slots is less than AFWL_i,1: number of filled RB slots is equal or bigger.."
                    bitfld.long 0x00 3. "TPIF,In TTCAN mode TPIF will never be set" "0: No transmission of the PTB has been completed,1: The requested transmission of the PTB has.."
                    newline
                    bitfld.long 0x00 2. "TSIF,In TTCAN mode TSIF will signal all successful transmissions regardless of storage location of the frame" "0: No transmission of the STB has been completed..,1: The requested transmission of the STB has.."
                    bitfld.long 0x00 1. "EIF,Error Interrupt Flag" "0: There has been no change,1: The border of the error warning limit has.."
                    newline
                    bitfld.long 0x00 0. "AIF,The AIF does not have an associated enable register" "0: No abort has been executed,1: After setting TPA or TSA the appropriated.."
            group.long 0x18++0x03
                line.long 0x00 "INTE,Interrupt Enable Register"
                    bitfld.long 0x00 18. "SWIE,DMR / TMR: Safety Warning Interrupt Enable" "0,1"
                    bitfld.long 0x00 14. "MDWIE,Memory Protection (ECC): Data Warning Interrupt Enable" "0,1"
                    newline
                    bitfld.long 0x00 13. "WTIE,Watch Trigger Interrupt Enable" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 11. "TTIE,If TTIE is set then TTIF will be set if the cycle time is equal to the trigger time TT_TRIG" "0,1"
                    newline
                    bitfld.long 0x00 10. "EPIE,Error Passive Interrupt Enable" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 9. "ALIE,Arbitration Lost Interrupt Enable" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 8. "BEIE,Bus Error Interrupt Enable" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 7. "RIE,Receive Interrupt Enable" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 6. "ROIE,RB Overflow Interrupt Enable" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 5. "RFIE,RB Full Interrupt Enable" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 4. "RAFIE,RB Almost-Full Interrupt Enable" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 3. "TPIE,Transmission Primary Interrupt Enable" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 2. "TSIE,Transmission Secondary Interrupt Enable" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 1. "EIE,Error Interrupt Enable" "0: DISABLED,1: ENABLED"

            rgroup.long 0x1C++0x03
                line.long 0x00 "TSTAT,Transmit Status Registers"
                    bitfld.long 0x00 24.--26. "TSTAT2,Transmission Status Code (TSTAT_2)" "0,1,2,3,4,5,6,7"
                    hexmask.long.byte 0x00 16.--23. 1. "HANDLE2,Handle for frame identification (TSTAT_2)"
                    newline
                    bitfld.long 0x00 8.--10. "TSTAT1,Transmission Status Code (TSTAT_1)" "0,1,2,3,4,5,6,7"
                    hexmask.long.byte 0x00 0.--7. 1. "HANDLE1,Handle for frame identification (TSTAT_1)"
            repeat 2. (increment 0 1) (increment 0 0x4)
                rgroup.long ($2+0x20)++0x03
                    line.long 0x00 "TTS[$1],Transmission Time Stamp $1"
                        hexmask.long 0x00 0.--31. 1. "TTS,TTS holds the time stamp of the last transmitted frame for CiA 603 time stamping"
            repeat.end

            group.long 0x28++0x03
                line.long 0x00 "CAN_WORD_28,CAN Controller WORD 28 Register"
                    bitfld.long 0x00 31. "SACK,Self-Acknowledge" "0: no self-ACK,1: self-ACK when LBME=1"
                    bitfld.long 0x00 30. "ROM,In case of a full RBUF when a new message is received then ROM selects the following" "0: The oldest message will be overwritten,1: The new message will not be stored"
                    newline
                    rbitfld.long 0x00 29. "ROV,ROV is cleared by setting RREL=1" "0: No Overflow,1: Overflow"
                    bitfld.long 0x00 28. "RREL,The host controller has read the actual RB slot and releases it" "0: NO_RELEASE,1: Release - The host has read the RB"
                    newline
                    bitfld.long 0x00 27. "RBALL,Receive Buffer stores ALL data frames" "0: normal operation,1: RB stores correct data frames as well as data.."
                    rbitfld.long 0x00 24.--25. "RSTAT,Receive buffer Status" "0: EMPTY,1: greater than empty and less than almost full..,2: greater than or equal to almost full..,3: full (stays set in case of overflow - for.."
                    newline
                    bitfld.long 0x00 23. "FD_ISO,ISO CAN FD mode has a different CRC initialization value and an additional stuff bit count" "0: Bosch CAN FD (non-ISO) mode,1: ISO CAN FD mode (ISO 11898-1:2015)"
                    bitfld.long 0x00 22. "TSNEXT,After all frame bytes are written to the TBUF registers the host controller has to set TSNEXT to signal that this slot has been filled" "0: no action,1: STB slot filled select next slot"
                    newline
                    bitfld.long 0x00 21. "TSMODE,In FIFO mode frames are transmitted in the order in that they are written into the STB" "0: FIFO mode,1: priority decision mode"
                    bitfld.long 0x00 20. "TTTBM,If TTEN=0 then TTTBM is ignored otherwise the following is valid" "0: separate PTB and STB behavior defined by TSMODE,1: full TTCAN support buffer slots selectable by.."
                    newline
                    rbitfld.long 0x00 18. "TSFF,If TTEN=0 or TTTBM=0: Transmit Secondary buffer Full Flag" "0: The buffer slot selected by TBPTR is empty,1: The buffer slot selected by TBPTR is filled"
                    rbitfld.long 0x00 16.--17. "TSSTAT,If TTEN=0 or TTTBM=0: 00 -STB is empty" "0: PTB and STB are empty,1: PTB and STB are not empty and not full,2: STB is more than half full,3: PTB and STB are full"
                    newline
                    bitfld.long 0x00 15. "TBSEL,Selects the transmit buffer to be loaded with a frame" "0: PTB (high-priority buffer),1: STB"
                    bitfld.long 0x00 14. "LOM,LOM cannot be changed while a transmission is active" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 13. "STBY,This register bit is connected to the output signal stby which can be used to control a standby mode of a transceiver" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 12. "TPE,If TPE is set the frame from the PTB will be transmitted at the next possible transmit position" "0: No transmission for the PTB,1: Transmission enable for the frame in the.."
                    newline
                    bitfld.long 0x00 11. "TPA,The bit has to be set by the host controller and will be reset by CAN-CTRL" "0: DISABLED,1: Aborts a transmission from PTB which has been.."
                    bitfld.long 0x00 10. "TSONE,TSONE stays set until the frame has been transmitted successfully or it is aborted using TSA" "0: No transmission for the STB,1: Transmission enable of one in the STB"
                    newline
                    bitfld.long 0x00 9. "TSALL,TSALL stays set until all frames have been transmitted successfully or they are aborted using TSA" "0: No transmission for the STB,1: Transmission enable of all frames in the STB"
                    bitfld.long 0x00 8. "TSA,The bit has to be set by the host controller and will be reset by CAN-CTRL" "0: DISABLED,1: Aborts a transmission from STB which has been.."
                    newline
                    bitfld.long 0x00 7. "RESET,Some register (e.g for node configuration) can only be modified if RESET=1" "0: No local reset of CAN-CTRL,1: The host controller performs a local reset of.."
                    bitfld.long 0x00 6. "LBME,LBME cannot be changed while a transmission is active" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 5. "LBMI,LBMI cannot be changed while a transmission is active" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 0. "BUSOFF,Writing a 1 to BUSOFF will reset TECNT and RECNT" "0: The controller status is bus on,1: The controller status is bus off"
            group.long 0x2C++0x03
                line.long 0x00 "CAN_WORD_2C,CAN Controller WORD 2C Register"
                    hexmask.long.byte 0x00 24.--31. 1. "TECNT,TECNT is incremented and decremented as defined in the CAN specification"
                    hexmask.long.byte 0x00 16.--23. 1. "RECNT,RECNT is incremented and decremented as defined in the CAN specification"
                    newline
                    rbitfld.long 0x00 13.--15. "KOER,KOER is updated with each new error" "0: NO_ERROR,1: BIT_ERROR,2: FORM_ERROR,3: STUFF_ERROR,4: Acknowledgement Error,5: CRC_ERROR,6: Other Error (dominant bits after own error..,7: PCRC_ERROR (CAN XL only"
                    rbitfld.long 0x00 8.--12. "ALC,Bbit position in the frame where the arbitration has been lost" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
                    newline
                    bitfld.long 0x00 4.--7. "AFWL,AFWL defines the internal warning limit AFWL_i with nRB being the number of available RB slots" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
                    bitfld.long 0x00 0.--3. "EWL,Programmable Error Warning Limit = (EWL+1)*8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            group.long 0x30++0x03
                line.long 0x00 "REF_MSG,Reference Message"
                    bitfld.long 0x00 31. "REF_IDE,Reference message IDE bit" "0,1"
                    hexmask.long 0x00 0.--28. 1. "REF_ID,REF_ID is used in TTCAN mode to detect a reference message"
            group.long 0x34++0x03
                line.long 0x00 "CAN_WORD_34,CAN Controller WORD 34 Register"
                    bitfld.long 0x00 25.--26. "T_PRESC,The TTCAN time base is a CAN bittime defined by PRESC AC_SEG_1 and AC_SEG_2" "0: X0,1: X1,2: X2,3: X3"
                    bitfld.long 0x00 24. "TTEN,Time Trigger Enable" "0: DISABLED,1: TTCAN enabled timer is running"
                    newline
                    bitfld.long 0x00 23. "TBE,TBE is automatically reset to 0 as soon as the slot is marked as empty and TSFF=0" "0: NO_ACTION,1: slot selected by TBPTR shall be marked as.."
                    bitfld.long 0x00 22. "TBF,TBF is automatically reset to 0 as soon as the slot is marked as filled and TSFF=1" "0: NO_ACTION,1: slot selected by TBPTR shall be marked as.."
                    newline
                    bitfld.long 0x00 16.--21. "TBPTR," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
                    bitfld.long 0x00 12.--15. "TEW,For a single shot transmit trigger there is a time of up to 16 ticks of the cycle time where the frame is allowed to start" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
                    newline
                    bitfld.long 0x00 8.--10. "TTYPE,The time of the trigger is defined by TT_TRIG" "0: Immediate Trigger for immediate transmission,1: Time Trigger for receive triggers,2: Single Shot Transmit Trigger for exclusive..,3: Transmit Start Trigger for merged arbitrating..,4: Transmit Stop Trigger for merged arbitrating..,5: no action,6: no action,7: no action"
                    bitfld.long 0x00 0.--5. "TTPTR,If TTPTR is too big and points to a slot that is not available then TEIF is set and no new trigger can be activated after a write access to TT_TRIG_1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            group.long 0x38++0x03
                line.long 0x00 "CAN_WORD_38,CAN Controller WORD 38 Register"
                    hexmask.long.byte 0x00 24.--31. 1. "TT_WTRIG_1,TT_WTRIG(15:0) defines the cycle time for a watch trigger"
                    hexmask.long.byte 0x00 16.--23. 1. "TT_WTRIG_0,TT_WTRIG(15:0) defines the cycle time for a watch trigger"
                    newline
                    hexmask.long.byte 0x00 8.--15. 1. "TT_TRIG_1,TT_TRIG(15:0) defines the cycle time for a trigger"
                    hexmask.long.byte 0x00 0.--7. 1. "TT_TRIG_0,TT_TRIG(15:0) defines the cycle time for a trigger"
            group.long 0x3C++0x03
                line.long 0x00 "CAN_WORD_3C,CAN Controller WORD 3C Register"
                    bitfld.long 0x00 31. "MPEN,MPEN is only writable if RESET=1" "0: disabled,1: enabled"
                    rbitfld.long 0x00 27.--28. "HELOC,HELOC will be updated with every new error during a read access from the host side" "0: no error during access from host side,1: error during access from host side in TBUF,2: error during access from host side in RBUF,3: error during access from host side in ACF"
                    newline
                    rbitfld.long 0x00 26. "TXB,If MDEIF or MAEIF is set because of an error while the CAN protocol machine is reading data for transmission then the transmission is immediately blocked" "0: normal operation,1: transmission blocked"
                    rbitfld.long 0x00 25. "TXS,If MDEIF or MAEIF is set because of an error while the priority reordering machine accesses the memory then any new transmission is stopped" "0: normal operation,1: transmission stopped"
                    newline
                    bitfld.long 0x00 24. "ACFA,If MDEIF or MAEIF is set because of an error in the address range of the ACF ACFA is set" "0: normal operation of ACF,1: ACF disabled"
                    bitfld.long 0x00 3. "XMRTP,Setting XMRTE=1 enables a build-in self-test" "0,1"
                    newline
                    bitfld.long 0x00 1. "XMRTE,Setting XMRTE=1 starts the automatic build-in self-test for the the DMR / TMR protected machinery" "0,1"
                    bitfld.long 0x00 0. "XMREN,It depends on the synthesis parameter SAFETY_ENABLE if DMR or TMR is available" "0,1"
            group.long 0x40++0x03
                line.long 0x00 "MEM_ES,Memory Error Simulation"
                    bitfld.long 0x00 26. "MES,MES defines the side which will be hit by the next memory error together with MEL" "0: Host side,1: CAN side"
                    bitfld.long 0x00 24.--25. "MEL,MEL defines the memory area which will be hit by the next memory error together with MES" "0: ACF,1: TBUF,2: RBUF,3: ACF"
                    newline
                    bitfld.long 0x00 20.--23. "MENEC,Error stimulation is delayed if MENEC>0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
                    bitfld.long 0x00 16.--19. "MEEEC,Error stimulation is activated if MENEC=0 and MEEEC>0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
                    newline
                    bitfld.long 0x00 14. "ME2EE,If ME2EE E=1 then MEBP2 is used to do stimulation of a single bit error" "0,1"
                    bitfld.long 0x00 8.--13. "MEBP2,MEBP2 defines the position of one single bit error during memory" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
                    newline
                    bitfld.long 0x00 7. "MEAEE,If MEAEE=1 then the address bit 2 is flipped" "0,1"
                    bitfld.long 0x00 6. "ME1EE,If ME1EE E=1 then MEBP1 is used to do stimulation of a single bit error" "0,1"
                    newline
                    bitfld.long 0x00 0.--5. "MEBP1,MEBP1 defines the position of one single bit error during memory" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            group.long 0x44++0x03
                line.long 0x00 "ACFCTRL,Acceptance Filter Control"
                    bitfld.long 0x00 31. "AE_15,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 30. "AE_14,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 29. "AE_13,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 28. "AE_12,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 27. "AE_11,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 26. "AE_10,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 25. "AE_9,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 24. "AE_8,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 23. "AE_7,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 22. "AE_6,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 21. "AE_5,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 20. "AE_4,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 19. "AE_3,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 18. "AE_2,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 17. "AE_1,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    bitfld.long 0x00 16. "AE_0,Each acceptance filter (ACFC / ACFM) can be individually enabled or disabled" "0: DISABLED,1: ENABLED"
                    newline
                    bitfld.long 0x00 0.--3. "ACFADR,ACFADR points to a specific acceptance filter" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            repeat 4. (increment 0 1) (increment 0 0x4)
                group.long ($2+0x48)++0x03
                    line.long 0x00 "ACFC[$1],Acceptance filters (code $1"
                        hexmask.long 0x00 0.--31. 1. "ACFC,ACFC"
            repeat.end
            repeat 4. (increment 0 1) (increment 0 0x4)
                group.long ($2+0x58)++0x03
                    line.long 0x00 "ACFM[$1],Acceptance filters (mask $1"
                        hexmask.long 0x00 0.--31. 1. "ACFM,ACFM"
            repeat.end
            repeat 519. (increment 0 1) (increment 0 0x4)
                group.long ($2+0x70)++0x03
                    line.long 0x00 "RBUF[$1],Receive Buffer Registers $1"
                        hexmask.long 0x00 0.--31. 1. "RBUF,RBUF"
            repeat.end
            repeat 515. (increment 0 1) (increment 0 0x04)
                group.long ($2+0x890)++0x03
                    line.long 0x00 "TBUF[$1],Transmit Buffer Registers $1"
                        hexmask.long 0x00 0.--31. 1. "TBUF,TBUF"
            repeat.end

            rgroup.long 0x10AC++0x03
                line.long 0x00 "PWM_CFG,PWM Encoding Configuration"
                    bitfld.long 0x00 16.--21. "PWML,PWML+1 defines the number of mtq for the long phase of PWM encoding" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
                    bitfld.long 0x00 8.--13. "PWMS,PWMS+1 defines the number of mtq for the short phase of PWM encoding" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
                    newline
                    bitfld.long 0x00 0.--5. "PWMO,PWMO defines the number of mtq before the start of PWM encoding" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"

            group.long 0x10B0++0x03
                line.long 0x00 "STR_CFG,Stream Configuration STR_CFG"
                    bitfld.long 0x00 3.--4. "TSTRCFG,TSTRCFG is writeable if RESET=1 and write-locked if 0" "0: PTB using TPE store & forward,1: PTB using TPE cut-through,2: STB using TSONE store & forward,3: STB using TSALL store & forward"
                    bitfld.long 0x00 2. "TSTREN,If enabled then frames to be transmitted are stored in the transmit buffer" "0: disabled,1: enabled"
                    newline
                    bitfld.long 0x00 1. "RSTREN,If enabled then received frames are forwarded to the reception stream interface" "0: disabled,1: enabled"
                    bitfld.long 0x00 0. "RBUFEN,If enabled then received frames are forwarded to RBUF" "0: disabled,1: enabled"
            group.long 0x10B4++0x03
                line.long 0x00 "LLCFORMAT,LLC Frame Calculator Input"
                    hexmask.long 0x00 0.--31. 1. "LLCFORMAT,A write access to LLCFORMAT results in the automatic calculation of the size information of an LLC frame inside LLCSIZE*"

            rgroup.long 0x10B8++0x03
                line.long 0x00 "LLCSIZE,LLC Frame Calculator Output"
                    hexmask.long.word 0x00 16.--31. 1. "LLCAOT,LLCAOT provides the address offset of the reception time-stamps (value T) of an LLC frame* depending on the value inside LLCFORMAT"
                    hexmask.long.word 0x00 0.--15. 1. "LLCPBYTES,LLCPBYTES provides the number of payload data bytes inside LLC frame** depending on the value inside LLCFORMAT"
        tree.end
    repeat.end
tree.end

tree "CHANDRA_NOC ()"
    base ad:0x84FD0000
    rgroup.long 0x00++0x03
        line.long 0x00 "Id_CoreId,Stores the Core Id and its checksum"
            hexmask.long.tbyte 0x00 8.--31. 1. "CORECHECKSUM,Field containing a checksum of the parameters of the IP"
            hexmask.long.byte 0x00 0.--7. 1. "CORETYPEID,Field identifying the type of IP"
    rgroup.long 0x04++0x03
        line.long 0x00 "Id_RevisionId,Stores a user-defined Id and the software revision"
            hexmask.long.tbyte 0x00 8.--31. 1. "FLEXNOCID,Field containing the build revision of the software used to generate the IP HDL code"
            hexmask.long.byte 0x00 0.--7. 1. "USERID,Field containing a user defined value not used anywhere inside the IP itself"

    group.long 0x08++0x03
        line.long 0x00 "FreezeEn,Register FreezeEn"
            hexmask.long.byte 0x00 0.--7. 1. "FREEZEEN,This 8 bits register enable/disable the Write operation on the RegBank when set"
    group.long 0x0C++0x03
        line.long 0x00 "Clear,clear"
            bitfld.long 0x00 1. "BISTCLEAR,Clear all BIST related registers" "0,1"
            bitfld.long 0x00 0. "MISSIONCLEAR,Clear Mission Faults" "0,1"
    group.long 0x10++0x03
        line.long 0x00 "BistControl,bistcontrol"
            bitfld.long 0x00 24. "AUTOMISSION,BIST AutoMission - Automaticaly go back into mission mode when BIST is done" "0,1"
            hexmask.long.byte 0x00 16.--23. 1. "TIMEOUT1,BIST TimeOut1 value"
            hexmask.long.word 0x00 0.--15. 1. "TIMEOUT0,BIST TimeOut0 value"

    rgroup.long 0x14++0x03
        line.long 0x00 "BistStatus,biststatus"
            bitfld.long 0x00 1. "FAILED,BIST Status (1=Failed)" "0,1"
            bitfld.long 0x00 0. "DONE,BIST Done" "0,1"

    group.long 0x18++0x03
        line.long 0x00 "BistStart,Register BistStart"
            hexmask.long.byte 0x00 0.--7. 1. "BISTSTART,Start BIST mode only with code word 0xB5"
    group.long 0x20++0x03
        line.long 0x00 "FaultTypeReg0,faulttypereg0"
            bitfld.long 0x00 30.--31. "FAULTTYPE15,Fault Type 15" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE14,Fault Type 14" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE13,Fault Type 13" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE12,Fault Type 12" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE11,Fault Type 11" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE10,Fault Type 10" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE9,Fault Type 9" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE8,Fault Type 8" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE7,Fault Type 7" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE6,Fault Type 6" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE5,Fault Type 5" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE4,Fault Type 4" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE3,Fault Type 3" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE2,Fault Type 2" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE1,Fault Type 1" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE0,Fault Type 0" "0,1,2,3"
    group.long 0x24++0x03
        line.long 0x00 "FaultTypeReg1,faulttypereg1"
            bitfld.long 0x00 30.--31. "FAULTTYPE31,Fault Type 31" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE30,Fault Type 30" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE29,Fault Type 29" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE28,Fault Type 28" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE27,Fault Type 27" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE26,Fault Type 26" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE25,Fault Type 25" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE24,Fault Type 24" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE23,Fault Type 23" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE22,Fault Type 22" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE21,Fault Type 21" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE20,Fault Type 20" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE19,Fault Type 19" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE18,Fault Type 18" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE17,Fault Type 17" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE16,Fault Type 16" "0,1,2,3"
    group.long 0x28++0x03
        line.long 0x00 "FaultTypeReg2,faulttypereg2"
            bitfld.long 0x00 30.--31. "FAULTTYPE47,Fault Type 47" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE46,Fault Type 46" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE45,Fault Type 45" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE44,Fault Type 44" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE43,Fault Type 43" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE42,Fault Type 42" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE41,Fault Type 41" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE40,Fault Type 40" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE39,Fault Type 39" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE38,Fault Type 38" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE37,Fault Type 37" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE36,Fault Type 36" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE35,Fault Type 35" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE34,Fault Type 34" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE33,Fault Type 33" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE32,Fault Type 32" "0,1,2,3"
    group.long 0x2C++0x03
        line.long 0x00 "FaultTypeReg3,faulttypereg3"
            bitfld.long 0x00 30.--31. "FAULTTYPE63,Fault Type 63" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE62,Fault Type 62" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE61,Fault Type 61" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE60,Fault Type 60" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE59,Fault Type 59" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE58,Fault Type 58" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE57,Fault Type 57" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE56,Fault Type 56" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE55,Fault Type 55" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE54,Fault Type 54" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE53,Fault Type 53" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE52,Fault Type 52" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE51,Fault Type 51" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE50,Fault Type 50" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE49,Fault Type 49" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE48,Fault Type 48" "0,1,2,3"
    group.long 0x30++0x03
        line.long 0x00 "FaultTypeReg4,faulttypereg4"
            bitfld.long 0x00 30.--31. "FAULTTYPE79,Fault Type 79" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE78,Fault Type 78" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE77,Fault Type 77" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE76,Fault Type 76" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE75,Fault Type 75" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE74,Fault Type 74" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE73,Fault Type 73" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE72,Fault Type 72" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE71,Fault Type 71" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE70,Fault Type 70" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE69,Fault Type 69" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE68,Fault Type 68" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE67,Fault Type 67" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE66,Fault Type 66" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE65,Fault Type 65" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE64,Fault Type 64" "0,1,2,3"
    group.long 0x34++0x03
        line.long 0x00 "FaultTypeReg5,faulttypereg5"
            bitfld.long 0x00 30.--31. "FAULTTYPE95,Fault Type 95" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE94,Fault Type 94" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE93,Fault Type 93" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE92,Fault Type 92" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE91,Fault Type 91" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE90,Fault Type 90" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE89,Fault Type 89" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE88,Fault Type 88" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE87,Fault Type 87" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE86,Fault Type 86" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE85,Fault Type 85" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE84,Fault Type 84" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE83,Fault Type 83" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE82,Fault Type 82" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE81,Fault Type 81" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE80,Fault Type 80" "0,1,2,3"
    group.long 0x38++0x03
        line.long 0x00 "FaultTypeReg6,faulttypereg6"
            bitfld.long 0x00 30.--31. "FAULTTYPE111,Fault Type 111" "0,1,2,3"
            bitfld.long 0x00 28.--29. "FAULTTYPE110,Fault Type 110" "0,1,2,3"
            bitfld.long 0x00 26.--27. "FAULTTYPE109,Fault Type 109" "0,1,2,3"
            bitfld.long 0x00 24.--25. "FAULTTYPE108,Fault Type 108" "0,1,2,3"
            bitfld.long 0x00 22.--23. "FAULTTYPE107,Fault Type 107" "0,1,2,3"
            bitfld.long 0x00 20.--21. "FAULTTYPE106,Fault Type 106" "0,1,2,3"
            bitfld.long 0x00 18.--19. "FAULTTYPE105,Fault Type 105" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--17. "FAULTTYPE104,Fault Type 104" "0,1,2,3"
            bitfld.long 0x00 14.--15. "FAULTTYPE103,Fault Type 103" "0,1,2,3"
            bitfld.long 0x00 12.--13. "FAULTTYPE102,Fault Type 102" "0,1,2,3"
            bitfld.long 0x00 10.--11. "FAULTTYPE101,Fault Type 101" "0,1,2,3"
            bitfld.long 0x00 8.--9. "FAULTTYPE100,Fault Type 100" "0,1,2,3"
            bitfld.long 0x00 6.--7. "FAULTTYPE99,Fault Type 99" "0,1,2,3"
            bitfld.long 0x00 4.--5. "FAULTTYPE98,Fault Type 98" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "FAULTTYPE97,Fault Type 97" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE96,Fault Type 96" "0,1,2,3"
    group.long 0x3C++0x03
        line.long 0x00 "FaultTypeReg7,faulttypereg7"
            bitfld.long 0x00 4.--5. "FAULTTYPE114,Fault Type 114" "0,1,2,3"
            bitfld.long 0x00 2.--3. "FAULTTYPE113,Fault Type 113" "0,1,2,3"
            bitfld.long 0x00 0.--1. "FAULTTYPE112,Fault Type 112" "0,1,2,3"

    rgroup.long 0x40++0x03
        line.long 0x00 "MissionFault0,missionfault0"
            bitfld.long 0x00 31. "FAULT31,Fault 31" "0,1"
            bitfld.long 0x00 30. "FAULT30,Fault 30" "0,1"
            bitfld.long 0x00 29. "FAULT29,Fault 29" "0,1"
            bitfld.long 0x00 28. "FAULT28,Fault 28" "0,1"
            bitfld.long 0x00 27. "FAULT27,Fault 27" "0,1"
            bitfld.long 0x00 26. "FAULT26,Fault 26" "0,1"
            bitfld.long 0x00 25. "FAULT25,Fault 25" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT24,Fault 24" "0,1"
            bitfld.long 0x00 23. "FAULT23,Fault 23" "0,1"
            bitfld.long 0x00 22. "FAULT22,Fault 22" "0,1"
            bitfld.long 0x00 21. "FAULT21,Fault 21" "0,1"
            bitfld.long 0x00 20. "FAULT20,Fault 20" "0,1"
            bitfld.long 0x00 19. "FAULT19,Fault 19" "0,1"
            bitfld.long 0x00 18. "FAULT18,Fault 18" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT17,Fault 17" "0,1"
            bitfld.long 0x00 16. "FAULT16,Fault 16" "0,1"
            bitfld.long 0x00 15. "FAULT15,Fault 15" "0,1"
            bitfld.long 0x00 14. "FAULT14,Fault 14" "0,1"
            bitfld.long 0x00 13. "FAULT13,Fault 13" "0,1"
            bitfld.long 0x00 12. "FAULT12,Fault 12" "0,1"
            bitfld.long 0x00 11. "FAULT11,Fault 11" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT10,Fault 10" "0,1"
            bitfld.long 0x00 9. "FAULT9,Fault 9" "0,1"
            bitfld.long 0x00 8. "FAULT8,Fault 8" "0,1"
            bitfld.long 0x00 7. "FAULT7,Fault 7" "0,1"
            bitfld.long 0x00 6. "FAULT6,Fault 6" "0,1"
            bitfld.long 0x00 5. "FAULT5,Fault 5" "0,1"
            bitfld.long 0x00 4. "FAULT4,Fault 4" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT3,Fault 3" "0,1"
            bitfld.long 0x00 2. "FAULT2,Fault 2" "0,1"
            bitfld.long 0x00 1. "FAULT1,Fault 1" "0,1"
            bitfld.long 0x00 0. "FAULT0,Fault 0" "0,1"
    rgroup.long 0x44++0x03
        line.long 0x00 "MissionFault1,missionfault1"
            bitfld.long 0x00 31. "FAULT63,Fault 63" "0,1"
            bitfld.long 0x00 30. "FAULT62,Fault 62" "0,1"
            bitfld.long 0x00 29. "FAULT61,Fault 61" "0,1"
            bitfld.long 0x00 28. "FAULT60,Fault 60" "0,1"
            bitfld.long 0x00 27. "FAULT59,Fault 59" "0,1"
            bitfld.long 0x00 26. "FAULT58,Fault 58" "0,1"
            bitfld.long 0x00 25. "FAULT57,Fault 57" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT56,Fault 56" "0,1"
            bitfld.long 0x00 23. "FAULT55,Fault 55" "0,1"
            bitfld.long 0x00 22. "FAULT54,Fault 54" "0,1"
            bitfld.long 0x00 21. "FAULT53,Fault 53" "0,1"
            bitfld.long 0x00 20. "FAULT52,Fault 52" "0,1"
            bitfld.long 0x00 19. "FAULT51,Fault 51" "0,1"
            bitfld.long 0x00 18. "FAULT50,Fault 50" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT49,Fault 49" "0,1"
            bitfld.long 0x00 16. "FAULT48,Fault 48" "0,1"
            bitfld.long 0x00 15. "FAULT47,Fault 47" "0,1"
            bitfld.long 0x00 14. "FAULT46,Fault 46" "0,1"
            bitfld.long 0x00 13. "FAULT45,Fault 45" "0,1"
            bitfld.long 0x00 12. "FAULT44,Fault 44" "0,1"
            bitfld.long 0x00 11. "FAULT43,Fault 43" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT42,Fault 42" "0,1"
            bitfld.long 0x00 9. "FAULT41,Fault 41" "0,1"
            bitfld.long 0x00 8. "FAULT40,Fault 40" "0,1"
            bitfld.long 0x00 7. "FAULT39,Fault 39" "0,1"
            bitfld.long 0x00 6. "FAULT38,Fault 38" "0,1"
            bitfld.long 0x00 5. "FAULT37,Fault 37" "0,1"
            bitfld.long 0x00 4. "FAULT36,Fault 36" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT35,Fault 35" "0,1"
            bitfld.long 0x00 2. "FAULT34,Fault 34" "0,1"
            bitfld.long 0x00 1. "FAULT33,Fault 33" "0,1"
            bitfld.long 0x00 0. "FAULT32,Fault 32" "0,1"
    rgroup.long 0x48++0x03
        line.long 0x00 "MissionFault2,missionfault2"
            bitfld.long 0x00 31. "FAULT95,Fault 95" "0,1"
            bitfld.long 0x00 30. "FAULT94,Fault 94" "0,1"
            bitfld.long 0x00 29. "FAULT93,Fault 93" "0,1"
            bitfld.long 0x00 28. "FAULT92,Fault 92" "0,1"
            bitfld.long 0x00 27. "FAULT91,Fault 91" "0,1"
            bitfld.long 0x00 26. "FAULT90,Fault 90" "0,1"
            bitfld.long 0x00 25. "FAULT89,Fault 89" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT88,Fault 88" "0,1"
            bitfld.long 0x00 23. "FAULT87,Fault 87" "0,1"
            bitfld.long 0x00 22. "FAULT86,Fault 86" "0,1"
            bitfld.long 0x00 21. "FAULT85,Fault 85" "0,1"
            bitfld.long 0x00 20. "FAULT84,Fault 84" "0,1"
            bitfld.long 0x00 19. "FAULT83,Fault 83" "0,1"
            bitfld.long 0x00 18. "FAULT82,Fault 82" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT81,Fault 81" "0,1"
            bitfld.long 0x00 16. "FAULT80,Fault 80" "0,1"
            bitfld.long 0x00 15. "FAULT79,Fault 79" "0,1"
            bitfld.long 0x00 14. "FAULT78,Fault 78" "0,1"
            bitfld.long 0x00 13. "FAULT77,Fault 77" "0,1"
            bitfld.long 0x00 12. "FAULT76,Fault 76" "0,1"
            bitfld.long 0x00 11. "FAULT75,Fault 75" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT74,Fault 74" "0,1"
            bitfld.long 0x00 9. "FAULT73,Fault 73" "0,1"
            bitfld.long 0x00 8. "FAULT72,Fault 72" "0,1"
            bitfld.long 0x00 7. "FAULT71,Fault 71" "0,1"
            bitfld.long 0x00 6. "FAULT70,Fault 70" "0,1"
            bitfld.long 0x00 5. "FAULT69,Fault 69" "0,1"
            bitfld.long 0x00 4. "FAULT68,Fault 68" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT67,Fault 67" "0,1"
            bitfld.long 0x00 2. "FAULT66,Fault 66" "0,1"
            bitfld.long 0x00 1. "FAULT65,Fault 65" "0,1"
            bitfld.long 0x00 0. "FAULT64,Fault 64" "0,1"
    rgroup.long 0x4C++0x03
        line.long 0x00 "MissionFault3,missionfault3"
            bitfld.long 0x00 31. "CONSTANT_0_127,Reserved bit" "0,1"
            bitfld.long 0x00 30. "CONSTANT_0_126,Reserved bit" "0,1"
            bitfld.long 0x00 29. "CONSTANT_0_125,Reserved bit" "0,1"
            bitfld.long 0x00 28. "CONSTANT_0_124,Reserved bit" "0,1"
            bitfld.long 0x00 27. "CONSTANT_0_123,Reserved bit" "0,1"
            bitfld.long 0x00 26. "CONSTANT_0_122,Reserved bit" "0,1"
            bitfld.long 0x00 25. "CONSTANT_0_121,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 24. "CONSTANT_0_120,Reserved bit" "0,1"
            bitfld.long 0x00 23. "CONSTANT_0_119,Reserved bit" "0,1"
            bitfld.long 0x00 22. "CONSTANT_0_118,Reserved bit" "0,1"
            bitfld.long 0x00 21. "CONSTANT_0_117,Reserved bit" "0,1"
            bitfld.long 0x00 20. "CONSTANT_0_116,Reserved bit" "0,1"
            bitfld.long 0x00 19. "CONSTANT_0_115,Reserved bit" "0,1"
            bitfld.long 0x00 18. "FAULT114,Fault 114" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT113,Fault 113" "0,1"
            bitfld.long 0x00 16. "FAULT112,Fault 112" "0,1"
            bitfld.long 0x00 15. "FAULT111,Fault 111" "0,1"
            bitfld.long 0x00 14. "FAULT110,Fault 110" "0,1"
            bitfld.long 0x00 13. "FAULT109,Fault 109" "0,1"
            bitfld.long 0x00 12. "FAULT108,Fault 108" "0,1"
            bitfld.long 0x00 11. "FAULT107,Fault 107" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT106,Fault 106" "0,1"
            bitfld.long 0x00 9. "FAULT105,Fault 105" "0,1"
            bitfld.long 0x00 8. "FAULT104,Fault 104" "0,1"
            bitfld.long 0x00 7. "FAULT103,Fault 103" "0,1"
            bitfld.long 0x00 6. "FAULT102,Fault 102" "0,1"
            bitfld.long 0x00 5. "FAULT101,Fault 101" "0,1"
            bitfld.long 0x00 4. "FAULT100,Fault 100" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT99,Fault 99" "0,1"
            bitfld.long 0x00 2. "FAULT98,Fault 98" "0,1"
            bitfld.long 0x00 1. "FAULT97,Fault 97" "0,1"
            bitfld.long 0x00 0. "FAULT96,Fault 96" "0,1"
    rgroup.long 0x50++0x03
        line.long 0x00 "LatentInternalFault,latentinternalfault"
            bitfld.long 0x00 2. "CRITORTREE,Latent internal Fault in Crit OR Tree" "0,1"
            bitfld.long 0x00 1. "MAJORTREE,Latent internal Fault in Maj OR Tree" "0,1"
            bitfld.long 0x00 0. "MINORTREE,Latent internal Fault in Min OR Tree" "0,1"
    rgroup.long 0x54++0x03
        line.long 0x00 "LatentComFault0,latentcomfault0"
            bitfld.long 0x00 31. "FAULT31,Latent communication Fault 31" "0,1"
            bitfld.long 0x00 30. "FAULT30,Latent communication Fault 30" "0,1"
            bitfld.long 0x00 29. "FAULT29,Latent communication Fault 29" "0,1"
            bitfld.long 0x00 28. "FAULT28,Latent communication Fault 28" "0,1"
            bitfld.long 0x00 27. "FAULT27,Latent communication Fault 27" "0,1"
            bitfld.long 0x00 26. "FAULT26,Latent communication Fault 26" "0,1"
            bitfld.long 0x00 25. "FAULT25,Latent communication Fault 25" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT24,Latent communication Fault 24" "0,1"
            bitfld.long 0x00 23. "FAULT23,Latent communication Fault 23" "0,1"
            bitfld.long 0x00 22. "FAULT22,Latent communication Fault 22" "0,1"
            bitfld.long 0x00 21. "FAULT21,Latent communication Fault 21" "0,1"
            bitfld.long 0x00 20. "FAULT20,Latent communication Fault 20" "0,1"
            bitfld.long 0x00 19. "FAULT19,Latent communication Fault 19" "0,1"
            bitfld.long 0x00 18. "FAULT18,Latent communication Fault 18" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT17,Latent communication Fault 17" "0,1"
            bitfld.long 0x00 16. "FAULT16,Latent communication Fault 16" "0,1"
            bitfld.long 0x00 15. "FAULT15,Latent communication Fault 15" "0,1"
            bitfld.long 0x00 14. "FAULT14,Latent communication Fault 14" "0,1"
            bitfld.long 0x00 13. "FAULT13,Latent communication Fault 13" "0,1"
            bitfld.long 0x00 12. "FAULT12,Latent communication Fault 12" "0,1"
            bitfld.long 0x00 11. "FAULT11,Latent communication Fault 11" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT10,Latent communication Fault 10" "0,1"
            bitfld.long 0x00 9. "FAULT9,Latent communication Fault 9" "0,1"
            bitfld.long 0x00 8. "FAULT8,Latent communication Fault 8" "0,1"
            bitfld.long 0x00 7. "FAULT7,Latent communication Fault 7" "0,1"
            bitfld.long 0x00 6. "FAULT6,Latent communication Fault 6" "0,1"
            bitfld.long 0x00 5. "FAULT5,Latent communication Fault 5" "0,1"
            bitfld.long 0x00 4. "FAULT4,Latent communication Fault 4" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT3,Latent communication Fault 3" "0,1"
            bitfld.long 0x00 2. "FAULT2,Latent communication Fault 2" "0,1"
            bitfld.long 0x00 1. "FAULT1,Latent communication Fault 1" "0,1"
            bitfld.long 0x00 0. "FAULT0,Latent communication Fault 0" "0,1"
    rgroup.long 0x58++0x03
        line.long 0x00 "LatentComFault1,latentcomfault1"
            bitfld.long 0x00 31. "FAULT63,Latent communication Fault 63" "0,1"
            bitfld.long 0x00 30. "FAULT62,Latent communication Fault 62" "0,1"
            bitfld.long 0x00 29. "FAULT61,Latent communication Fault 61" "0,1"
            bitfld.long 0x00 28. "FAULT60,Latent communication Fault 60" "0,1"
            bitfld.long 0x00 27. "FAULT59,Latent communication Fault 59" "0,1"
            bitfld.long 0x00 26. "FAULT58,Latent communication Fault 58" "0,1"
            bitfld.long 0x00 25. "FAULT57,Latent communication Fault 57" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT56,Latent communication Fault 56" "0,1"
            bitfld.long 0x00 23. "FAULT55,Latent communication Fault 55" "0,1"
            bitfld.long 0x00 22. "FAULT54,Latent communication Fault 54" "0,1"
            bitfld.long 0x00 21. "FAULT53,Latent communication Fault 53" "0,1"
            bitfld.long 0x00 20. "FAULT52,Latent communication Fault 52" "0,1"
            bitfld.long 0x00 19. "FAULT51,Latent communication Fault 51" "0,1"
            bitfld.long 0x00 18. "FAULT50,Latent communication Fault 50" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT49,Latent communication Fault 49" "0,1"
            bitfld.long 0x00 16. "FAULT48,Latent communication Fault 48" "0,1"
            bitfld.long 0x00 15. "FAULT47,Latent communication Fault 47" "0,1"
            bitfld.long 0x00 14. "FAULT46,Latent communication Fault 46" "0,1"
            bitfld.long 0x00 13. "FAULT45,Latent communication Fault 45" "0,1"
            bitfld.long 0x00 12. "FAULT44,Latent communication Fault 44" "0,1"
            bitfld.long 0x00 11. "FAULT43,Latent communication Fault 43" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT42,Latent communication Fault 42" "0,1"
            bitfld.long 0x00 9. "FAULT41,Latent communication Fault 41" "0,1"
            bitfld.long 0x00 8. "FAULT40,Latent communication Fault 40" "0,1"
            bitfld.long 0x00 7. "FAULT39,Latent communication Fault 39" "0,1"
            bitfld.long 0x00 6. "FAULT38,Latent communication Fault 38" "0,1"
            bitfld.long 0x00 5. "FAULT37,Latent communication Fault 37" "0,1"
            bitfld.long 0x00 4. "FAULT36,Latent communication Fault 36" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT35,Latent communication Fault 35" "0,1"
            bitfld.long 0x00 2. "FAULT34,Latent communication Fault 34" "0,1"
            bitfld.long 0x00 1. "FAULT33,Latent communication Fault 33" "0,1"
            bitfld.long 0x00 0. "FAULT32,Latent communication Fault 32" "0,1"
    rgroup.long 0x5C++0x03
        line.long 0x00 "LatentComFault2,latentcomfault2"
            bitfld.long 0x00 31. "FAULT95,Latent communication Fault 95" "0,1"
            bitfld.long 0x00 30. "FAULT94,Latent communication Fault 94" "0,1"
            bitfld.long 0x00 29. "FAULT93,Latent communication Fault 93" "0,1"
            bitfld.long 0x00 28. "FAULT92,Latent communication Fault 92" "0,1"
            bitfld.long 0x00 27. "FAULT91,Latent communication Fault 91" "0,1"
            bitfld.long 0x00 26. "FAULT90,Latent communication Fault 90" "0,1"
            bitfld.long 0x00 25. "FAULT89,Latent communication Fault 89" "0,1"
            newline
            bitfld.long 0x00 24. "FAULT88,Latent communication Fault 88" "0,1"
            bitfld.long 0x00 23. "FAULT87,Latent communication Fault 87" "0,1"
            bitfld.long 0x00 22. "FAULT86,Latent communication Fault 86" "0,1"
            bitfld.long 0x00 21. "FAULT85,Latent communication Fault 85" "0,1"
            bitfld.long 0x00 20. "FAULT84,Latent communication Fault 84" "0,1"
            bitfld.long 0x00 19. "FAULT83,Latent communication Fault 83" "0,1"
            bitfld.long 0x00 18. "FAULT82,Latent communication Fault 82" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT81,Latent communication Fault 81" "0,1"
            bitfld.long 0x00 16. "FAULT80,Latent communication Fault 80" "0,1"
            bitfld.long 0x00 15. "FAULT79,Latent communication Fault 79" "0,1"
            bitfld.long 0x00 14. "FAULT78,Latent communication Fault 78" "0,1"
            bitfld.long 0x00 13. "FAULT77,Latent communication Fault 77" "0,1"
            bitfld.long 0x00 12. "FAULT76,Latent communication Fault 76" "0,1"
            bitfld.long 0x00 11. "FAULT75,Latent communication Fault 75" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT74,Latent communication Fault 74" "0,1"
            bitfld.long 0x00 9. "FAULT73,Latent communication Fault 73" "0,1"
            bitfld.long 0x00 8. "FAULT72,Latent communication Fault 72" "0,1"
            bitfld.long 0x00 7. "FAULT71,Latent communication Fault 71" "0,1"
            bitfld.long 0x00 6. "FAULT70,Latent communication Fault 70" "0,1"
            bitfld.long 0x00 5. "FAULT69,Latent communication Fault 69" "0,1"
            bitfld.long 0x00 4. "FAULT68,Latent communication Fault 68" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT67,Latent communication Fault 67" "0,1"
            bitfld.long 0x00 2. "FAULT66,Latent communication Fault 66" "0,1"
            bitfld.long 0x00 1. "FAULT65,Latent communication Fault 65" "0,1"
            bitfld.long 0x00 0. "FAULT64,Latent communication Fault 64" "0,1"
    rgroup.long 0x60++0x03
        line.long 0x00 "LatentComFault3,latentcomfault3"
            bitfld.long 0x00 31. "CONSTANT_0_127,Reserved bit" "0,1"
            bitfld.long 0x00 30. "CONSTANT_0_126,Reserved bit" "0,1"
            bitfld.long 0x00 29. "CONSTANT_0_125,Reserved bit" "0,1"
            bitfld.long 0x00 28. "CONSTANT_0_124,Reserved bit" "0,1"
            bitfld.long 0x00 27. "CONSTANT_0_123,Reserved bit" "0,1"
            bitfld.long 0x00 26. "CONSTANT_0_122,Reserved bit" "0,1"
            bitfld.long 0x00 25. "CONSTANT_0_121,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 24. "CONSTANT_0_120,Reserved bit" "0,1"
            bitfld.long 0x00 23. "CONSTANT_0_119,Reserved bit" "0,1"
            bitfld.long 0x00 22. "CONSTANT_0_118,Reserved bit" "0,1"
            bitfld.long 0x00 21. "CONSTANT_0_117,Reserved bit" "0,1"
            bitfld.long 0x00 20. "CONSTANT_0_116,Reserved bit" "0,1"
            bitfld.long 0x00 19. "CONSTANT_0_115,Reserved bit" "0,1"
            bitfld.long 0x00 18. "CONSTANT_0_114,Reserved bit" "0,1"
            newline
            bitfld.long 0x00 17. "FAULT113,Latent communication Fault 113" "0,1"
            bitfld.long 0x00 16. "FAULT112,Latent communication Fault 112" "0,1"
            bitfld.long 0x00 15. "FAULT111,Latent communication Fault 111" "0,1"
            bitfld.long 0x00 14. "FAULT110,Latent communication Fault 110" "0,1"
            bitfld.long 0x00 13. "FAULT109,Latent communication Fault 109" "0,1"
            bitfld.long 0x00 12. "FAULT108,Latent communication Fault 108" "0,1"
            bitfld.long 0x00 11. "FAULT107,Latent communication Fault 107" "0,1"
            newline
            bitfld.long 0x00 10. "FAULT106,Latent communication Fault 106" "0,1"
            bitfld.long 0x00 9. "FAULT105,Latent communication Fault 105" "0,1"
            bitfld.long 0x00 8. "FAULT104,Latent communication Fault 104" "0,1"
            bitfld.long 0x00 7. "FAULT103,Latent communication Fault 103" "0,1"
            bitfld.long 0x00 6. "FAULT102,Latent communication Fault 102" "0,1"
            bitfld.long 0x00 5. "FAULT101,Latent communication Fault 101" "0,1"
            bitfld.long 0x00 4. "FAULT100,Latent communication Fault 100" "0,1"
            newline
            bitfld.long 0x00 3. "FAULT99,Latent communication Fault 99" "0,1"
            bitfld.long 0x00 2. "FAULT98,Latent communication Fault 98" "0,1"
            bitfld.long 0x00 1. "FAULT97,Latent communication Fault 97" "0,1"
            bitfld.long 0x00 0. "FAULT96,Latent communication Fault 96" "0,1"
tree.end

tree "CRC ()"
    base ad:0x91600000
    group.long 0x00++0x03
        line.long 0x00 "CH0_CTL,CRC Channel 0 Control Register"
            bitfld.long 0x00 24.--26. "POLY,Polynomial selection on channel 0 to generate CRC" "0: (poly = 0x1D),1: (poly = 0x2F),2: (poly = 0x1021),3: (poly = 0x04C11DB7),4: (poly = 0xF4ACFB13),?..."
            bitfld.long 0x00 18. "OUT_POL,Flip polarity of CRC channel 0 when set to 1" "0,1"
            bitfld.long 0x00 16. "OUT_REV,Reverse output bit endianness of CRC channel 0 when set to 1" "0,1"
            newline
            bitfld.long 0x00 4.--5. "BYTE_SHIFT,Number of bytes to right shift input Data after byte and bit reversing for channel 0" "0: No right shift,1: right shift by 1 byte,2: right shift by 2 byte,3: right shift by 3 byte"
            bitfld.long 0x00 3. "BIT_REV,Reverse Bit Order of Data written into CRC engine within byte boundary for channel 0" "0: standard bit order of CRC,1: Reverse bit order of CRC"
            bitfld.long 0x00 2. "BYTE_REV,Reverse Byte Order of Data written into CRC engine for channel 0" "0: standard byte order of CRC,1: Reverse byte order of CRC"
            newline
            bitfld.long 0x00 0.--1. "PAR,Parallelism selection for channel 0" "0: bits [7:0] of input data is unmasked while..,1: bits [15:0] of input data is unmasked while..,2: bits [24:0] of input data is unmasked while..,3: bits [31:0] of input data is unmasked while.."
    group.long 0x04++0x03
        line.long 0x00 "CH0_INIT,Initial Seed Value Register"
            hexmask.long 0x00 0.--31. 1. "SEED,Seed value for channel 0 CRC shift register"

    rgroup.long 0x08++0x03
        line.long 0x00 "CH0_OUT,Channel 0 CRC Output"
            hexmask.long 0x00 0.--31. 1. "DAT,Channel 0 CRC output"

    group.long 0x10++0x03
        line.long 0x00 "CH0_XIN0,Channel 0 CRC input 0"
            hexmask.long 0x00 0.--31. 1. "DAT,First block of 32-bit data written to CRC engine"
    group.long 0x14++0x03
        line.long 0x00 "CH0_XIN1,Channel 0 CRC input 1"
            hexmask.long 0x00 0.--31. 1. "DAT,Second block of 32-bit data written to CRC engine"
    group.long 0x18++0x03
        line.long 0x00 "CH0_XIN2,Channel 0 CRC input 2"
            hexmask.long 0x00 0.--31. 1. "DAT,Third block of 32-bit data written to CRC engine"
    group.long 0x1C++0x03
        line.long 0x00 "CH0_XIN3,Channel 0 CRC input 3"
            hexmask.long 0x00 0.--31. 1. "DAT,Fourth block of 32-bit data written to CRC engine"
    group.long 0x20++0x03
        line.long 0x00 "CH1_CTL,CRC Channel 1 Control Register"
            bitfld.long 0x00 24.--26. "POLY,Polynomial selection on channel 1 to generate CRC" "0: (poly = 0x1D),1: (poly = 0x2F),2: (poly = 0x1021),3: (poly = 0x04C11DB7),4: (poly = 0xF4ACFB13),?..."
            bitfld.long 0x00 18. "OUT_POL,Flip polarity of CRC channel 1 when set to 1" "0,1"
            bitfld.long 0x00 16. "OUT_REV,Reverse output bit endianness of CRC channel 1 when set to 1" "0,1"
            newline
            bitfld.long 0x00 4.--5. "BYTE_SHIFT,Number of bytes to right shift input Data after byte and bit reversing for channel 1" "0: No right shift,1: right shift by 1 byte,2: right shift by 2 byte,3: right shift by 3 byte"
            bitfld.long 0x00 3. "BIT_REV,Reverse Bit Order of Data written into CRC engine within byte boundary for channel 1" "0: standard bit order of CRC,1: Reverse bit order of CRC"
            bitfld.long 0x00 2. "BYTE_REV,Reverse Byte Order of Data written into CRC engine for channel 1" "0: standard byte order of CRC,1: Reverse byte order of CRC"
            newline
            bitfld.long 0x00 0.--1. "PAR,Parallelism selection for channel 1" "0: bits [7:0] of input data is unmasked while..,1: bits [15:0] of input data is unmasked while..,2: bits [24:0] of input data is unmasked while..,3: bits [31:0] of input data is unmasked while.."
    group.long 0x24++0x03
        line.long 0x00 "CH1_INIT,Initial Seed Value Register"
            hexmask.long 0x00 0.--31. 1. "SEED,Seed value for channel 1 CRC shift register"

    rgroup.long 0x28++0x03
        line.long 0x00 "CH1_OUT,Channel 1 CRC Output"
            hexmask.long 0x00 0.--31. 1. "DAT,Channel 1 CRC output"

    group.long 0x30++0x03
        line.long 0x00 "CH1_XIN0,Channel 1 CRC input 0"
            hexmask.long 0x00 0.--31. 1. "DAT,First block of 32-bit data written to CRC engine"
    group.long 0x34++0x03
        line.long 0x00 "CH1_XIN1,Channel 1 CRC input 1"
            hexmask.long 0x00 0.--31. 1. "DAT,Second block of 32-bit data written to CRC engine"
    group.long 0x38++0x03
        line.long 0x00 "CH1_XIN2,Channel 1 CRC input 2"
            hexmask.long 0x00 0.--31. 1. "DAT,Third block of 32-bit data written to CRC engine"
    group.long 0x3C++0x03
        line.long 0x00 "CH1_XIN3,Channel 1 CRC input 3"
            hexmask.long 0x00 0.--31. 1. "DAT,Fourth block of 32-bit data written to CRC engine"
    group.long 0x40++0x03
        line.long 0x00 "CH2_CTL,CRC Channel 2 Control Register"
            bitfld.long 0x00 24.--26. "POLY,Polynomial selection on channel 2 to generate CRC" "0: (poly = 0x1D),1: (poly = 0x2F),2: (poly = 0x1021),3: (poly = 0x04C11DB7),4: (poly = 0xF4ACFB13),?..."
            bitfld.long 0x00 18. "OUT_POL,Flip polarity of CRC channel 2 when set to 1" "0,1"
            bitfld.long 0x00 16. "OUT_REV,Reverse output bit endianness of CRC channel 2 when set to 1" "0,1"
            newline
            bitfld.long 0x00 4.--5. "BYTE_SHIFT,Number of bytes to right shift input Data after byte and bit reversing for channel 2" "0: No right shift,1: right shift by 1 byte,2: right shift by 2 byte,3: right shift by 3 byte"
            bitfld.long 0x00 3. "BIT_REV,Reverse Bit Order of Data written into CRC engine within byte boundary for channel 2" "0: standard bit order of CRC,1: Reverse bit order of CRC"
            bitfld.long 0x00 2. "BYTE_REV,Reverse Byte Order of Data written into CRC engine for channel 2" "0: standard byte order of CRC,1: Reverse byte order of CRC"
            newline
            bitfld.long 0x00 0.--1. "PAR,Parallelism selection for channel 2" "0: bits [7:0] of input data is unmasked while..,1: bits [15:0] of input data is unmasked while..,2: bits [24:0] of input data is unmasked while..,3: bits [31:0] of input data is unmasked while.."
    group.long 0x44++0x03
        line.long 0x00 "CH2_INIT,Initial Seed Value Register"
            hexmask.long 0x00 0.--31. 1. "SEED,Seed value for channel 2 CRC shift register"

    rgroup.long 0x48++0x03
        line.long 0x00 "CH2_OUT,Channel 2 CRC Output"
            hexmask.long 0x00 0.--31. 1. "DAT,Channel 2 CRC output"

    group.long 0x50++0x03
        line.long 0x00 "CH2_XIN0,Channel 2 CRC input 0"
            hexmask.long 0x00 0.--31. 1. "DAT,First block of 32-bit data written to CRC engine"
    group.long 0x54++0x03
        line.long 0x00 "CH2_XIN1,Channel 2 CRC input 1"
            hexmask.long 0x00 0.--31. 1. "DAT,Second block of 32-bit data written to CRC engine"
    group.long 0x58++0x03
        line.long 0x00 "CH2_XIN2,Channel 2 CRC input 2"
            hexmask.long 0x00 0.--31. 1. "DAT,Third block of 32-bit data written to CRC engine"
    group.long 0x5C++0x03
        line.long 0x00 "CH2_XIN3,Channel 2 CRC input 3"
            hexmask.long 0x00 0.--31. 1. "DAT,Fourth block of 32-bit data written to CRC engine"
    group.long 0x60++0x03
        line.long 0x00 "CH3_CTL,CRC Channel 3 Control Register"
            bitfld.long 0x00 24.--26. "POLY,Polynomial selection on channel 3 to generate CRC" "0: (poly = 0x1D),1: (poly = 0x2F),2: (poly = 0x1021),3: (poly = 0x04C11DB7),4: (poly = 0xF4ACFB13),?..."
            bitfld.long 0x00 18. "OUT_POL,Flip polarity of CRC channel 3 when set to 1" "0,1"
            bitfld.long 0x00 16. "OUT_REV,Reverse output bit endianness of CRC channel 3 when set to 1" "0,1"
            newline
            bitfld.long 0x00 4.--5. "BYTE_SHIFT,Number of bytes to right shift input Data after byte and bit reversing for channel 3" "0: No right shift,1: right shift by 1 byte,2: right shift by 2 byte,3: right shift by 3 byte"
            bitfld.long 0x00 3. "BIT_REV,Reverse Bit Order of Data written into CRC engine within byte boundary for channel 3" "0: standard bit order of CRC,1: Reverse bit order of CRC"
            bitfld.long 0x00 2. "BYTE_REV,Reverse Byte Order of Data written into CRC engine for channel 3" "0: standard byte order of CRC,1: Reverse byte order of CRC"
            newline
            bitfld.long 0x00 0.--1. "PAR,Parallelism selection for channel 3" "0: bits [7:0] of input data is unmasked while..,1: bits [15:0] of input data is unmasked while..,2: bits [24:0] of input data is unmasked while..,3: bits [31:0] of input data is unmasked while.."
    group.long 0x64++0x03
        line.long 0x00 "CH3_INIT,Initial Seed Value Register"
            hexmask.long 0x00 0.--31. 1. "SEED,Seed value for channel 3 CRC shift register"

    rgroup.long 0x68++0x03
        line.long 0x00 "CH3_OUT,Channel 3 CRC Output"
            hexmask.long 0x00 0.--31. 1. "DAT,Channel 3 CRC output"

    group.long 0x70++0x03
        line.long 0x00 "CH3_XIN0,Channel 3 CRC input 0"
            hexmask.long 0x00 0.--31. 1. "DAT,First block of 32-bit data written to CRC engine"
    group.long 0x74++0x03
        line.long 0x00 "CH3_XIN1,Channel 3 CRC input 1"
            hexmask.long 0x00 0.--31. 1. "DAT,Second block of 32-bit data written to CRC engine"
    group.long 0x78++0x03
        line.long 0x00 "CH3_XIN2,Channel 3 CRC input 2"
            hexmask.long 0x00 0.--31. 1. "DAT,Third block of 32-bit data written to CRC engine"
    group.long 0x7C++0x03
        line.long 0x00 "CH3_XIN3,Channel 3 CRC input 3"
            hexmask.long 0x00 0.--31. 1. "DAT,Fourth block of 32-bit data written to CRC engine"
tree.end

tree "CRG ()"
    base ad:0x89002000
    group.long 0x00++0x03
        line.long 0x00 "CLK_TOP_CTRL,Clock control register"
            bitfld.long 0x00 28.--29. "CTL_CG_MIPI_ESC_DIV,MIPI Escape Clock Divider Select" "0: 500 MHz Sys Clock Divided by 5 - 100 MHz,1: 500 MHz Sys Clock Divided by 6 - 83.3 MHz,2: 500 MHz Sys Clock Divided by 7 - 71.4 MHz,3: 500 MHz Sys Clock Divided by 8 - 62.5 MHz"
            newline
            bitfld.long 0x00 26.--27. "CTL_CG_SEL_CLK_TEST,Clock Test Select" "0,1,2,3"
            newline
            bitfld.long 0x00 24.--25. "CTL_CG_SEL_DSP_CLK,DSP Clock Divider Select" "0: SERDES 2.5GHz PLL Clock Divided by 3 - 833 MHz,1: SERDES 2.5GHz PLL Clock Divided by 5 - 500 MHz,2: SERDES 2.5GHz PLL Clock Divided by 4 - 625 MHz,3: SERDES 2.5GHz PLL Clock Divided by 2 - 1.25 GHz"
            newline
            bitfld.long 0x00 12. "CTL_CG_ART_SER_CKEN,Enable for Artie Serial clock" "0,1"
            newline
            bitfld.long 0x00 11. "CTL_CG_HSST_CKEN,Enable for HSST clock" "0,1"
            newline
            bitfld.long 0x00 10. "CTL_CG_MIPI_CKEN,Enable for MIPI system clock" "0,1"
            newline
            bitfld.long 0x00 9. "CTL_CG_DSP_CKEN,Enable for DSP clock" "0,1"
            newline
            bitfld.long 0x00 8. "CTL_CG_RA_CKEN,Enable for RA clock" "0,1"
            newline
            bitfld.long 0x00 2. "CTL_CG_ASER_DIV,Divide ratio for Artie Serial clock" "0: Div-by-5,1: Div-by-4"
            newline
            bitfld.long 0x00 1. "CTL_CG_WDG_SEL,Select source for Watchdog clock" "0: RC clock,1: Ref clock"
            newline
            bitfld.long 0x00 0. "CTL_CG_ROOT_SEL,Main clock select for Ref clock vs System Source clocks" "0: Ref clock,1: PLL output clock (500 MHz)"
    group.long 0x04++0x03
        line.long 0x00 "CLK_REF_FAIL_DETECTOR,Clock Reference Failure Detector Register"
            bitfld.long 0x00 12. "CTL_CKDET_FAIL_CLR,Register to clear reference clock failure flag" "0,1"
            newline
            rbitfld.long 0x00 8. "STS_CKDET_FAIL_FLAG,Register indicating clock failure on Reference Clock" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_CKDET_ENA,Register to enable clock failure detection on Reference Clock" "0,1"

    wgroup.long 0x08++0x03
        line.long 0x00 "RESET_ALL,Reset all"
            bitfld.long 0x00 0. "CTL_RG_REQ_ALL,Set to trigger a full reset of the system" "0,1"

    group.long 0x0C++0x03
        line.long 0x00 "RESET_REQ,Reset requests"
            bitfld.long 0x00 18. "CTL_RG_REQ_REF,Reset request for miscellaneous blocks such as PVT controllers" "0,1"
            newline
            bitfld.long 0x00 16. "CTL_RG_REQ_R52_CORE,R52 core reset" "0,1"
            newline
            bitfld.long 0x00 9. "CTL_RG_REQ_DSP_XOCD,Reset request for DSP debug features" "0,1"
            newline
            bitfld.long 0x00 8. "CTL_RG_REQ_DSP_BANK,Reset request for DSP top SFR bank" "0,1"
            newline
            bitfld.long 0x00 7. "CTL_RG_REQ_DBG,Reset request for Debug Subsystem" "0,1"
            newline
            bitfld.long 0x00 5. "CTL_RG_REQ_HSST,Reset request for HSST domain" "0,1"
            newline
            bitfld.long 0x00 3. "CTL_RG_REQ_MIPI_SYS,Reset request for MIPI system clock logic" "0,1"
            newline
            bitfld.long 0x00 2. "CTL_RG_REQ_DSP_CORE,Reset request for DSP core" "0,1"
            newline
            bitfld.long 0x00 1. "CTL_RG_REQ_ART_SER,Reset request for Artie Serial" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_RG_REQ_RA,Reset request for RA" "0,1"

    rgroup.long 0x10++0x03
        line.long 0x00 "RST_REASON_FLAG,Reset Reason Flag Register"
            bitfld.long 0x00 1. "BOR_1P8_FLAG,Flag indicates that the source has triggered a reset" "0,1"
            newline
            bitfld.long 0x00 0. "BOR_0P8_FLAG,Flag indicates that the source has triggered a reset" "0,1"

    group.long 0x14++0x03
        line.long 0x00 "RST_REASON_CLR,Reset Reason Flag Clear Register"
            bitfld.long 0x00 3. "BOR_1P8_FLAG_CLR,Set to send a single flag clear pulse" "0,1"
            newline
            bitfld.long 0x00 2. "BOR_0P8_FLAG_CLR,Set to send a single flag clear pulse" "0,1"

    rgroup.long 0x18++0x03
        line.long 0x00 "BOR_MGR_STATUS,BOR Status register gives information on the state of the BOR manager state machine"
            bitfld.long 0x00 2. "BOR_1P8_ARMED_ACK,Indicates the BOR Manager for 1.8V rail is ready and armed" "0: BOR Manager disabled,1: BOR Manager armed"
            newline
            bitfld.long 0x00 0. "BOR_0P8_ARMED_ACK,Indicates the BOR Manager for 0.8V rail is ready and armed" "0: BOR Manager disabled,1: BOR Manager armed"

    group.long 0x1C++0x03
        line.long 0x00 "BOR_0P8_TRIM,BOR Trim Control Register for 0.8V rail"
            bitfld.long 0x00 8. "BOR_0P8_ARM,BOR Armed Request 0.8V" "0,1"
            newline
            bitfld.long 0x00 0.--5. "BOR_0P8_TRIM,BOR Trim Adjust for 0.8V" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0x20++0x03
        line.long 0x00 "BOR_1P8_TRIM,BOR Trim Control Register for 1.8V rail"
            bitfld.long 0x00 8. "BOR_1P8_ARM,BOR Armed Request 1.8V" "0,1"
            newline
            bitfld.long 0x00 0.--5. "BOR_1P8_TRIM,BOR Trim Adjust for 1.8V" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0x24++0x03
        line.long 0x00 "BOR_0P8_OVRD,BOR Override controls to allow manual access to the hardware controlled logic"
            bitfld.long 0x00 3. "BOR_0P8_OVRD_REQ_SEL,BOR Manager Select" "0: BOR Manager request is driven by PMU..,1: BOR Manager request is driven by register bit.."
            newline
            bitfld.long 0x00 2. "BOR_0P8_OVRD_REQ_VAL,BOR Manager Request Value" "0: BOR Manager is requested to be disabled,1: BOR Manager is requested to be enabled"
            newline
            bitfld.long 0x00 1. "BOR_0P8_OVRD_RESET,BOR Reset Override" "0: Reset controlled by State-Machine Hardware,1: Reset Blocked"
            newline
            bitfld.long 0x00 0. "BOR_0P8_OVRD_BIAS,BOR Bias Override" "0: BIAS controlled by State-Machine Hardware,1: BIAS Forced to Enabled State"
    group.long 0x28++0x03
        line.long 0x00 "BOR_1P8_OVRD,BOR Override controls to allow manual access to the hardware controlled logic"
            bitfld.long 0x00 3. "BOR_1P8_OVRD_REQ_SEL,BOR Manager Select" "0: BOR Manager request is driven by PMU..,1: BOR Manager request is driven by register bit.."
            newline
            bitfld.long 0x00 2. "BOR_1P8_OVRD_REQ_VAL,BOR Manager Request Value" "0: BOR Manager is requested to be disabled,1: BOR Manager is requested to be enabled"
            newline
            bitfld.long 0x00 1. "BOR_1P8_OVRD_RESET,BOR Reset Override" "0: Reset controlled by State-Machine Hardware,1: Reset Blocked"
            newline
            bitfld.long 0x00 0. "BOR_1P8_OVRD_BIAS,BOR Bias Override" "0: BIAS controlled by State-Machine Hardware,1: BIAS Forced to Enabled State"

    rgroup.long 0x2C++0x03
        line.long 0x00 "BOR_MGR_TEST_DATA,BOR Test Data for 0.8V and 1.8V BOR Managers"
            hexmask.long.word 0x00 16.--31. 1. "BOR_1P8_TEST_DATA,Used for testing and development only"
            newline
            hexmask.long.word 0x00 0.--15. 1. "BOR_0P8_TEST_DATA,Used for testing and development only"

    group.long 0x30++0x03
        line.long 0x00 "AMUX_CTRL,PMU Control"
            bitfld.long 0x00 16. "CTL_AMUX_VSSD_ENA,Enable 10k pull-down on AMUX" "0,1"
            newline
            bitfld.long 0x00 15. "CTL_AMUX_BOR1P8_ENA,0.8V BOR AMUX test enable" "0,1"
            newline
            bitfld.long 0x00 14. "CTL_AMUX_BOR0P8_ENA,0.8V BOR AMUX test enable" "0,1"
            newline
            bitfld.long 0x00 13. "CTL_AMUX_PD_ENA,Enable 10k pull-down on AMUX" "0,1"
            newline
            bitfld.long 0x00 12. "CTL_AMUX_ADC_VIN0_ENA,Enable ADC_VIN0 switch to AMUX" "0,1"
            newline
            bitfld.long 0x00 11. "CTL_AMUX_SRDS_ENA,Enable ATESTOUT_SRDS switch to AMUX" "0,1"
            newline
            bitfld.long 0x00 10. "CTL_AMUX_ADC_ENA,Enable ADC switch to AMUX" "0,1"
            newline
            bitfld.long 0x00 9. "CTL_AMUX_BYP_ENA,Enable AMUX buffer bypass" "0,1"
            newline
            bitfld.long 0x00 8. "CTL_AMUX_BUF_ENA,Enable AMUX buffer" "0,1"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_ATB_SEL,PMU Analog Test Bus selection"
    group.long 0x34++0x03
        line.long 0x00 "RESET_LOCKOUT,SP reset lockout Control"
            bitfld.long 0x00 0.--3. "SP_RST_LOCKOUT,Security initiated SP (R52) reset lockout" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x38++0x03
        line.long 0x00 "CTL_ADD_FAIL_DETECTOR,Control for Additional Clocks Failure Detector Register"
            bitfld.long 0x00 13. "CTL_CKMIPI_DET_FAIL_CLR,Toggle to clear MIPI Clock failure flag" "0,1"
            newline
            bitfld.long 0x00 12. "CTL_CKMIPI_DET_ENA,Register to enable clock failure detection on MIPI Clock" "0,1"
            newline
            bitfld.long 0x00 9. "CTL_CKRA_DET_FAIL_CLR,Toggle to clear RA Clock failure flag" "0,1"
            newline
            bitfld.long 0x00 8. "CTL_CKRA_DET_ENA,Register to enable clock failure detection on RA Clock" "0,1"
            newline
            bitfld.long 0x00 5. "CTL_CKDSP_DET_FAIL_CLR,Toggle to clear DSP Clock failure flag" "0,1"
            newline
            bitfld.long 0x00 4. "CTL_CKDSP_DET_ENA,Register to enable clock failure detection on DSP Clock" "0,1"
            newline
            bitfld.long 0x00 1. "CTL_CKSYS_DET_FAIL_CLR,Toggle to clear System Clock failure flag" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_CKSYS_DET_ENA,Register to enable clock failure detection on System Clock" "0,1"

    rgroup.long 0x3C++0x03
        line.long 0x00 "STS_ADD_FAIL_DETECTOR,Status for Additional Clocks Failure Detector Register"
            bitfld.long 0x00 12. "STS_CKMIPI_DET_FAIL_FLAG,Register indicating clock failure on MIPI Clock" "0,1"
            newline
            bitfld.long 0x00 8. "STS_CKRA_DET_FAIL_FLAG,Register indicating clock failure on RA Clock" "0,1"
            newline
            bitfld.long 0x00 4. "STS_CKDSP_DET_FAIL_FLAG,Register indicating clock failure on DSP Clock" "0,1"
            newline
            bitfld.long 0x00 0. "STS_CKSYS_DET_FAIL_FLAG,Register indicating clock failure on System Clock" "0,1"

    group.long 0x40++0x03
        line.long 0x00 "CTL_FREQ_MON_SYS_TOP,Control for System Clock frequency monitor - top level"
            bitfld.long 0x00 24. "CTL_CFM_SYS_FREQ_SNAP,Toggle to take snapshot of valid frequency count for System Clock" "0,1"
            newline
            bitfld.long 0x00 16. "CTL_CFM_SYS_WIND_SKIP,Toggle to skip one count on the sampling window counter" "0,1"
            newline
            bitfld.long 0x00 8. "CTL_CFM_SYS_DUT_SKIP,Toggle to skip one count on the System Clock rollover counter" "0,1"
            newline
            bitfld.long 0x00 4.--5. "CTL_CFM_SYS_ERR_ENA,Enable for frequency over/under errors" "0,1,2,3"
            newline
            bitfld.long 0x00 2. "CTL_CFM_SYS_AUTO_SNAP,Set to automatically take a snapshot if there's a frequency over/under error" "0,1"
            newline
            bitfld.long 0x00 1. "CTL_CFM_SYS_CLR,Set to clear internal counters of frequency monitor for System Clock" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_CFM_SYS_ENA,Set to enable frequency monitor for System Clock" "0,1"
    group.long 0x44++0x03
        line.long 0x00 "CTL_FREQ_MON_SYS_WINDOW,Control for System Clock frequency monitor - window size"
            hexmask.long.byte 0x00 24.--30. 1. "CTL_CFM_SYS_DUT_SIZE,Rollover for System Clock"
            newline
            hexmask.long.tbyte 0x00 0.--19. 1. "CTL_CFM_SYS_WIND_SIZE,Sampling Window size for frequency monitor for System Clock"
    group.long 0x48++0x03
        line.long 0x00 "CTL_FREQ_MON_SYS_HI,Control for System Clock frequency monitor - high limit"
            hexmask.long.tbyte 0x00 0.--19. 1. "CTL_CFM_SYS_FREQ_HI,If frequency count is greater than this value then flag an over-frequency error"
    group.long 0x4C++0x03
        line.long 0x00 "CTL_FREQ_MON_SYS_LO,Control for System Clock frequency monitor - low limit"
            hexmask.long.tbyte 0x00 0.--19. 1. "CTL_CFM_SYS_FREQ_LO,If frequency count is less than this value then flag an under-frequency error"

    rgroup.long 0x50++0x03
        line.long 0x00 "STS_FREQ_MON_SYS_CNT,Status for System Clock frequency monitor"
            bitfld.long 0x00 24. "STS_CFM_SYS_FREQ_VAL,Snapshot of frequency count is valid" "0,1"

    group.long 0x54++0x03
        line.long 0x00 "IRQ_FREQ_MON_SYS,Interrupt sources for System Clock frequency monitor"
            bitfld.long 0x00 0.--1. "STS_CFM_SYS_ERR_VAL,Interrupt sources for System Clock frequency monitor" "0,1,2,3"

    rgroup.long 0x58++0x03
        line.long 0x00 "IRQ_FREQ_MON_SYS_NOMASK,Interrupt sources for System Clock frequency monitor without masking"
            hexmask.long.tbyte 0x00 8.--27. 1. "STS_CFM_SYS_FREQ_CNT,Snapshot of frequency count value"
            newline
            bitfld.long 0x00 0.--1. "STS_CFM_SYS_ERR_VAL_NOMASK,Interrupt sources for System Clock frequency monitor without masking" "0,1,2,3"

    group.long 0x5C++0x03
        line.long 0x00 "CTL_FREQ_MON_SRX_TOP,Control for SERDES Rx Clock frequency monitor - top level"
            bitfld.long 0x00 24. "CTL_CFM_SRX_FREQ_SNAP,Toggle to take snapshot of valid frequency count for SERDES Rx Clock" "0,1"
            newline
            bitfld.long 0x00 16. "CTL_CFM_SRX_WIND_SKIP,Toggle to skip one count on the sampling window counter" "0,1"
            newline
            bitfld.long 0x00 8. "CTL_CFM_SRX_DUT_SKIP,Toggle to skip one count on the SERDES Rx Clock rollover counter" "0,1"
            newline
            bitfld.long 0x00 4.--5. "CTL_CFM_SRX_ERR_ENA,Enable for frequency over/under errors" "0,1,2,3"
            newline
            bitfld.long 0x00 2. "CTL_CFM_SRX_AUTO_SNAP,Set to automatically take a snapshot if there's a frequency over/under error" "0,1"
            newline
            bitfld.long 0x00 1. "CTL_CFM_SRX_CLR,Set to clear internal counters of frequency monitor for SERDES Rx Clock" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_CFM_SRX_ENA,Set to enable frequency monitor for SERDES Rx Clock" "0,1"
    group.long 0x60++0x03
        line.long 0x00 "CTL_FREQ_MON_SRX_WINDOW,Control for SERDES Rx Clock frequency monitor - window size"
            bitfld.long 0x00 24.--29. "CTL_CFM_SRX_DUT_SIZE,Rollover for SERDES Rx Clock" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            hexmask.long.tbyte 0x00 0.--19. 1. "CTL_CFM_SRX_WIND_SIZE,Sampling Window size for frequency monitor for SERDES Rx Clock"
    group.long 0x64++0x03
        line.long 0x00 "CTL_FREQ_MON_SRX_HI,Control for SERDES Rx Clock frequency monitor - high limit"
            hexmask.long.tbyte 0x00 0.--19. 1. "CTL_CFM_SRX_FREQ_HI,If frequency count is greater than this value then flag an over-frequency error"
    group.long 0x68++0x03
        line.long 0x00 "CTL_FREQ_MON_SRX_LO,Control for SERDES Rx Clock frequency monitor - low limit"
            hexmask.long.tbyte 0x00 0.--19. 1. "CTL_CFM_SRX_FREQ_LO,If frequency count is less than this value then flag an under-frequency error"

    rgroup.long 0x6C++0x03
        line.long 0x00 "STS_FREQ_MON_SRX_CNT,Status for SERDES Rx Clock frequency monitor"
            bitfld.long 0x00 24. "STS_CFM_SRX_FREQ_VAL,Snapshot of frequency count is valid" "0,1"

    group.long 0x70++0x03
        line.long 0x00 "IRQ_FREQ_MON_SRX,Interrupt sources for SERDES Rx Clock frequency monitor"
            bitfld.long 0x00 0.--1. "STS_CFM_SRX_ERR_VAL,Interrupt sources for SERDES Rx Clock frequency monitor" "0,1,2,3"

    rgroup.long 0x74++0x03
        line.long 0x00 "IRQ_FREQ_MON_SRX_NOMASK,Interrupt sources for SERDES Rx Clock frequency monitor without masking"
            hexmask.long.tbyte 0x00 8.--27. 1. "STS_CFM_SRX_FREQ_CNT,Snapshot of frequency count value"
            newline
            bitfld.long 0x00 0.--1. "STS_CFM_SRX_ERR_VAL_NOMASK,Interrupt sources for SERDES Rx Clock frequency monitor without masking" "0,1,2,3"

    group.long 0x78++0x03
        line.long 0x00 "CTL_FREQ_MON_AO_TOP,Control for Always-On Clock frequency monitor - top level"
            bitfld.long 0x00 24. "CTL_CFM_AO_FREQ_SNAP,Toggle to take snapshot of valid frequency count for Always-On Clock" "0,1"
            newline
            bitfld.long 0x00 16. "CTL_CFM_AO_WIND_SKIP,Toggle to skip one count on the sampling window counter" "0,1"
            newline
            bitfld.long 0x00 8. "CTL_CFM_AO_DUT_SKIP,Toggle to skip one count on the Always-On Clock rollover counter" "0,1"
            newline
            bitfld.long 0x00 4.--5. "CTL_CFM_AO_ERR_ENA,Enable for frequency over/under errors" "0,1,2,3"
            newline
            bitfld.long 0x00 2. "CTL_CFM_AO_AUTO_SNAP,Set to automatically take a snapshot if there's a frequency over/under error" "0,1"
            newline
            bitfld.long 0x00 1. "CTL_CFM_AO_CLR,Set to clear internal counters of frequency monitor for Always-On Clock" "0,1"
            newline
            bitfld.long 0x00 0. "CTL_CFM_AO_ENA,Set to enable frequency monitor for Always-On Clock" "0,1"
    group.long 0x7C++0x03
        line.long 0x00 "CTL_FREQ_MON_AO_WINDOW,Control for Always-On Clock frequency monitor - window size"
            bitfld.long 0x00 24.--29. "CTL_CFM_AO_DUT_SIZE,Rollover for Always-On Clock" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            hexmask.long.tbyte 0x00 0.--19. 1. "CTL_CFM_AO_WIND_SIZE,Sampling Window size for frequency monitor for Always-On Clock"
    group.long 0x80++0x03
        line.long 0x00 "CTL_FREQ_MON_AO_HI,Control for Always-On Clock frequency monitor - high limit"
            hexmask.long.tbyte 0x00 0.--19. 1. "CTL_CFM_AO_FREQ_HI,If frequency count is greater than this value then flag an over-frequency error"
    group.long 0x84++0x03
        line.long 0x00 "CTL_FREQ_MON_AO_LO,Control for Always-On Clock frequency monitor - low limit"
            hexmask.long.tbyte 0x00 0.--19. 1. "CTL_CFM_AO_FREQ_LO,If frequency count is less than this value then flag an under-frequency error"

    rgroup.long 0x88++0x03
        line.long 0x00 "STS_FREQ_MON_AO_CNT,Status for Always-On Clock frequency monitor"
            bitfld.long 0x00 24. "STS_CFM_AO_FREQ_VAL,Snapshot of frequency count is valid" "0,1"

    group.long 0x8C++0x03
        line.long 0x00 "IRQ_FREQ_MON_AO,Interrupt sources for Always-On Clock frequency monitor"
            bitfld.long 0x00 0.--1. "STS_CFM_AO_ERR_VAL,Interrupt sources for Always-On Clock frequency monitor" "0,1,2,3"

    rgroup.long 0x90++0x03
        line.long 0x00 "IRQ_FREQ_MON_AO_NOMASK,Interrupt sources for Always-On Clock frequency monitor without masking"
            hexmask.long.tbyte 0x00 8.--27. 1. "STS_CFM_AO_FREQ_CNT,Snapshot of frequency count value"
            newline
            bitfld.long 0x00 0.--1. "STS_CFM_AO_ERR_VAL_NOMASK,Interrupt sources for Always-On Clock frequency monitor without masking" "0,1,2,3"

    group.long 0x94++0x03
        line.long 0x00 "CTL_RMON,Control for software-serviceable resets monitor"
            bitfld.long 0x00 16.--19. "CTL_RMON_SWS_FRC,Set to force testing of reset monitor of the resets" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0.--3. "CTL_RMON_SWS_ENA,Set to enable reset monitor" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x98++0x03
        line.long 0x00 "IRQ_RMON,Interrupt sources for software-serviceable resets monitor"
            bitfld.long 0x00 0.--3. "STS_RMON_SWS,Interrupt sources for software-serviceable resets monitor" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    rgroup.long 0x9C++0x03
        line.long 0x00 "IRQ_RMON_NOMASK,Interrupt sources for software-serviceable resets monitor without masking"
            bitfld.long 0x00 0.--3. "STS_RMON_SWS_NOMASK,Interrupt sources for software-serviceable resets monitor without masking" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    rgroup.long 0xA0++0x03
        line.long 0x00 "STS_RST,Status register for resets"
            bitfld.long 0x00 8. "STS_RST_DBG_BLOCK,If this field is '1' then the block for debug subsystem's reset is asserted and a self-reset will not be applied the debug subsystem" "0,1"
            newline
            bitfld.long 0x00 0.--3. "STS_POLICED_LOCKOUT,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.long 0xA4++0x03
        line.long 0x00 "CTL_RST_DBG,Status register for resets"
            hexmask.long.byte 0x00 8.--15. 1. "CTL_RST_DBG_RELEASE,Write 0x7B to this field to release the block on the debug subsystem's reset"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "CTL_RST_DBG_BLOCK,Write 0xE5 to this field to block the debug subsystem's reset such that a self-reset will not be applied the debug subsystem"
    group.long 0xA8++0x03
        line.long 0x00 "SPARE,Spare Register"
            hexmask.long 0x00 0.--31. 1. "SPARE,Spare registers"
    group.long 0xAC++0x03
        line.long 0x00 "CTL_LOCK,Lock control"
            hexmask.long 0x00 0.--31. 1. "CTL_CRG_LOCK_KEY,Write 0x9db8ca97 to allow write access to this SFR bank"

    rgroup.long 0xB0++0x03
        line.long 0x00 "STS_LOCK,Lock status"
            bitfld.long 0x00 0. "STS_CRG_LOCK_N,Lock status for this SFR bank" "0,1"
tree.end

tree "CSI ()"
    base ad:0x84410000
    group.long 0x00++0x03
        line.long 0x00 "CFG_MODE,cfg_mode"
            bitfld.long 0x00 31. "bist_start_bit,BIST start writing a 1 into this bit will start bist This field is referenced to clock core_clk" "0,1"
            bitfld.long 0x00 30. "cfg_bist_disable,BIST disable: writing a 1 to this bit will disable BIST" "0,1"
            newline
            hexmask.long.word 0x00 18.--29. 1. "reserved_29_18,reserved_29_18"
            bitfld.long 0x00 16.--17. "cfg_byte_data_format,For byte wide data types (RAW8 Embedded Blank NULL and user defined) selects the number of bytes to send to each pixel port" "0,1,2,3"
            newline
            rbitfld.long 0x00 12.--15. "reserved_15_12,reserved_15_12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 11. "cfg_scramble_en,Select either scramble mode or unscramble for the RX data for the TX data" "0: Scramble encryption off,1: Scramble encryption on"
            newline
            rbitfld.long 0x00 10. "reserved_10_10,reserved_10_10" "0,1"
            bitfld.long 0x00 9. "cfg_packet_interface_en,Selects packet interface instead of standard pixel interface" "0: Pixel Interface,1: Packet Interface"
            newline
            bitfld.long 0x00 8. "cfg_vcx_en,Enables Virtual Channel Extension (VCX) which number of virtual channels to 16 for D-PHY and 32 for C-PHY" "0,1"
            rbitfld.long 0x00 7. "reserved_7_7,reserved_7_7" "0,1"
            newline
            rbitfld.long 0x00 6. "reserved_6_6,reserved_6_6" "0,1"
            rbitfld.long 0x00 4.--5. "reserved_5_4,reserved_5_4" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--3. "cfg_num_lanes,Sets the number of active lanes that are to be used for receiving data" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x04++0x03
        line.long 0x00 "CFG_FLUSH_COUNT,cfg_flush_count"
            hexmask.long 0x00 4.--31. 1. "reserved_31_4,reserved_31_4"
            bitfld.long 0x00 0.--3. "cfg_flush_count,Count for flush counter" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x08++0x03
        line.long 0x00 "CFG_WATCHDOG_COUNT,cfg_watchdog_count"
            bitfld.long 0x00 31. "cfg_watchdog_en,Enable for watchdog timer" "0,1"
            hexmask.long.word 0x00 16.--30. 1. "reserved_30_16,reserved_30_16"
            newline
            hexmask.long.word 0x00 0.--15. 1. "cfg_watchdog_count,Count for watchdog timer"

    rgroup.long 0x0C++0x03
        line.long 0x00 "BIT_ERR,bit_err"
            hexmask.long.word 0x00 22.--31. 1. "reserved_31_22,reserved_31_22"
            bitfld.long 0x00 16.--21. "ecc_received_status,Captures the received ECC of the last packet This field is referenced to clock core_clk" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 15. "reserved_15_15,reserved_15_15" "0,1"
            hexmask.long.word 0x00 0.--14. 1. "bit_err,Captures the first Status event when either a one or two bit error occurs crc error or video interface errors with only the one bit error providing position information"
    rgroup.long 0x10++0x03
        line.long 0x00 "PAYLOAD_CRC,payload_crc"
            hexmask.long.word 0x00 16.--31. 1. "crc_calculated,Calculated CRC from last received long packet This field is referenced to clock core_clk"
            hexmask.long.word 0x00 0.--15. 1. "crc_received,Calculated CRC from last received long packet This field is referenced to clock core_clk"

    group.long 0x14++0x03
        line.long 0x00 "IRQ_STATUS,irq_status"
            hexmask.long.word 0x00 18.--31. 1. "reserved_31_18,reserved_31_18"
            bitfld.long 0x00 17. "irq_status_17,IRQ assertion of BIST done status This field is referenced to clock core_clk" "0,1"
            newline
            rbitfld.long 0x00 16. "reserved_16_16,reserved_16_16" "0,1"
            rbitfld.long 0x00 15. "reserved_15_15,reserved_15_15" "0,1"
            newline
            rbitfld.long 0x00 14. "reserved_14_14,reserved_14_14" "0,1"
            rbitfld.long 0x00 13. "reserved_13_13,reserved_13_13" "0,1"
            newline
            bitfld.long 0x00 12. "irq_status_12,IRQ assertion of csr_parity_error This field is referenced to clock core_clk" "0,1"
            bitfld.long 0x00 11. "irq_status_11,IRQ assertion of phy_status This field is referenced to clock core_clk" "0,1"
            newline
            bitfld.long 0x00 10. "irq_status_10,IRQ assertion of calibration active/cphy calibration active (if CPHY enabled) This field is referenced to clock core_clk" "0,1"
            bitfld.long 0x00 9. "irq_status_9,IRQ assertion of BIST error This field is referenced to clock core_clk" "0,1"
            newline
            bitfld.long 0x00 8. "irq_status_8,IRQ assertion of parity error This field is referenced to clock core_clk" "0,1"
            bitfld.long 0x00 7. "irq_status_7,IRQ assertion of internal error This field is referenced to clock core_clk" "0,1"
            newline
            bitfld.long 0x00 6. "irq_status_6,IRQ_assertion of watchdog error This field is referenced to clock core_clk" "0,1"
            bitfld.long 0x00 5. "irq_status_5,IRQ assertion of lane error This field is referenced to clock core_clk" "0,1"
            newline
            bitfld.long 0x00 4. "irq_status_4,IRQ assertion of ULPS mark changing This field is referenced to clock core_clk" "0,1"
            bitfld.long 0x00 3. "irq_status_3,IRQ assertion of ULPS active changing This field is referenced to clock core_clk" "0,1"
            newline
            bitfld.long 0x00 2. "irq_status_2,IRQ assertion of double bit ECC error This field is referenced to clock core_clk" "0,1"
            bitfld.long 0x00 1. "irq_status_1,IRQ_assertion of single bit ECC error This field is referenced to clock core_clk" "0,1"
            newline
            bitfld.long 0x00 0. "irq_status_0,IRQ assertion of CRC error This field is referenced to clock core_clk" "0,1"
    group.long 0x18++0x03
        line.long 0x00 "IRQ_ENABLE,irq_enable"
            hexmask.long.word 0x00 18.--31. 1. "reserved_31_18,reserved_31_18"
            bitfld.long 0x00 17. "irq_enable_17,IRQ enable of BIST done status" "0,1"
            newline
            rbitfld.long 0x00 16. "reserved_16_16,reserved_16_16" "0,1"
            rbitfld.long 0x00 15. "reserved_15_15,reserved_15_15" "0,1"
            newline
            rbitfld.long 0x00 14. "reserved_14_14,reserved_14_14" "0,1"
            rbitfld.long 0x00 13. "reserved_13_13,reserved_13_13" "0,1"
            newline
            bitfld.long 0x00 12. "irq_enable_12,IRQ enable for CSR Parity" "0,1"
            bitfld.long 0x00 11. "irq_enable_11,IRQ enable for phy status" "0,1"
            newline
            bitfld.long 0x00 10. "irq_enable_10,IRQ enable for calibration active" "0,1"
            bitfld.long 0x00 9. "irq_enable_9,IRQ enable for bist error" "0,1"
            newline
            bitfld.long 0x00 8. "irq_enable_8,IRQ enable for parity error" "0,1"
            bitfld.long 0x00 7. "irq_enable_7,IRQ enable for internal error" "0,1"
            newline
            bitfld.long 0x00 6. "irq_enable_6,IRQ_enable for watchdog error" "0,1"
            bitfld.long 0x00 5. "irq_enable_5,IRQ enable for lane error" "0,1"
            newline
            bitfld.long 0x00 4. "irq_enable_4,IRQ enable for ULPS mark change" "0,1"
            bitfld.long 0x00 3. "irq_enable_3,IRQ enable for ULPS active change" "0,1"
            newline
            bitfld.long 0x00 2. "irq_enable_2,IRQ enable for double bit ECC error" "0,1"
            bitfld.long 0x00 1. "irq_enable_1,IRQ enable for single bit ECC error" "0,1"
            newline
            bitfld.long 0x00 0. "irq_enable_0,IRQ enable for CRC error" "0,1"
    group.long 0x1C++0x03
        line.long 0x00 "CFG_DISABLE_PAYLOAD_0,cfg_disable_payload_0"
            hexmask.long 0x00 0.--31. 1. "cfg_disable_payload_31_0,CSI2 RX Controller cfg_diable_payload"
    group.long 0x20++0x03
        line.long 0x00 "CFG_DISABLE_PAYLOAD_1,cfg_disable_payload_1"
            hexmask.long.word 0x00 17.--31. 1. "reserved_63_49,reserved_63_49"
            hexmask.long.tbyte 0x00 0.--16. 1. "cfg_disable_payload_48_32,CSI2 RX Controller cfg_diable_payload"
    group.long 0x24++0x03
        line.long 0x00 "CFG_RX_USERDEF_DT_0,cfg_rx_userdef_dt_0"
            rbitfld.long 0x00 30.--31. "reserved_31_30,reserved_31_30" "0,1,2,3"
            bitfld.long 0x00 24.--29. "cfg_userdef_33h_dt,Data type for USERDEF_33H" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            rbitfld.long 0x00 22.--23. "reserved_23_22,reserved_23_22" "0,1,2,3"
            bitfld.long 0x00 16.--21. "cfg_userdef_32h_dt,Data type for USERDEF_32H" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            rbitfld.long 0x00 14.--15. "reserved_15_14,reserved_15_14" "0,1,2,3"
            bitfld.long 0x00 8.--13. "cfg_userdef_31h_dt,Data type for USERDEF_31H" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            rbitfld.long 0x00 6.--7. "reserved_7_6,reserved_7_6" "0,1,2,3"
            bitfld.long 0x00 0.--5. "cfg_userdef_30h_dt,Data type for USERDEF_30H" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0x28++0x03
        line.long 0x00 "CFG_RX_USERDEF_DT_1,cfg_rx_userdef_dt_1"
            rbitfld.long 0x00 30.--31. "reserved_31_30,reserved_31_30" "0,1,2,3"
            bitfld.long 0x00 24.--29. "cfg_userdef_37h_dt,Data type for USERDEF_37H" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            rbitfld.long 0x00 22.--23. "reserved_23_22,reserved_23_22" "0,1,2,3"
            bitfld.long 0x00 16.--21. "cfg_userdef_36h_dt,Data type for USERDEF_36H" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            rbitfld.long 0x00 14.--15. "reserved_15_14,reserved_15_14" "0,1,2,3"
            bitfld.long 0x00 8.--13. "cfg_userdef_35h_dt,Data type for USERDEF_35H" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            rbitfld.long 0x00 6.--7. "reserved_7_6,reserved_7_6" "0,1,2,3"
            bitfld.long 0x00 0.--5. "cfg_userdef_34h_dt,Data type for USERDEF_34H" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0x2C++0x03
        line.long 0x00 "CLOCK_LANE,clock_lane"
            bitfld.long 0x00 31. "cfg_clk_lane_en,Forces PHY Enable_n signals to 1'b0 when register is set to 1" "0,1"
            hexmask.long 0x00 2.--30. 1. "reserved_30_2,reserved_30_2"
            newline
            rbitfld.long 0x00 1. "ulps_clk_status,CSI2 RX ULPS status" "0,1"
            rbitfld.long 0x00 0. "ulps_clk_mark_status,CSI2 RX ULPS status" "0,1"
    group.long 0x30++0x03
        line.long 0x00 "LANE_0,lane_0"
            bitfld.long 0x00 31. "cfg_data_lane_en_ln0,Forces PHY Enable_n signals to 1'b0 when register is set to 1" "0,1"
            rbitfld.long 0x00 26.--30. "reserved_30_26,reserved_30_26" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 24.--25. "cfg_rx_lane0_sel,PPI Lane mux control for lane 0" "0: Data lane 0 on the Tx Controller gets data lane,1: Data lane 0 on the Tx Controller gets data lane,2: Data lane 0 on the Tx Controller gets data lane,3: Data lane 0 on the Tx Controller gets data lane"
            rbitfld.long 0x00 18.--23. "reserved_23_18,reserved_23_18" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            rbitfld.long 0x00 17. "reserved_17_17,reserved_17_17" "0,1"
            rbitfld.long 0x00 16. "reserved_16_16,reserved_16_16" "0,1"
            newline
            rbitfld.long 0x00 15. "reserved_15_15,reserved_15_15" "0,1"
            rbitfld.long 0x00 14. "reserved_14_14,reserved_14_14" "0,1"
            newline
            rbitfld.long 0x00 13. "reserved_13_13,reserved_13_13" "0,1"
            rbitfld.long 0x00 12. "reserved_12_12,reserved_12_12" "0,1"
            newline
            rbitfld.long 0x00 11. "reserved_11_11,reserved_11_11" "0,1"
            rbitfld.long 0x00 10. "reserved_10_10,reserved_10_10" "0,1"
            newline
            rbitfld.long 0x00 9. "reserved_9_9,reserved_9_9" "0,1"
            rbitfld.long 0x00 8. "reserved_8_8,reserved_8_8" "0,1"
            newline
            rbitfld.long 0x00 4.--7. "reserved_7_4,reserved_7_4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            rbitfld.long 0x00 3. "skewcal_status_ln0,Asserted if lane currently being calibrated See CSI-2 Controller User Guide description for additional information" "0,1"
            newline
            rbitfld.long 0x00 2. "stopstate_status_ln0,CSI2 RX PHY PPI StopState captured status from the PHY" "0,1"
            rbitfld.long 0x00 1. "ulps_status_ln0,CSI2 RX ULPS status" "0,1"
            newline
            rbitfld.long 0x00 0. "ulps_mark_status_ln0,CSI2 RX ULPS status" "0,1"
    group.long 0x34++0x03
        line.long 0x00 "LANE_1,lane_1"
            bitfld.long 0x00 31. "cfg_data_lane_en_ln1,Forces PHY Enable_n signals to 1'b0 when register is set to 1" "0,1"
            rbitfld.long 0x00 26.--30. "reserved_30_26,reserved_30_26" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 24.--25. "cfg_rx_lane1_sel,PPI Lane mux control for lane 1" "0: Data lane 1 on the Tx Controller gets data lane,1: Data lane 1 on the Tx Controller gets data lane,2: Data lane 1 on the Tx Controller gets data lane,3: Data lane 1 on the Tx Controller gets data lane"
            hexmask.long.word 0x00 15.--23. 1. "reserved_23_15,reserved_23_15"
            newline
            rbitfld.long 0x00 14. "reserved_14_14,reserved_14_14" "0,1"
            rbitfld.long 0x00 13. "reserved_13_13,reserved_13_13" "0,1"
            newline
            rbitfld.long 0x00 12. "reserved_12_12,reserved_12_12" "0,1"
            rbitfld.long 0x00 11. "reserved_11_11,reserved_11_11" "0,1"
            newline
            rbitfld.long 0x00 10. "reserved_10_10,reserved_10_10" "0,1"
            rbitfld.long 0x00 9. "reserved_9_9,reserved_9_9" "0,1"
            newline
            rbitfld.long 0x00 8. "reserved_8_8,reserved_8_8" "0,1"
            rbitfld.long 0x00 4.--7. "reserved_7_4,reserved_7_4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 3. "skewcal_status_ln1,Asserted if lane currently being calibrated See CSI-2 Controller User Guide description for additional information" "0,1"
            rbitfld.long 0x00 2. "stopstate_status_ln1,CSI2 RX PHY PPI StopState captured status from the PHY" "0,1"
            newline
            rbitfld.long 0x00 1. "ulps_status_ln1,CSI2 RX ULPS status" "0,1"
            rbitfld.long 0x00 0. "ulps_mark_status_ln1,CSI2 RX ULPS status" "0,1"
    group.long 0x38++0x03
        line.long 0x00 "LANE_2,lane_2"
            bitfld.long 0x00 31. "cfg_data_lane_en_ln2,Forces PHY Enable_n signals to 1'b0 when register is set to 1" "0,1"
            rbitfld.long 0x00 26.--30. "reserved_30_26,reserved_30_26" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 24.--25. "cfg_rx_lane2_sel,PPI Lane mux control for lane 2" "0: Data lane 2 on the Rx Controller gets data lane,1: Data lane 2 on the Rx Controller gets data lane,2: Data lane 2 on the Rx Controller gets data lane,3: Data lane 2 on the Rx Controller gets data lane"
            hexmask.long.word 0x00 15.--23. 1. "reserved_23_15,reserved_23_15"
            newline
            rbitfld.long 0x00 14. "reserved_14_14,reserved_14_14" "0,1"
            rbitfld.long 0x00 13. "reserved_13_13,reserved_13_13" "0,1"
            newline
            rbitfld.long 0x00 12. "reserved_12_12,reserved_12_12" "0,1"
            rbitfld.long 0x00 11. "reserved_11_11,reserved_11_11" "0,1"
            newline
            rbitfld.long 0x00 10. "reserved_10_10,reserved_10_10" "0,1"
            rbitfld.long 0x00 9. "reserved_9_9,reserved_9_9" "0,1"
            newline
            rbitfld.long 0x00 8. "reserved_8_8,reserved_8_8" "0,1"
            rbitfld.long 0x00 4.--7. "reserved_7_4,reserved_7_4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 3. "skewcal_status_ln2,Asserted if lane currently being calibrated See CSI-2 Controller User Guide description for additional information" "0,1"
            rbitfld.long 0x00 2. "stopstate_status_ln2,CSI2 RX PHY PPI StopState captured status from the PHY" "0,1"
            newline
            rbitfld.long 0x00 1. "ulps_status_ln2,CSI2 RX ULPS status" "0,1"
            rbitfld.long 0x00 0. "ulps_mark_status_ln2,CSI2 RX ULPS status" "0,1"
    group.long 0x3C++0x03
        line.long 0x00 "LANE_3,lane_3"
            bitfld.long 0x00 31. "cfg_data_lane_en_ln3,Forces PHY Enable_n signals to 1'b0 when register is set to 1" "0,1"
            rbitfld.long 0x00 26.--30. "reserved_30_26,reserved_30_26" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 24.--25. "cfg_rx_lane3_sel,PPI Lane mux control for lane 3" "0: Data lane 3 on the Rx Controller gets data lane,1: Data lane 3 on the Rx Controller gets data lane,2: Data lane 3 on the Rx Controller gets data lane,3: Data lane 3 on the Rx Controller gets data lane"
            hexmask.long.word 0x00 15.--23. 1. "reserved_23_15,reserved_23_15"
            newline
            rbitfld.long 0x00 14. "reserved_14_14,reserved_14_14" "0,1"
            rbitfld.long 0x00 13. "reserved_13_13,reserved_13_13" "0,1"
            newline
            rbitfld.long 0x00 12. "reserved_12_12,reserved_12_12" "0,1"
            rbitfld.long 0x00 11. "reserved_11_11,reserved_11_11" "0,1"
            newline
            rbitfld.long 0x00 10. "reserved_10_10,reserved_10_10" "0,1"
            rbitfld.long 0x00 9. "reserved_9_9,reserved_9_9" "0,1"
            newline
            rbitfld.long 0x00 8. "reserved_8_8,reserved_8_8" "0,1"
            rbitfld.long 0x00 4.--7. "reserved_7_4,reserved_7_4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 3. "skewcal_status_ln3,Asserted if lane currently being calibrated See CSI-2 Controller User Guide description for additional information" "0,1"
            rbitfld.long 0x00 2. "stopstate_status_ln3,CSI2 RX PHY PPI StopState captured status from the PHY" "0,1"
            newline
            rbitfld.long 0x00 1. "ulps_status_ln3,CSI2 RX ULPS status" "0,1"
            rbitfld.long 0x00 0. "ulps_mark_status_ln3,CSI2 RX ULPS status" "0,1"
tree.end

tree "DBGM_CTRL ()"
    base ad:0x84FFF000
    group.long 0x00++0x03
        line.long 0x00 "MAILBOX0,Debugger MailBox Register 0"
            hexmask.long 0x00 0.--31. 1. "MAILBOX0,Not Documented for security reasons"
    group.long 0x04++0x03
        line.long 0x00 "MAILBOX1,Debugger MailBox Register 1"
            hexmask.long 0x00 0.--31. 1. "MAILBOX1,Not Documented for security reasons"
    group.long 0x08++0x03
        line.long 0x00 "MAILBOX2,Debugger MailBox Register 2"
            hexmask.long 0x00 0.--31. 1. "MAILBOX2,Not Documented for security reasons"
    group.long 0x0C++0x03
        line.long 0x00 "MAILBOX3,Debugger MailBox Register 3"
            hexmask.long 0x00 0.--31. 1. "MAILBOX3,Not Documented for security reasons"
    group.long 0x10++0x03
        line.long 0x00 "MAILBOX4,Debugger MailBox Register 4"
            hexmask.long 0x00 0.--31. 1. "MAILBOX4,Not Documented for security reasons"
    group.long 0x14++0x03
        line.long 0x00 "MAILBOX5,Debugger MailBox Register 5"
            hexmask.long 0x00 0.--31. 1. "MAILBOX5,Not Documented for security reasons"
    group.long 0x18++0x03
        line.long 0x00 "MAILBOX_INT,Debugger MailBox Interrupt Register"
            bitfld.long 0x00 0. "DBG_MAILBOX_INTR,Not Documented for security reasons" "0,1"
    group.long 0x1C++0x03
        line.long 0x00 "SBI_ENA_CODE0,Special Boot Init Enable Code Register 0"
            hexmask.long 0x00 0.--31. 1. "SBI_ENA_CODE0,Not Documented for security reasons"
    group.long 0x20++0x03
        line.long 0x00 "SBI_ENA_CODE1,Special Boot Init Enable Code Register 1"
            hexmask.long 0x00 0.--31. 1. "SBI_ENA_CODE1,Not Documented for security reasons"
    group.long 0x24++0x03
        line.long 0x00 "SWD_ENA_CODE0,Serial Wire Debug Enable Code Register 0"
            hexmask.long 0x00 0.--31. 1. "SWD_ENA_CODE0,Not Documented for security reasons"
    group.long 0x28++0x03
        line.long 0x00 "SWD_ENA_CODE1,Serial Wire Debug Enable Code Register 1"
            hexmask.long 0x00 0.--31. 1. "SWD_ENA_CODE1,Not Documented for security reasons"
    group.long 0x2C++0x03
        line.long 0x00 "TRNG_ENA_CODE0,TRNG Test Modes Enable Code Register 0"
            hexmask.long 0x00 0.--31. 1. "TRNG_ENA_CODE0,Not Documented for security reasons"
    group.long 0x30++0x03
        line.long 0x00 "TRNG_ENA_CODE1,TRNG Test Modes Enable Code Register 1"
            hexmask.long 0x00 0.--31. 1. "TRNG_ENA_CODE1,Not Documented for security reasons"
    group.long 0x34++0x03
        line.long 0x00 "OTP_ENA_CODE0,OTP Test Mode Enable Code Register 0"
            hexmask.long 0x00 0.--31. 1. "OTP_ENA_CODE0,Not Documented for security reasons"
    group.long 0x38++0x03
        line.long 0x00 "OTP_ENA_CODE1,OTP Test Mode Enable Code Register 1"
            hexmask.long 0x00 0.--31. 1. "OTP_ENA_CODE1,Not Documented for security reasons"

    rgroup.long 0x3C++0x03
        line.long 0x00 "HSM_DEBUG_UNLOCK0,HSM Debug Unlock Register 0"
            hexmask.long 0x00 4.--31. 1. "HSM_DEBUG_UNLOCK0,Not Documented for security reasons"
    rgroup.long 0x40++0x03
        line.long 0x00 "HSM_DEBUG_UNLOCK1,HSM Debug Unlock Register 1"
            hexmask.long 0x00 0.--31. 1. "HSM_DEBUG_UNLOCK1,Not Documented for security reasons"
    rgroup.long 0x44++0x03
        line.long 0x00 "HSM_DEBUG_UNLOCK2,HSM Debug Unlock Register 2"
            hexmask.long 0x00 0.--31. 1. "HSM_DEBUG_UNLOCK2,Not Documented for security reasons"
    rgroup.long 0x48++0x03
        line.long 0x00 "HSM_DEBUG_UNLOCK3,HSM Debug Unlock Register 3"
            hexmask.long 0x00 0.--31. 1. "HSM_DEBUG_UNLOCK3,Not Documented for security reasons"
    rgroup.long 0x4C++0x03
        line.long 0x00 "HSM_DEVICE_LIFECYCLE,HSM Device Life Cycle Register"
            hexmask.long 0x00 0.--31. 1. "HSM_DEVICE_LIFECYCLE,Not Documented for security reasons"
    rgroup.long 0x50++0x03
        line.long 0x00 "HSM_MISC,HSM Misc Register"
            bitfld.long 0x00 4. "SPECIAL_BOOT_INIT,Not Documented for security reasons" "0,1"
            bitfld.long 0x00 0. "HSM_DEVICE_LIFECYCLE_VALID,Not Documented for security reasons" "0,1"

    group.long 0x54++0x03
        line.long 0x00 "AURORA_CTRL0,Aurora 8b10b Control 0 register"
            hexmask.long.word 0x00 16.--31. 1. "STATIC_CC_PERIOD,CC period"
            hexmask.long.word 0x00 0.--15. 1. "STATIC_VERIFICATION_TIMEOUT,Verification timeout"
    group.long 0x58++0x03
        line.long 0x00 "AURORA_CTRL1,Aurora 8b10b Control 1 register"
            bitfld.long 0x00 16. "CV_TIMEOUT_EN,CV Timeout Enable" "0,1"
            bitfld.long 0x00 12.--14. "UFC_SIZE_MSG,User Flow Control Message size" "0: 2 bytes,1: 4 bytes,2: 6 bytes,3: 8 bytes,4: 10 bytes,5: 12 bytes,6: 14 bytes,7: 16 bytes"
            bitfld.long 0x00 8. "UFC_TRANSMIT,User Flow Control transmit start bit" "0,1"
            bitfld.long 0x00 4. "TX_VERIFY,TX Verify control" "0,1"
            newline
            bitfld.long 0x00 0. "TX_ALIGNED,TX Aligned control" "0,1"
    group.long 0x5C++0x03
        line.long 0x00 "AURORA_CTRL2,Aurora 8b10b Control 2 register"
            hexmask.long 0x00 0.--31. 1. "UFC_DATA_3_0,1st set of 4 Data bytes of the User Flow Control Message (----.----.----.XXXX) LSB"
    group.long 0x60++0x03
        line.long 0x00 "AURORA_CTRL3,Aurora 8b10b Control 3 register"
            hexmask.long 0x00 0.--31. 1. "UFC_DATA_7_4,2nd set of 4 Data bytes of the User Flow Control Message (----.----.XXXX.----)"
    group.long 0x64++0x03
        line.long 0x00 "AURORA_CTRL4,Aurora 8b10b Control 4 register"
            hexmask.long 0x00 0.--31. 1. "UFC_DATA_11_8,3rd set of 4 Data bytes of the User Flow Control Message (----.XXXX.----.----)"
    group.long 0x68++0x03
        line.long 0x00 "AURORA_CTRL5,Aurora 8b10b Control 5 register"
            hexmask.long 0x00 0.--31. 1. "UFC_DATA_15_12,4th set of 4 Data bytes of the User Flow Control Message (XXXX.----.----.----) MSB"

    rgroup.long 0xFD0++0x03
        line.long 0x00 "PIDR4,Peripheral Identification Register 4"
            bitfld.long 0x00 0.--3. "DES_2,JEP106[10:7] continuation code" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    rgroup.long 0xFD4++0x03
        line.long 0x00 "PIDR5,Peripheral Identification Register 5"
            hexmask.long.byte 0x00 0.--7. 1. "PIDR5,The PIDR5 register is part of the set of peripheral identification registers"
    rgroup.long 0xFD8++0x03
        line.long 0x00 "PIDR6,Peripheral Identification Register 6"
            hexmask.long.byte 0x00 0.--7. 1. "PIDR6,The PIDR6 register is part of the set of peripheral identification registers"
    rgroup.long 0xFDC++0x03
        line.long 0x00 "PIDR7,Peripheral Identification Register 7"
            hexmask.long.byte 0x00 0.--7. 1. "PIDR7,The PIDR7 register is part of the set of peripheral identification registers"
    rgroup.long 0xFE0++0x03
        line.long 0x00 "PIDR0,Peripheral Identification Register 0"
            hexmask.long.byte 0x00 0.--7. 1. "PART_0,Part number bits[7:0]"
    rgroup.long 0xFE4++0x03
        line.long 0x00 "PIDR1,Peripheral Identification Register 1"
            bitfld.long 0x00 4.--7. "DES_0,JEP106 identification code bits[3:0]" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 0.--3. "PART_1,Part number bits[11:8]" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    rgroup.long 0xFE8++0x03
        line.long 0x00 "PIDR2,Peripheral Identification Register 2"
            bitfld.long 0x00 4.--7. "REVISION,Revision" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 3. "JEDEC,Indicates that a JEDEC assigned value is used" "0,1"
            bitfld.long 0x00 0.--2. "DES_1,JEP106 identification code bits[6:4]" "0,1,2,3,4,5,6,7"
    rgroup.long 0xFEC++0x03
        line.long 0x00 "PIDR3,Peripheral Identification Register 3"
            bitfld.long 0x00 4.--7. "REVAND,This field indicates minor errata fixes specific to this design for example metal fixes after implementation" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 0.--3. "CMOD,Customer Modified" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    rgroup.long 0xFF0++0x03
        line.long 0x00 "CIDR0,Component Identification Register 0"
            hexmask.long 0x00 0.--31. 1. "CIDR0,cidr0"
    rgroup.long 0xFF4++0x03
        line.long 0x00 "CIDR1,Component Identification Register 1"
            hexmask.long 0x00 0.--31. 1. "CIDR1,cidr1"
    rgroup.long 0xFF8++0x03
        line.long 0x00 "CIDR2,Component Identification Register 2"
            hexmask.long 0x00 0.--31. 1. "CIDR2,cidr2"
    rgroup.long 0xFFC++0x03
        line.long 0x00 "CIDR3,Component Identification Register 3"
            hexmask.long 0x00 0.--31. 1. "CIDR3,cidr3"
tree.end

tree "DBGM_ROM ()"
    base ad:0x84FFE000
    rgroup.long 0x00++0x03
        line.long 0x00 "ROMENTRY0,ROM Entries register 0"
            hexmask.long 0x00 0.--31. 1. "ROMENTRY0,The component address relative to the base address of this ROM table"
    rgroup.long 0xFBC++0x03
        line.long 0x00 "DEVARCH,Device Architecture Register"
            hexmask.long 0x00 0.--31. 1. "DEVARCH,Identifies the architect and architecture of a CoreSight component"
    rgroup.long 0xFC8++0x03
        line.long 0x00 "DEVID,Device Configuration Register"
            hexmask.long 0x00 0.--31. 1. "DEVID,The register indicates the capabilities of the component"
    rgroup.long 0xFD0++0x03
        line.long 0x00 "PIDR4,Peripheral Identification Register 4"
            bitfld.long 0x00 0.--3. "DES_2,JEP106[10:7] continuation code" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    rgroup.long 0xFD4++0x03
        line.long 0x00 "PIDR5,Peripheral Identification Register 5"
            hexmask.long.byte 0x00 0.--7. 1. "PIDR5,The PIDR5 register is part of the set of peripheral identification registers"
    rgroup.long 0xFD8++0x03
        line.long 0x00 "PIDR6,Peripheral Identification Register 6"
            hexmask.long.byte 0x00 0.--7. 1. "PIDR6,The PIDR6 register is part of the set of peripheral identification registers"
    rgroup.long 0xFDC++0x03
        line.long 0x00 "PIDR7,Peripheral Identification Register 7"
            hexmask.long.byte 0x00 0.--7. 1. "PIDR7,The PIDR7 register is part of the set of peripheral identification registers"
    rgroup.long 0xFE0++0x03
        line.long 0x00 "PIDR0,Peripheral Identification Register 0"
            hexmask.long.byte 0x00 0.--7. 1. "PART_0,Part number bits[7:0]"
    rgroup.long 0xFE4++0x03
        line.long 0x00 "PIDR1,Peripheral Identification Register 1"
            bitfld.long 0x00 4.--7. "DES_0,JEP106 identification code bits[3:0]" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 0.--3. "PART_1,Part number bits[11:8]" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    rgroup.long 0xFE8++0x03
        line.long 0x00 "PIDR2,Peripheral Identification Register 2"
            bitfld.long 0x00 4.--7. "REVISION,Revision" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 3. "JEDEC,Indicates that a JEDEC assigned value is used" "0,1"
            bitfld.long 0x00 0.--2. "DES_1,JEP106 identification code bits[6:4]" "0,1,2,3,4,5,6,7"
    rgroup.long 0xFEC++0x03
        line.long 0x00 "PIDR3,Peripheral Identification Register 3"
            bitfld.long 0x00 4.--7. "REVAND,This field indicates minor errata fixes specific to this design for example metal fixes after implementation" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            bitfld.long 0x00 0.--3. "CMOD,Customer Modified" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    rgroup.long 0xFF0++0x03
        line.long 0x00 "CIDR0,Component Identification Register 0"
            hexmask.long 0x00 0.--31. 1. "CIDR0,cidr0"
    rgroup.long 0xFF4++0x03
        line.long 0x00 "CIDR1,Component Identification Register 1"
            hexmask.long 0x00 0.--31. 1. "CIDR1,cidr1"
    rgroup.long 0xFF8++0x03
        line.long 0x00 "CIDR2,Component Identification Register 2"
            hexmask.long 0x00 0.--31. 1. "CIDR2,cidr2"
    rgroup.long 0xFFC++0x03
        line.long 0x00 "CIDR3,Component Identification Register 3"
            hexmask.long 0x00 0.--31. 1. "CIDR3,cidr3"
tree.end

tree "DMA ()"
    base ad:0x91400000
    rgroup.quad 0x00++0x07
        line.quad 0x00 "DMAC_IDREG,DMAC ID Register contains a 32-bit value that is hardwired and read back by a read to the DW_axi_dmac ID Register"
            hexmask.quad.long 0x00 32.--63. 1. "RSVD_DMAC_IDREG,DMAC_IDREG Reserved bits - Read Only"
            newline
            hexmask.quad.long 0x00 0.--31. 1. "DMAC_ID,DMAC ID Number"
    rgroup.quad 0x08++0x07
        line.quad 0x00 "DMAC_COMPVERREG,This register contains a 32-bit value that is hardwired and read back by a read to the DW_axi_dmac Component Version Register"
            hexmask.quad.long 0x00 32.--63. 1. "RSVD_DMAC_COMPVERREG,DMAC_COMPVERREG Reserved bits - Read Only"
            newline
            hexmask.quad.long 0x00 0.--31. 1. "DMAC_COMPVER,DMAC Component Version Number"

    group.quad 0x10++0x07
        line.quad 0x00 "DMAC_CFGREG,This register is used to enable the DW_axi_dmac which must be done before any channel activity can begin"
            hexmask.quad 0x00 2.--63. 1. "RSVD_DMAC_CFGREG,DMAC_CFGREG Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 1. "INT_EN,This bit is used to globally enable the interrupt generation" "0: DW_axi_dmac Interrupts are disabled,1: DW_axi_dmac Interrupts are enabled"
            newline
            bitfld.quad 0x00 0. "DMAC_EN,This bit is used to enable the DW_axi_dmac" "0: DW_axi_dmac is disabled,1: DW_axi_dmac is enabled"
    group.quad 0x18++0x07
        line.quad 0x00 "DMAC_CHENREG,This is DW_axi_dmac Channel Enable Register"
            hexmask.quad.word 0x00 48.--63. 1. "RSVD_DMAC_CHENREG,DMAC_CHENREG Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 44.--47. "RSVD_DMAC_CHENREG_CH_ABORT_WE,CH_ABORT_WE Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.quad 0x00 43. "CH4_ABORT_WE,This bit is used to write enable the Channel-4 Abort bit" "0: Disable Write to CH4_ABORT bit,1: Enable Write to CH4_ABORT bit"
            newline
            rbitfld.quad 0x00 42. "CH3_ABORT_WE,This bit is used to write enable the Channel-3 Abort bit" "0: Disable Write to CH3_ABORT bit,1: Enable Write to CH3_ABORT bit"
            newline
            rbitfld.quad 0x00 41. "CH2_ABORT_WE,This bit is used to write enable the Channel-2 Abort bit" "0: Disable Write to CH2_ABORT bit,1: Enable Write to CH2_ABORT bit"
            newline
            rbitfld.quad 0x00 40. "CH1_ABORT_WE,This bit is used to write enable the Channel-1 Abort bit" "0: Disable Write to CH1_ABORT bit,1: Enable Write to CH1_ABORT bit"
            newline
            rbitfld.quad 0x00 36.--39. "RSVD_DMAC_CHENREG_CH_ABORT,CH_ABORT Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.quad 0x00 35. "CH4_ABORT,Channel-4 Abort Request" "0: No Request for Channel-4 Abort,1: Request for Channel-4 Abort"
            newline
            rbitfld.quad 0x00 34. "CH3_ABORT,Channel-3 Abort Request" "0: No Request for Channel-3 Abort,1: Request for Channel-3 Abort"
            newline
            rbitfld.quad 0x00 33. "CH2_ABORT,Channel-2 Abort Request" "0: No Request for Channel-2 Abort,1: Request for Channel-2 Abort"
            newline
            rbitfld.quad 0x00 32. "CH1_ABORT,Channel-1 Abort Request" "0: No Request for Channel-1 Abort,1: Request for Channel-1 Abort"
            newline
            rbitfld.quad 0x00 28.--31. "RSVD_DMAC_CHENREG_CH_SUSP_WE,CH_SUSP_WE Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 27. "CH4_SUSP_WE,This bit is used as a write enable to the Channel-4 Suspend bit" "0: Disable Write to CH4_SUSP bit,1: Enable Write to respective CH4_SUSP bit"
            newline
            bitfld.quad 0x00 26. "CH3_SUSP_WE,This bit is used as a write enable to the Channel-3 Suspend bit" "0: Disable Write to CH3_SUSP bit,1: Enable Write to respective CH3_SUSP bit"
            newline
            bitfld.quad 0x00 25. "CH2_SUSP_WE,This bit is used as a write enable to the Channel-2 Suspend bit" "0: Disable Write to CH2_SUSP bit,1: Enable Write to respective CH2_SUSP bit"
            newline
            bitfld.quad 0x00 24. "CH1_SUSP_WE,This bit is used as a write enable to the Channel-1 Suspend bit" "0: Disable Write to CH1_SUSP bit,1: Enable Write to respective CH1_SUSP bit"
            newline
            rbitfld.quad 0x00 20.--23. "RSVD_DMAC_CHENREG_CH_SUSP,CH_SUSP Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 19. "CH4_SUSP,Channel-4 Suspend Request" "0: No Channel Suspend Request,1: Request to Suspended Channel-4"
            newline
            bitfld.quad 0x00 18. "CH3_SUSP,Channel-3 Suspend Request" "0: No Channel Suspend Request,1: Request to Suspended Channel-3"
            newline
            bitfld.quad 0x00 17. "CH2_SUSP,Channel-2 Suspend Request" "0: No Channel Suspend Request,1: Request to Suspended Channel-2"
            newline
            bitfld.quad 0x00 16. "CH1_SUSP,Channel-1 Suspend Request" "0: No Channel Suspend Request,1: Request to Suspended Channel-1"
            newline
            rbitfld.quad 0x00 12.--15. "RSVD_DMAC_CHENREG_CH_WE_EN,CH_WE_EN Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 11. "CH4_EN_WE,DW_axi_dmac Channel-4 Enable Write Enable bit" "0: Disable Write to respective CH4_EN bit,1: Enable Write to CH4_EN bit"
            newline
            bitfld.quad 0x00 10. "CH3_EN_WE,DW_axi_dmac Channel-3 Enable Write Enable bit" "0: Disable Write to respective CH3_EN bit,1: Enable Write to CH3_EN bit"
            newline
            bitfld.quad 0x00 9. "CH2_EN_WE,DW_axi_dmac Channel-2 Enable Write Enable bit" "0: Disable Write to respective CH2_EN bit,1: Enable Write to CH2_EN bit"
            newline
            bitfld.quad 0x00 8. "CH1_EN_WE,DW_axi_dmac Channel-1 Enable Write Enable bit" "0: Disable Write to respective CH1_EN bit,1: Enable Write to CH1_EN bit"
            newline
            rbitfld.quad 0x00 4.--7. "RSVD_DMAC_CHENREG_CH_EN,CH_EN Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 3. "CH4_EN,This bit is used to enable the DW_axi_dmac Channel-4" "0: DW_axi_dmac,1: DW_axi_dmac"
            newline
            bitfld.quad 0x00 2. "CH3_EN,This bit is used to enable the DW_axi_dmac Channel-3" "0: DW_axi_dmac,1: DW_axi_dmac"
            newline
            bitfld.quad 0x00 1. "CH2_EN,This bit is used to enable the DW_axi_dmac Channel-2" "0: DW_axi_dmac,1: DW_axi_dmac"
            newline
            bitfld.quad 0x00 0. "CH1_EN,This bit is used to enable the DW_axi_dmac Channel-1" "0: DW_axi_dmac,1: DW_axi_dmac"

    rgroup.quad 0x30++0x07
        line.quad 0x00 "DMAC_INTSTATUSREG,DMAC Interrupt Status Register captures the combined channel interrupt for each channel and Combined common register block interrupt"
            hexmask.quad.quad 0x00 17.--63. 1. "RSVD_DMAC_INTSTATUSREG_63to17,DMAC Interrupt Status Register (bits 63to17) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 16. "CommonReg_IntStat,Common Register Interrupt Status Bit" "0: Common Register Interrupt is Inactive,1: Common Register Interrupt is Active"
            newline
            hexmask.quad.byte 0x00 8.--15. 1. "RSVD_DMAC_INTSTATUSREG,DMAC Interrupt Status Register (bits 15to8) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 4.--7. "RSVD_DMAC_INTSTATUSREG_8to1,DMAC_INTSTATUSREG Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 3. "CH4_IntStat,Channel 4 Interrupt Status Bit" "0: Channel {ch_num} Interrupt is Inactive,1: Channel {ch_num} Interrupt is Active"
            newline
            bitfld.quad 0x00 2. "CH3_IntStat,Channel 3 Interrupt Status Bit" "0: Channel {ch_num} Interrupt is Inactive,1: Channel {ch_num} Interrupt is Active"
            newline
            bitfld.quad 0x00 1. "CH2_IntStat,Channel 2 Interrupt Status Bit" "0: Channel {ch_num} Interrupt is Inactive,1: Channel {ch_num} Interrupt is Active"
            newline
            bitfld.quad 0x00 0. "CH1_IntStat,Channel 1 Interrupt Status Bit" "0: Channel {ch_num} Interrupt is Inactive,1: Channel {ch_num} Interrupt is Active"

    wgroup.quad 0x38++0x07
        line.quad 0x00 "DMAC_COMMONREG_INTCLEARREG,Writing 1 to specific field clears the corresponding field in DMAC Common register Interrupt Status Register (DMAC_CommonReg_IntStatusReg)"
            hexmask.quad.quad 0x00 21.--63. 1. "RSVD_DMAC_COMMONREG_INTCLEARREG_63to21,DMAC Common Register Interrupt Clear Register (bits 63to21) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 20. "Clear_MXIF2_BCH_EccPROT_UnCorrERR_IntStat,AXI Master Interface 2 Write Response Channel ECC Protection related Uncorrectable Error Interrupt Clear bit" "0: Inactive signal,1: Clear the MXIF2_BCH_EccPROT_UnCorrERR_IntStat.."
            newline
            bitfld.quad 0x00 19. "Clear_MXIF2_BCH_EccPROT_CorrERR_IntStat,AXI Master Interface 2 Write Response Channel ECC Protection related Correctable Error Interrupt Clear bit" "0: Inactive signal,1: Clear the MXIF2_BCH_EccPROT_CorrERR_IntStat.."
            newline
            bitfld.quad 0x00 18. "Clear_MXIF2_RCH1_EccPROT_UnCorrERR_IntStat,AXI Master Interface 2 Read Channel (Other Control signals) ECC Protection related Uncorrectable Error Interrupt Clear bit" "0: Inactive signal,1: Clear the.."
            newline
            bitfld.quad 0x00 17. "Clear_MXIF2_RCH1_EccPROT_CorrERR_IntStat,AXI Master Interface 2 Read Channel (Other Control signals) ECC Protection related Correctable Error Interrupt Clear bit" "0: Inactive signal,1: Clear the MXIF2_RCH1_EccPROT_CorrERR_IntStat.."
            newline
            bitfld.quad 0x00 16. "Clear_MXIF2_RCH0_EccPROT_UnCorrERR_IntStat,AXI Master Interface 2 Read Channel (Data) ECC Protection related Uncorrectable Error Interrupt Clear bit" "0: Inactive signal,1: Clear the.."
            newline
            bitfld.quad 0x00 15. "Clear_MXIF2_RCH0_EccPROT_CorrERR_IntStat,AXI Master Interface 2 Read Channel (Data) ECC Protection related Correctable Error Interrupt Clear bit" "0: Inactive signal,1: Clear the MXIF2_RCH0_EccPROT_CorrERR_IntStat.."
            newline
            bitfld.quad 0x00 14. "Clear_MXIF1_BCH_EccPROT_UnCorrERR_IntStat,AXI Master Interface 1 Write Response Channel ECC Protection related Uncorrectable Error Interrupt Clear bit" "0: Inactive signal,1: Clear the MXIF1_BCH_EccPROT_UnCorrERR_IntStat.."
            newline
            bitfld.quad 0x00 13. "Clear_MXIF1_BCH_EccPROT_CorrERR_IntStat,AXI Master Interface 1 Write Response Channel ECC Protection related Correctable Error Interrupt Clear bit" "0: Inactive signal,1: Clear the MXIF1_BCH_EccPROT_CorrERR_IntStat.."
            newline
            bitfld.quad 0x00 12. "Clear_MXIF1_RCH1_EccPROT_UnCorrERR_IntStat,AXI Master Interface 1 Read Channel (Other Control signals) ECC Protection related Uncorrectable Error Interrupt Clear bit" "0: Inactive signal,1: Clear the.."
            newline
            bitfld.quad 0x00 11. "Clear_MXIF1_RCH1_EccPROT_CorrERR_IntStat,AXI Master Interface 1 Read Channel (Other Control signals) ECC Protection related Correctable Error Interrupt Clear bit" "0: Inactive signal,1: Clear the MXIF1_RCH1_EccPROT_CorrERR_IntStat.."
            newline
            bitfld.quad 0x00 10. "Clear_MXIF1_RCH0_EccPROT_UnCorrERR_IntStat,AXI Master Interface 1 Read Channel (Data) ECC Protection related Uncorrectable Error Interrupt Clear bit" "0: Inactive signal,1: Clear the.."
            newline
            bitfld.quad 0x00 9. "Clear_MXIF1_RCH0_EccPROT_CorrERR_IntStat,AXI Master Interface 1 Read Channel (Data) ECC Protection related Correctable Error Interrupt Clear bit" "0: Inactive signal,1: Clear the MXIF1_RCH0_EccPROT_CorrERR_IntStat.."
            newline
            bitfld.quad 0x00 8. "Clear_SLVIF_UndefinedReg_DEC_ERR_IntStat,Slave Interface Undefined register Decode Error Interrupt clear Bit" "0: Inactive signal,1: Clear the SLVIF_UndefinedReg_DEC_ERR.."
            newline
            bitfld.quad 0x00 7. "Clear_SLVIF_CommonReg_WRPARITY_ERR_IntStat,Slave Interface Common Register Write Parity Error Interrupt clear Bit" "0: Inactive signal,1: Clear the SLVIF_CommonReg_WRPARITY_ERR.."
            newline
            bitfld.quad 0x00 4.--6. "RSVD_DMAC_COMMONREG_INTCLEARREG_6to4,DMAC Common Register Interrupt Clear Register (bits 6to4) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 3. "Clear_SLVIF_CommonReg_WrOnHold_ERR_IntStat,Slave Interface Common Register Write On Hold Error Interrupt clear Bit" "0: Inactive signal,1: Clear the SLVIF_CommonReg_WrOnHold_ERR.."
            newline
            bitfld.quad 0x00 2. "Clear_SLVIF_CommonReg_RD2WO_ERR_IntStat,Slave Interface Common Register Read to Write only Error Interrupt clear Bit" "0: Inactive signal,1: Clear the SLVIF_CommonReg_RD2WO_ERR interrupt.."
            newline
            bitfld.quad 0x00 1. "Clear_SLVIF_CommonReg_WR2RO_ERR_IntStat,Slave Interface Common Register Write to Read only Error Interrupt clear Bit" "0: Inactive signal,1: Clear the SLVIF_CommonReg_WR2RO_ERR interrupt.."
            newline
            bitfld.quad 0x00 0. "Clear_SLVIF_CommonReg_DEC_ERR_IntStat,Slave Interface Common Register Decode Error Interrupt clear Bit" "0: Inactive signal,1: Clear the SLVIF_CommonReg_DEC_ERR interrupt.."

    group.quad 0x40++0x07
        line.quad 0x00 "DMAC_COMMONREG_INTSTATUS_ENABLEREG,Writing 1 to specific field enables the corresponding interrupt status generation in DMAC Common register Interrupt Status Register (DMAC_CommonReg_IntStatusReg)"
            hexmask.quad.quad 0x00 21.--63. 1. "RSVD_DMAC_COMMONREG_INTSTATUS_ENABLEREG_63to21,DMAC Common Register Interrupt Status Enable Register (bits 63to21) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 20. "Enable_MXIF2_BCH_EccPROT_UnCorrERR_IntStat,AXI Master Interface 2 Write Response Channel ECC Protection related Uncorrectable Error Interrupt Status bit" "0: MXIF2_BCH_EccPROT_UnCorrERR_IntStat bit in..,1: MXIF2_BCH_EccPROT_UnCorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 19. "Enable_MXIF2_BCH_EccPROT_CorrERR_IntStat,AXI Master Interface 2 Write Response Channel ECC Protection related Correctable Error Interrupt Status bit" "0: MXIF2_BCH_EccPROT_CorrERR_IntStat bit in..,1: MXIF2_BCH_EccPROT_CorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 18. "Enable_MXIF2_RCH1_EccPROT_UnCorrERR_IntStat,AXI Master Interface 2 Read Channel (Other Control signals) ECC Protection related Uncorrectable Error Interrupt Status bit" "0: MXIF2_RCH1_EccPROT_UnCorrERR_IntStat bit in..,1: MXIF2_RCH1_EccPROT_UnCorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 17. "Enable_MXIF2_RCH1_EccPROT_CorrERR_IntStat,AXI Master Interface 2 Read Channel (Other Control signals) ECC Protection related Correctable Error Interrupt Status bit" "0: MXIF2_RCH1_EccPROT_CorrERR_IntStat bit in..,1: MXIF2_RCH1_EccPROT_CorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 16. "Enable_MXIF2_RCH0_EccPROT_UnCorrERR_IntStat,AXI Master Interface 2 Read Channel (Data) ECC Protection related Uncorrectable Error Interrupt Status bit" "0: MXIF2_RCH0_EccPROT_UnCorrERR_IntStat bit in..,1: MXIF2_RCH0_EccPROT_UnCorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 15. "Enable_MXIF2_RCH0_EccPROT_CorrERR_IntStat,AXI Master Interface 2 Read Channel (Data) ECC Protection related Correctable Error Interrupt Status bit" "0: MXIF2_RCH0_EccPROT_CorrERR_IntStat bit in..,1: MXIF2_RCH0_EccPROT_CorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 14. "Enable_MXIF1_BCH_EccPROT_UnCorrERR_IntStat,AXI Master Interface 1 Write Response Channel ECC Protection related Uncorrectable Error Interrupt Status bit" "0: MXIF1_BCH_EccPROT_UnCorrERR_IntStat bit in..,1: MXIF1_BCH_EccPROT_UnCorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 13. "Enable_MXIF1_BCH_EccPROT_CorrERR_IntStat,AXI Master Interface 1 Write Response Channel ECC Protection related Correctable Error Interrupt Status bit" "0: MXIF1_BCH_EccPROT_CorrERR_IntStat bit in..,1: MXIF1_BCH_EccPROT_CorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 12. "Enable_MXIF1_RCH1_EccPROT_UnCorrERR_IntStat,AXI Master Interface 1 Read Channel (Other Control signals) ECC Protection related Uncorrectable Error Interrupt Status bit" "0: MXIF1_RCH1_EccPROT_UnCorrERR_IntStat bit in..,1: MXIF1_RCH1_EccPROT_UnCorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 11. "Enable_MXIF1_RCH1_EccPROT_CorrERR_IntStat,AXI Master Interface 1 Read Channel (Other Control signals) ECC Protection related Correctable Error Interrupt Status bit" "0: MXIF1_RCH1_EccPROT_CorrERR_IntStat bit in..,1: MXIF1_RCH1_EccPROT_CorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 10. "Enable_MXIF1_RCH0_EccPROT_UnCorrERR_IntStat,AXI Master Interface 1 Read Channel (Data) ECC Protection related Uncorrectable Error Interrupt Status bit" "0: MXIF1_RCH0_EccPROT_UnCorrERR_IntStat bit in..,1: MXIF1_RCH0_EccPROT_UnCorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 9. "Enable_MXIF1_RCH0_EccPROT_CorrERR_IntStat,AXI Master Interface 1 Read Channel (Data) ECC Protection related Correctable Error Interrupt Status bit" "0: MXIF1_RCH0_EccPROT_CorrERR_IntStat bit in..,1: MXIF1_RCH0_EccPROT_CorrERR_IntStat bit in.."
            newline
            bitfld.quad 0x00 8. "Enable_SLVIF_UndefinedReg_DEC_ERR_IntStat,Slave Interface Undefined register Decode Error Interrupt Status enable Bit" "0: SLVIF_UndefinedReg_DEC_ERR_IntStat bit in..,1: SLVIF_UndefinedReg_DEC_ERR_IntStat bit in.."
            newline
            bitfld.quad 0x00 7. "Enable_SLVIF_CommonReg_WRPARITY_ERR_IntStat,Slave Interface Common Register Write Parity Error Interrupt Status Enable Bit" "0: SLVIF_CommonReg_WRPARITY_ERR_IntStat bit in..,1: SLVIF_CommonReg_WRPARITY_ERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 4.--6. "RSVD_DMAC_COMMONREG_INTSTATUS_ENABLEREG_6to4,DMAC Common Register Interrupt Status Enable Register (bits 6to4) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 3. "Enable_SLVIF_CommonReg_WrOnHold_ERR_IntStat,Slave Interface Common Register Write On Hold Error Interrupt Status Enable Bit" "0: SLVIF_CommonReg_WrOnHold_ERR_IntStat bit in..,1: SLVIF_CommonReg_WrOnHold_ERR_IntStat bit in.."
            newline
            bitfld.quad 0x00 2. "Enable_SLVIF_CommonReg_RD2WO_ERR_IntStat,Slave Interface Common Register Read to Write only Error Interrupt Status Enable Bit" "0: SLVIF_CommonReg_RD2WO_ERR_IntStat bit in..,1: SLVIF_CommonReg_RD2WO_ERR_IntStat bit in.."
            newline
            bitfld.quad 0x00 1. "Enable_SLVIF_CommonReg_WR2RO_ERR_IntStat,Slave Interface Common Register Write to Read only Error Interrupt Status Enable Bit" "0: SLVIF_CommonReg_WR2RO_ERR_IntStat bit in..,1: SLVIF_CommonReg_WR2RO_ERR_IntStat bit in.."
            newline
            bitfld.quad 0x00 0. "Enable_SLVIF_CommonReg_DEC_ERR_IntStat,Slave Interface Common Register Decode Error Interrupt Status Enable Bit" "0: SLVIF_CommonReg_DEC_ERR_IntStat bit in..,1: SLVIF_CommonReg_DEC_ERR_IntStat bit in.."
    group.quad 0x48++0x07
        line.quad 0x00 "DMAC_COMMONREG_INTSIGNAL_ENABLEREG,Writing 1 to specific field will propagate the corresponding interrupt status in DMAC Common register Interrupt Status Register (DMAC_CommonReg_IntStatusReg) to generate an port level interrupt"
            hexmask.quad.quad 0x00 21.--63. 1. "RSVD_DMAC_COMMONREG_INTSIGNAL_ENABLEREG_63to21,DMAC Common Register Interrupt Signal Enable Register (bits 63to21) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 20. "Enable_MXIF2_BCH_EccPROT_UnCorrERR_IntSignal,AXI Master Interface 2 Write Response Channel ECC Protection related Uncorrectable Error Interrupt Status bit" "0: MXIF2_BCH_EccPROT_UnCorrERR_IntStat signal in..,1: MXIF2_BCH_EccPROT_UnCorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 19. "Enable_MXIF2_BCH_EccPROT_CorrERR_IntSignal,AXI Master Interface 2 Write Response Channel ECC Protection related Correctable Error Interrupt Status bit" "0: MXIF2_BCH_EccPROT_CorrERR_IntStat signal in..,1: MXIF2_BCH_EccPROT_CorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 18. "Enable_MXIF2_RCH1_EccPROT_UnCorrERR_IntSignal,AXI Master Interface 2 Read Channel (Other Control signals) ECC Protection related Uncorrectable Error Interrupt Status bit" "0: MXIF2_RCH1_EccPROT_UnCorrERR_IntStat signal..,1: MXIF2_RCH1_EccPROT_UnCorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 17. "Enable_MXIF2_RCH1_EccPROT_CorrERR_IntSignal,AXI Master Interface 2 Read Channel (Other Control signals) ECC Protection related Correctable Error Interrupt Status bit" "0: MXIF2_RCH1_EccPROT_CorrERR_IntStat signal in..,1: MXIF2_RCH1_EccPROT_CorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 16. "Enable_MXIF2_RCH0_EccPROT_UnCorrERR_IntSignal,AXI Master Interface 2 Read Channel (Data) ECC Protection related Uncorrectable Error Interrupt Status bit" "0: MXIF2_RCH0_EccPROT_UnCorrERR_IntStat signal..,1: MXIF2_RCH0_EccPROT_UnCorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 15. "Enable_MXIF2_RCH0_EccPROT_CorrERR_IntSignal,AXI Master Interface 2 Read Channel (Data) ECC Protection related Correctable Error Interrupt Status bit" "0: MXIF2_RCH0_EccPROT_CorrERR_IntStat signal in..,1: MXIF2_RCH0_EccPROT_CorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 14. "Enable_MXIF1_BCH_EccPROT_UnCorrERR_IntSignal,AXI Master Interface 1 Write Response Channel ECC Protection related Uncorrectable Error Interrupt Status bit" "0: MXIF1_BCH_EccPROT_UnCorrERR_IntStat signal in..,1: MXIF1_BCH_EccPROT_UnCorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 13. "Enable_MXIF1_BCH_EccPROT_CorrERR_IntSignal,AXI Master Interface 1 Write Response Channel ECC Protection related Correctable Error Interrupt Status bit" "0: MXIF1_BCH_EccPROT_CorrERR_IntStat signal in..,1: MXIF1_BCH_EccPROT_CorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 12. "Enable_MXIF1_RCH1_EccPROT_UnCorrERR_IntSignal,AXI Master Interface 1 Read Channel (Other Control signals) ECC Protection related Uncorrectable Error Interrupt Status bit" "0: MXIF1_RCH1_EccPROT_UnCorrERR_IntStat signal..,1: MXIF1_RCH1_EccPROT_UnCorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 11. "Enable_MXIF1_RCH1_EccPROT_CorrERR_IntSignal,AXI Master Interface 1 Read Channel (Other Control signals) ECC Protection related Correctable Error Interrupt Status bit" "0: MXIF1_RCH1_EccPROT_CorrERR_IntStat signal in..,1: MXIF1_RCH1_EccPROT_CorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 10. "Enable_MXIF1_RCH0_EccPROT_UnCorrERR_IntSignal,AXI Master Interface 1 Read Channel (Data) ECC Protection related Uncorrectable Error Interrupt Status bit" "0: MXIF1_RCH0_EccPROT_UnCorrERR_IntStat signal..,1: MXIF1_RCH0_EccPROT_UnCorrERR_IntStat bit in.."
            newline
            rbitfld.quad 0x00 9. "Enable_MXIF1_RCH0_EccPROT_CorrERR_IntSignal,AXI Master Interface 1 Read Channel (Data) ECC Protection related Correctable Error Interrupt Status bit" "0: MXIF1_RCH0_EccPROT_CorrERR_IntStat signal in..,1: MXIF1_RCH0_EccPROT_CorrERR_IntStat bit in.."
            newline
            bitfld.quad 0x00 8. "Enable_SLVIF_UndefinedReg_DEC_ERR_IntSignal,Slave Interface Undefined register Decode Error Interrupt Signal Enable Bit" "0: SLVIF_UndefinedReg_DEC_ERR_IntStat signal in..,1: SLVIF_UndefinedReg_DEC_ERR_IntStat signal in.."
            newline
            bitfld.quad 0x00 7. "Enable_SLVIF_CommonReg_WRPARITY_ERR_IntSignal,Slave Interface Write Parity Error Interrupt Signal Enable Bit" "0: SLVIF_CommonReg_WRPARITY_ERR_IntStat signal..,1: SLVIF_CommonReg_WRPARITY_ERR_IntStat signal.."
            newline
            rbitfld.quad 0x00 4.--6. "RSVD_DMAC_COMMONREG_INTSIGNAL_ENABLEREG_6to4,DMAC Common Register Interrupt Signal Enable Register (bits 6to4) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 3. "Enable_SLVIF_CommonReg_WrOnHold_ERR_IntSignal,Slave Interface Common Register Write On Hold Error Interrupt Signal Enable Bit" "0: SLVIF_CommonReg_WrOnHold_ERR_IntStat signal..,1: SLVIF_CommonReg_WrOnHold_ERR_IntStat signal.."
            newline
            bitfld.quad 0x00 2. "Enable_SLVIF_CommonReg_RD2WO_ERR_IntSignal,Slave Interface Common Register Read to Write only Error Interrupt Signal Enable Bit" "0: SLVIF_CommonReg_RD2WO_ERR_IntStat signal in..,1: SLVIF_CommonReg_RD2WO_ERR_IntStat signal in.."
            newline
            bitfld.quad 0x00 1. "Enable_SLVIF_CommonReg_WR2RO_ERR_IntSignal,Slave Interface Common Register Write to Read only Error Interrupt Signal Enable Bit" "0: SLVIF_CommonReg_WR2RO_ERR_IntStat signal in..,1: SLVIF_CommonReg_WR2RO_ERR_IntStat signal in.."
            newline
            bitfld.quad 0x00 0. "Enable_SLVIF_CommonReg_DEC_ERR_IntSignal,Slave Interface Common Register Decode Error Interrupt Signal Enable Bit" "0: SLVIF_CommonReg_DEC_ERR_IntStat signal in..,1: SLVIF_CommonReg_DEC_ERR_IntStat signal in.."

    rgroup.quad 0x50++0x07
        line.quad 0x00 "DMAC_COMMONREG_INTSTATUSREG,This Register captures Slave interface access errors"
            hexmask.quad.quad 0x00 21.--63. 1. "RSVD_DMAC_COMMONREG_INTSTATUSREG_63to21,DMAC Common Register Interrupt Signal Enable Register (bits 63to21) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 20. "MXIF2_BCH_EccPROT_UnCorrERR_IntStat,AXI Master Interface 2 Write Response Channel ECC Protection Uncorrectable Error Interrupt Status bit" "0: AXI Master 2 Write Response Channel..,1: AXI Master 2 Write Response Channel.."
            newline
            bitfld.quad 0x00 19. "MXIF2_BCH_EccPROT_CorrERR_IntStat,AXI Master Interface 2 Write Response Channel ECC Protection Correctable Error Interrupt Status bit" "0: AXI Master 2 Write Response Channel..,1: AXI Master 2 Write Response Channel.."
            newline
            bitfld.quad 0x00 18. "MXIF2_RCH1_EccPROT_UnCorrERR_IntStat,AXI Master Interface 1 Read Channel (Other Control signals) ECC Protection Uncorrectable Error Interrupt Status bit" "0: AXI Master 2 Read Channel (Other Control..,1: AXI Master 2 Read Channel (Other Control.."
            newline
            bitfld.quad 0x00 17. "MXIF2_RCH1_EccPROT_CorrERR_IntStat,AXI Master Interface 2 Read Channel (Other Control signals) ECC Protection Correctable Error Interrupt Status bit" "0: AXI Master 2 Read Channel (Other Control..,1: AXI Master 2 Read Channel (Other Control.."
            newline
            bitfld.quad 0x00 16. "MXIF2_RCH0_EccPROT_UnCorrERR_IntStat,AXI Master Interface 2 Read Channel (Data) ECC Protection Uncorrectable Error Interrupt Status bit" "0: AXI Master 2 Read Channel (Data)..,1: AXI Master 2 Read Channel (Data).."
            newline
            bitfld.quad 0x00 15. "MXIF2_RCH0_EccPROT_CorrERR_IntStat,AXI Master Interface 2 Read Channel (Data) ECC Protection Correctable Error Interrupt Status bit" "0: AXI Master 2 Read Channel (Data) Correctable..,1: AXI Master 2 Read Channel (Data) Correctable.."
            newline
            bitfld.quad 0x00 14. "MXIF1_BCH_EccPROT_UnCorrERR_IntStat,AXI Master Interface 1 Write Response Channel ECC Protection Uncorrectable Error Interrupt Status bit" "0: AXI Master 1 Write Response Channel..,1: AXI Master 1 Write Response Channel.."
            newline
            bitfld.quad 0x00 13. "MXIF1_BCH_EccPROT_CorrERR_IntStat,AXI Master Interface 1 Write Response Channel ECC Protection Correctable Error Interrupt Status bit" "0: AXI Master 1 Write Response Channel..,1: AXI Master 1 Write Response Channel.."
            newline
            bitfld.quad 0x00 12. "MXIF1_RCH1_EccPROT_UnCorrERR_IntStat,AXI Master Interface 1 Read Channel (Other Control signals) ECC Protection Uncorrectable Error Interrupt Status bit" "0: AXI Master 1 Read Channel (Other Control..,1: AXI Master 1 Read Channel (Other Control.."
            newline
            bitfld.quad 0x00 11. "MXIF1_RCH1_EccPROT_CorrERR_IntStat,AXI Master Interface 1 Read Channel (Other Control signals) ECC Protection Correctable Error Interrupt Status bit" "0: AXI Master 1 Read Channel (Other Control..,1: AXI Master 1 Read Channel (Other Control.."
            newline
            bitfld.quad 0x00 10. "MXIF1_RCH0_EccPROT_UnCorrERR_IntStat,AXI Master Interface 1 Read Channel (Data) ECC Protection Uncorrectable Error Interrupt Status bit" "0: AXI Master 1 Read Channel (Data)..,1: AXI Master 1 Read Channel (Data).."
            newline
            bitfld.quad 0x00 9. "MXIF1_RCH0_EccPROT_CorrERR_IntStat,AXI Master Interface 1 Read Channel (Data) ECC Protection Correctable Error Interrupt Status bit" "0: AXI Master 1 Read Channel (Data) Correctable..,1: AXI Master 1 Read Channel (Data) Correctable.."
            newline
            bitfld.quad 0x00 8. "SLVIF_UndefinedReg_DEC_ERR_IntStat,Slave Interface Undefined register Decode Error Interrupt Signal Enable Bit" "0: No Slave Interface Decode Errors,1: Slave Interface Decode Error detected"
            newline
            bitfld.quad 0x00 7. "SLVIF_CommonReg_WRPARITY_ERR_IntStat,Slave Interface Common Register Write Parity Error Interrupt Status Bit" "0: No Slave Interface Common Register Write..,1: Slave Interface Common Register Write Parity.."
            newline
            bitfld.quad 0x00 4.--6. "RSVD_DMAC_COMMONREG_INTSTATUSREG_6to4,DMAC Common Register Interrupt Status Register (bits 6to4) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 3. "SLVIF_CommonReg_WrOnHold_ERR_IntStat,Slave Interface Common Register Write On Hold Error Interrupt Status Bit" "0: No Slave Interface Common Register Write On..,1: Slave Interface Common Register Write On Hold.."
            newline
            bitfld.quad 0x00 2. "SLVIF_CommonReg_RD2WO_ERR_IntStat,Slave Interface Common Register Read to Write only Error Interrupt Status bit" "0: No Slave Interface Read to Write Only Errors,1: Slave Interface Read to Write Only Error.."
            newline
            bitfld.quad 0x00 1. "SLVIF_CommonReg_WR2RO_ERR_IntStat,Slave Interface Common Register Write to Read Only Error Interrupt Status bit" "0: Slave Interface Write to Read Only Error..,1: No Slave Interface Write to Read Only Errors"
            newline
            bitfld.quad 0x00 0. "SLVIF_CommonReg_DEC_ERR_IntStat,Slave Interface Common Register Decode Error Interrupt Status Bit" "0: No Slave Interface Decode Errors,1: Slave Interface Decode Error detected"

    group.quad 0x58++0x07
        line.quad 0x00 "DMAC_RESETREG,This register is used to initiate the Software Reset to DW_axi_dmac"
            hexmask.quad 0x00 1.--63. 1. "RSVD_DMAC_ResetReg_1to63,DMAC_ResetReg (bits 1to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 0. "DMAC_RST,DMAC Reset Request bit Software writes 1 to this bit to reset the DW_axi_dmac and polls this bit to see it as 0" "0,1"
    group.quad 0x60++0x07
        line.quad 0x00 "DMAC_LOWPOWER_CFGREG,This register contains the fields that configures the Context Sensitive Low Power feature"
            hexmask.quad.byte 0x00 56.--63. 1. "RSVD_DMAC_LOWPOWER_CFGREG_63to56,DMAC_LOWPOWER_CFGREG (bits 56to63) Reserved bits - Read Only"
            newline
            hexmask.quad.byte 0x00 48.--55. 1. "MXIF_LPDLY,Defines the load value to be programmed into the AXI Master Interface low power delay counter"
            newline
            hexmask.quad.byte 0x00 40.--47. 1. "SBIU_LPDLY,Defines the load value to be programmed into the SBIU low power delay counter"
            newline
            hexmask.quad.byte 0x00 32.--39. 1. "GLCH_LPDLY,Defines the load value to be programmed into the Global and DMA Channel low power delay counter"
            newline
            hexmask.quad.long 0x00 4.--31. 1. "RSVD_DMAC_LOWPOWER_CFGREG_31to4,DMAC_LOWPOWER_CFGREG (bits 4to31) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 3. "MXIF_CSLP_EN,AXI Master Interface Context Sensitive Low Power feature enable" "0: AXI Master Interface Context Sensitive Low..,1: AXI Master Interface Context Sensitive Low.."
            newline
            bitfld.quad 0x00 2. "SBIU_CSLP_EN,SBIU Context Sensitive Low Power feature enable" "0: SBIU Context Sensitive Low Power feature is..,1: SBIU Context Sensitive Low Power feature is.."
            newline
            bitfld.quad 0x00 1. "CHNL_CSLP_EN,DMA Channel Context Sensitive Low Power feature enable" "0: DMA Channel Context Sensitive Low Power..,1: DMA Channel Context Sensitive Low Power.."
            newline
            bitfld.quad 0x00 0. "GBL_CSLP_EN,Global Context Sensitive Low Power feature enable" "0: Global Context Sensitive Low Power feature is..,1: Global Context Sensitive Low Power feature is.."
    group.quad 0x70++0x07
        line.quad 0x00 "DMAC_COMMON_PARCTLREG,This register contains the fields that enables/disables the Parity Protection Feature and a field that selects even or odd parity mode"
            hexmask.quad 0x00 2.--63. 1. "RSVD_DMAC_COMMONREG_PARCTLREG_63to2,DMAC_COMMONREG_PARCTLREG (bits 2to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 1. "PARITY_MODE,Parity Mode selects the even or odd parity scheme for the Parity Protection feature" "0: The Even Parity check is used for registers..,1: The Odd Parity check is used for registers in.."
            newline
            bitfld.quad 0x00 0. "PARITY_EN,This field is used to enable/disable the Parity Protection feature" "0: The Parity check for registers in the..,1: The Parity check for registers in the.."
    group.quad 0x78++0x07
        line.quad 0x00 "DMAC_COMMON_ECCCTLSTATUSREG,This register contains the fields that - Reset the ECC Protection Correctable and Uncorrectable Counters"
            hexmask.quad.tbyte 0x00 42.--63. 1. "RSVD_DMAC_COMMONREG_ECCCTLSTATUSREG_42to63,DMAC_COMMONREG_ECCCTLSTATUSREG (bits 42to63) Reserved bits - Read Only"
            newline
            hexmask.quad.word 0x00 32.--41. 1. "ECC_UNCORR_ERR_COUNT,ECC Uncorrectable Error count This field provides the number of uncorrectable error detected since the ECC Error count reset or soft reset or dmac_resetn"
            newline
            rbitfld.quad 0x00 26.--31. "RSVD_DMAC_COMMONREG_ECCCTLSTATUSREG_26to31,DMAC_COMMONREG_ECCCTLSTATUSREG (bits 26to31) Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            hexmask.quad.word 0x00 16.--25. 1. "ECC_CORR_ERR_COUNT,ECC Correctable Error count This field provides the number of correctable error detected since the ECC Error count reset or soft reset or dmac_resetn"
            newline
            rbitfld.quad 0x00 12.--15. "RSVD_DMAC_COMMONREG_ECCCTLSTATUSREG_12to15,DMAC_COMMONREG_ECCCTLSTATUSREG (bits 12to15) Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 7.--11. "ECC_INTFC_NO,ECC Protected Interface Number This is used to provide the interface number of specific interface type to multiplex the correctable and uncorrectable error counters" "0: AXI Read Data Channel - RCH0 (ECC counter of,1: AXI Read Data Channel - RCH1 (ECC counter of,2: AXI Write Response Channel - BCH If illegal,?..."
            newline
            bitfld.quad 0x00 5.--6. "ECC_INTFC_TYPE,ECC Protected Interace Type This is used to select the required interface that is protected through the ECC" "0: Channel FIFO Memory Interface,1: Channel UID Memory Interface,2: AXI Master Interface,?..."
            newline
            bitfld.quad 0x00 4. "ECC_ERR_COUNT_RST,ECC Error Count Reset This bit is used to reset the ECC Protection Correctable and Uncorrectable Counters" "0: Do not Reset the ECC error Counters,1: Reset the ECC error Counters"
            newline
            rbitfld.quad 0x00 0.--3. "RSVD_DMAC_ECCCTLSTATUSREG_0to3,DMAC_COMMONREG_ECCCTLSTATUSREG (bits 0to3) Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.quad 0x100++0x07
        line.quad 0x00 "CH1_SAR,The starting source address is programmed by software before the DMA channel is enabled or by an LLI update before the start of the DMA transfer"
            hexmask.quad 0x00 0.--63. 1. "SAR,Current Source Address of DMA transfer"
    group.quad 0x108++0x07
        line.quad 0x00 "CH1_DAR,The starting destination address is programmed by the software before the DMA channel is enabled or by an LLI update before the start of the DMA transfer"
            hexmask.quad 0x00 0.--63. 1. "DAR,Current Destination Address of DMA transfer"
    group.quad 0x110++0x07
        line.quad 0x00 "CH1_BLOCK_TS,When DW_axi_dmac is the flow controller the DMAC uses this register before the channel is enabled for block-size"
            hexmask.quad.quad 0x00 22.--63. 1. "RSVD_DMAC_CHx_BLOCK_TSREG_63to22,DMAC Channelx Block Transfer Size Register (bits 63to22) Reserved bits - Read Only"
            newline
            hexmask.quad.tbyte 0x00 0.--21. 1. "BLOCK_TS,Block Transfer Size"
    group.quad 0x118++0x07
        line.quad 0x00 "CH1_CTL,This register contains fields that control the DMA transfer"
            bitfld.quad 0x00 63. "SHADOWREG_OR_LLI_VALID,Shadow Register content/Linked List Item valid" "0: Indicates shadowreg/LLI content is Invalid,1: Indicates shadowreg/LLI content is Valid"
            newline
            bitfld.quad 0x00 62. "SHADOWREG_OR_LLI_LAST,Last Shadow Register/Linked List Item" "0: Indicates shadowreg/LLI content is not the..,1: Indicates shadowreg/LLI content is the last one"
            newline
            rbitfld.quad 0x00 59.--61. "RSVD_DMAC_CHx_CTL_59to61,DMAC Channelx Control Transfer Register (bits 59to61) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 58. "IOC_BlkTfr,Interrupt On completion of Block Transfer This bit is used to control the block transfer completion interrupt generation on a block by block basis for shadow register or linked list based multi-block transfers" "0: Disables..,1: Enables.."
            newline
            rbitfld.quad 0x00 57. "DST_STAT_EN,Destination Status Enable Enable the logic to fetch status from destination peripheral of channel x pointed to by the content of CHx_DSTATAR register and stores it in CHx_DSTAT register" "0: No status fetch for Destination device,1: Enables status fetch for Destination and.."
            newline
            rbitfld.quad 0x00 56. "SRC_STAT_EN,Source Status Enable Enable the logic to fetch status from source peripheral of channel x pointed to by the content of CHx_SSTATAR register and stores it in CHx_SSTAT register" "0: No status fetch for Source device,1: Enables status fetch for Source and store the.."
            newline
            hexmask.quad.byte 0x00 48.--55. 1. "AWLEN,Destination Burst Length AXI Burst length used for destination data transfer"
            newline
            bitfld.quad 0x00 47. "AWLEN_EN,Destination Burst Length Enable If this bit is set to 1 DW_axi_dmac uses the value of CHx_CTL.AWLEN as AXI Burst length for destination data transfer till the extent possible remaining transfers use maximum possible burst length" "0: AXI Burst Length is any possible value <=..,1: AXI Burst Length is CH1_CTL.AWLEN (till the.."
            newline
            hexmask.quad.byte 0x00 39.--46. 1. "ARLEN,Source Burst Length AXI Burst length used for source data transfer"
            newline
            bitfld.quad 0x00 38. "ARLEN_EN,Source Burst Length Enable If this bit is set to 1 DW_axi_dmac uses the value of CHx_CTL.ARLEN as AXI Burst length for source data transfer till the extent possible remaining transfers use maximum possible burst length" "0: AXI Burst Length is any possible value <=..,1: AXI Burst Length is CH1_CTL.ARLEN (till the.."
            newline
            bitfld.quad 0x00 35.--37. "AW_PROT,AXI 'aw_prot' signal" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 32.--34. "AR_PROT,AXI 'ar_prot' signal" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 31. "RSVD_DMAC_CHx_CTL_31,DMAC Channelx Control Transfer Register bit31 Reserved bits - Read Only" "0,1"
            newline
            bitfld.quad 0x00 30. "NonPosted_LastWrite_En,Non Posted Last Write Enable This bit decides whether posted writes can be used throughout the block transfer" "0: Posted writes may be used throughout the..,1: Last write in the block must be non-posted"
            newline
            bitfld.quad 0x00 26.--29. "AW_CACHE,AXI 'aw_cache' signal" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 22.--25. "AR_CACHE,AXI 'ar_cache' signal" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 18.--21. "DST_MSIZE,Destination Burst Transaction Length" "0: 1 Data Item read from Destination in the..,1: 4 Data Item read from Destination in the..,2: 8 Data Item read from Destination in the..,3: 16 Data Item read from Destination in the..,4: 32 Data Item read from Destination in the..,5: 64 Data Item read from Destination in the..,6: 128 Data Item read from Destination in the..,7: 256 Data Item read from Destination in the..,8: 512 Data Item read from Destination in the..,9: 1024 Data Item read from Destination in the..,?..."
            newline
            bitfld.quad 0x00 14.--17. "SRC_MSIZE,Source Burst Transaction Length" "0: 1 Data Item read from Source in the burst..,1: 4 Data Item read from Source in the burst..,2: 8 Data Item read from Source in the burst..,3: 16 Data Item read from Source in the burst..,4: 32 Data Item read from Source in the burst..,5: 64 Data Item read from Source in the burst..,6: 128 Data Item read from Source in the burst..,7: 256 Data Item read from Source in the burst..,8: 512 Data Item read from Source in the burst..,9: 1024 Data Item read from Source in the burst..,?..."
            newline
            bitfld.quad 0x00 11.--13. "DST_TR_WIDTH,Destination Transfer Width" "0: Destination Transfer Width is 8 bits,1: Destination Transfer Width is 16 bits,2: Destination Transfer Width is 32 bits,3: Destination Transfer Width is 64 bits,4: Destination Transfer Width is 128 bits,5: Destination Transfer Width is 256 bits,6: Destination Transfer Width is 512 bits,?..."
            newline
            bitfld.quad 0x00 8.--10. "SRC_TR_WIDTH,Source Transfer Width" "0: Source Transfer Width is 8 bits,1: Source Transfer Width is 16 bits,2: Source Transfer Width is 32 bits,3: Source Transfer Width is 64 bits,4: Source Transfer Width is 128 bits,5: Source Transfer Width is 256 bits,6: Source Transfer Width is 512 bits,?..."
            newline
            rbitfld.quad 0x00 7. "RSVD_DMAC_CHx_CTL_7,DMAC Channelx Control Transfer Register bit7 Reserved bits - Read Only" "0,1"
            newline
            bitfld.quad 0x00 6. "DINC,Destination Address Increment" "0: Destination address incremented on every..,1: Destination address is fixed"
            newline
            rbitfld.quad 0x00 5. "RSVD_DMAC_CHx_CTL_5,DMAC Channelx Control Transfer Register bit5 Reserved bits - Read Only" "0,1"
            newline
            bitfld.quad 0x00 4. "SINC,Source Address Increment" "0: Source address incremented on every source..,1: Source address is fixed"
            newline
            rbitfld.quad 0x00 3. "RSVD_DMAC_CHx_CTL_3,DMAC Channelx Control Transfer Register bit3 Reserved bits - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 2. "DMS,Destination Master Select" "0: Destination device on Master-1 interface layer,1: Destination device on Master-2 interface layer"
            newline
            rbitfld.quad 0x00 1. "RSVD_DMAC_CHx_CTL_1,DMAC Channelx Control Transfer Register bit1 Reserved bits - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 0. "SMS,Source Master Select" "0: Source device on Master-1 interface layer,1: Source device on Master-2 interface layer"
    group.quad 0x120++0x07
        line.quad 0x00 "CH1_CFG,This register contains fields that configure the DMA transfer"
            rbitfld.quad 0x00 63. "RSVD_DMAC_CHx_CFG_63,DMAC Channelx Transfer Configuration Register (63bit) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 59.--62. "DST_OSR_LMT,Destination Outstanding Request Limit - Maximum outstanding request supported is 16" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 55.--58. "SRC_OSR_LMT,Source Outstanding Request Limit - Maximum outstanding request supported is 16" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.quad 0x00 53.--54. "LOCK_CH_L,Channel Lock Level This bit indicates the duration over which CHx_CFG.LOCK_CH bit applies" "0: Duration of the Channel locking is for the..,1: Duration of the Channel locking is for the..,?..."
            newline
            rbitfld.quad 0x00 52. "LOCK_CH,Channel Lock bit When the channel is granted control of the master bus interface and if the CHx_CFG.LOCK_CH bit is asserted then no other channels are granted control of the master bus interface for the duration specified in CHx_CFG.LOCK_CH_L" "0: Channel is not locked during the transfers,1: Channel is locked and granted exclusive.."
            newline
            bitfld.quad 0x00 49.--51. "CH_PRIOR,Channel Priority A priority of DMAX_NUM_CHANNELS-1 is the highest priority and 0 is the lowest" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 48. "RSVD_DMAC_CHx_CFG_48,DMAC Channelx Transfer Configuration Register (48bit) Reserved bit - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 46.--47. "RSVD_DMAC_CHx_CFG_47_44,DMAC Channelx Transfer Configuration Register (bits (LOG2_DMAX_NUM_HS_IF+44) to 47) Reserved bits - Read Only" "0,1,2,3"
            newline
            bitfld.quad 0x00 44.--45. "DST_PER,Assigns a hardware handshaking interface (0 - DMAX_NUM_HS_IF-1) to the destination of Channelx if the CHx_CFG.HS_SEL_DST field is 0 otherwise this field is ignored" "0,1,2,3"
            newline
            rbitfld.quad 0x00 43. "RSVD_DMAC_CHx_CFG_43,DMAC Channelx Transfer Configuration Register (43bit) Reserved bit - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 41.--42. "RSVD_DMAC_CHx_CFG_42_39,DMAC Channelx Transfer Configuration Register (bits (LOG2_DMAX_NUM_HS_IF+39) to 42) Reserved bits - Read Only" "0,1,2,3"
            newline
            bitfld.quad 0x00 39.--40. "SRC_PER,Assigns a hardware handshaking interface (0 - DMAX_NUM_HS_IF-1) to the source of Channelx if the CHx_CFG.HS_SEL_SRC field is 0 otherwise this field is ignored" "0,1,2,3"
            newline
            rbitfld.quad 0x00 38. "DST_HWHS_POL,Destination Hardware Handshaking Interface Polarity" "0: Polarity of the Handshaking Interface used..,1: Polarity of the Handshaking Interface used.."
            newline
            rbitfld.quad 0x00 37. "SRC_HWHS_POL,Source Hardware Handshaking Interface Polarity" "0: Polarity of the Handshaking Interface used..,1: Polarity of the Handshaking Interface used.."
            newline
            bitfld.quad 0x00 36. "HS_SEL_DST,Destination Software or Hardware Handshaking Select" "0: Hardware Handshaking Interface is used for..,1: Software Handshaking Interface is used for.."
            newline
            bitfld.quad 0x00 35. "HS_SEL_SRC,Source Software or Hardware Handshaking Select" "0: Hardware Handshaking Interface is used for..,1: Software Handshaking Interface is used for.."
            newline
            bitfld.quad 0x00 32.--34. "TT_FC,Transfer Type and Flow Control" "0: Transfer Type is memory to memory and Flow..,1: Transfer Type is memory to peripheral and..,2: Transfer Type is peripheral to memory and..,3: Transfer Type is peripheral to peripheral and..,4: Transfer Type is peripheral to Memory and..,5: Transfer Type is peripheral to peripheral and..,6: Transfer Type is memory to peripheral and..,7: Transfer Type is peripheral to peripheral and.."
            newline
            rbitfld.quad 0x00 29.--31. "RSVD_DMAC_CHx_CFG_29to31,DMAC Channelx Transfer Configuration Register (bits 29to31) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 25.--28. "WR_UID,Defines the number of AXI Unique ID's supported for the AXI Write Channel" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_CFG_22to24,DMAC Channelx Transfer Configuration Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 18.--21. "RD_UID,Defines the number of AXI Unique ID's supported for the AXI Read Channel" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.quad.word 0x00 4.--17. 1. "RSVD_DMAC_CHx_CFG_4to17,DMAC Channelx Transfer Configuration Register (bits 4to17) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 2.--3. "DST_MULTBLK_TYPE,Destination Multi Block Transfer Type" "0: Contiguous Multiblock Type used for..,1: Reload Multiblock Type used for Destination..,2: Shadow Register based Multiblock Type used..,3: Linked List based Multiblock Type used for.."
            newline
            rbitfld.quad 0x00 0.--1. "SRC_MULTBLK_TYPE,Source Multi Block Transfer Type" "0: Contiguous Multiblock Type used for Source..,1: Reload Multiblock Type used for Source Transfer,2: Shadow Register based Multiblock Type used..,3: Linked List based Multiblock Type used for.."
    group.quad 0x128++0x07
        line.quad 0x00 "CH1_LLP,This is the Linked List Pointer register"
            hexmask.quad 0x00 6.--63. 1. "LOC,Starting Address Memory of LLI block Starting Address In Memory of next LLI if block chaining is enabled"
            newline
            rbitfld.quad 0x00 1.--5. "RSVD_DMAC_CHx_LLP_1to5,DMAC Channelx Linked List Pointer Register (bits 1to5) Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            rbitfld.quad 0x00 0. "LMS,LLI master Select This bit identifies the AXI layer/interface where the memory device that stores the next linked list item resides" "0: next Linked List item resides on AXI Master1..,1: next Linked List item resides on AXI Master2.."

    rgroup.quad 0x130++0x07
        line.quad 0x00 "CH1_STATUSREG,Channelx Status Register contains fields that indicate the status of DMA transfers for Channelx"
            hexmask.quad.tbyte 0x00 47.--63. 1. "RSVD_DMAC_CHx_STATUSREG_47to63,DMAC Channelx Status Register (bits 47to63) Reserved bits - Read Only"
            newline
            hexmask.quad.word 0x00 32.--46. 1. "DATA_LEFT_IN_FIFO,Data Left in FIFO"
            newline
            hexmask.quad.word 0x00 22.--31. 1. "RSVD_DMAC_CHx_STATUSREG_22to31,DMAC Channelx Status Register (bits 22to31) Reserved bits - Read Only"
            newline
            hexmask.quad.tbyte 0x00 0.--21. 1. "CMPLTD_BLK_TFR_SIZE,Completed Block Transfer Size"

    group.quad 0x138++0x07
        line.quad 0x00 "CH1_SWHSSRCREG,Channelx Software handshake Source Register"
            hexmask.quad 0x00 6.--63. 1. "RSVD_DMAC_CHx_SWHSSRCREG_6to63,DMAC Channelx Software Handshake Source Register (bits 6to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 5. "SWHS_LST_SRC_WE,Write Enable bit for Software Handshake Last Request for Channel Source" "0: Disables write to the SWHS_LAST_SRC bit,1: Enables write to the SWHS_LAST_SRC bit"
            newline
            bitfld.quad 0x00 4. "SWHS_LST_SRC,Software Handshake Last Request for Channel Source" "0: Source peripheral indication that the curent..,1: Source peripheral indication to dmac that the.."
            newline
            bitfld.quad 0x00 3. "SWHS_SGLREQ_SRC_WE,Write Enable bit for Software Handshake Single Request for Channel Source" "0: Disables write to the SWHS_SGLREQ_SRC bit,1: Enables write to the SWHS_SGLREQ_SRC bit"
            newline
            bitfld.quad 0x00 2. "SWHS_SGLREQ_SRC,Software Handshake Single Request for Channel Source" "0: Source peripheral is not requesting for a..,1: Source peripheral request for a single dma.."
            newline
            bitfld.quad 0x00 1. "SWHS_REQ_SRC_WE,Write Enable bit for Software Handshake Request for Channel Source" "0: Disables write to the SWHS_REQ_SRC bit,1: Enables write to the SWHS_REQ_SRC bit"
            newline
            bitfld.quad 0x00 0. "SWHS_REQ_SRC,Software Handshake Request for Channel Source" "0: Source peripheral is not requesting for a..,1: Source peripheral request for a dma transfer"
    group.quad 0x140++0x07
        line.quad 0x00 "CH1_SWHSDSTREG,Channelx Software handshake Destination Register"
            hexmask.quad 0x00 6.--63. 1. "RSVD_DMAC_CHx_SWHSDSTREG_6to63,DMAC Channelx Software Handshake Destination Register (bits 6to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 5. "SWHS_LST_DST_WE,Write Enable bit for Software Handshake Last Request for Channel Destination" "0: Disables write to the SWHS_LAST_DST bit,1: Enables write to the SWHS_LAST_DST bit"
            newline
            bitfld.quad 0x00 4. "SWHS_LST_DST,Software Handshake Last Request for Channel Destination" "0: Destination peripheral indication that the..,1: Destination peripheral indication to dmac.."
            newline
            bitfld.quad 0x00 3. "SWHS_SGLREQ_DST_WE,Write Enable bit for Software Handshake Single Request for Channel Destination" "0: Disables write to the SWHS_SGLREQ_DST bit,1: Enables write to the SWHS_SGLREQ_DST bit"
            newline
            bitfld.quad 0x00 2. "SWHS_SGLREQ_DST,Software Handshake Single Request for Channel Destination" "0: Destination peripheral is not requesting for..,1: Destination peripheral request for a single.."
            newline
            bitfld.quad 0x00 1. "SWHS_REQ_DST_WE,Write Enable bit for Software Handshake Request for Channel Destination" "0: Disables write to the SWHS_REQ_DST bit,1: Enables write to the SWHS_REQ_DST bit"
            newline
            bitfld.quad 0x00 0. "SWHS_REQ_DST,Software Handshake Request for Channel Destination" "0: Destination peripheral is not requesting for..,1: Destination peripheral request for a dma.."

    wgroup.quad 0x148++0x07
        line.quad 0x00 "CH1_BLK_TFR_RESUMEREQREG,Channelx Block Transfer Resume Request Register"
            hexmask.quad 0x00 1.--63. 1. "RSVD_DMAC_CHx_BLK_TFR_RESUMEREQREG_1to63,DMAC Channelx Block Transfer Resume Request Register (bits 1to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 0. "BLK_TFR_RESUMEREQ,Block Transfer Resume Request during Linked-List or Shadow-Register-based multi-block transfer" "0: No request to resume the block transfer,1: Request for resuming the block transfer"

    group.quad 0x150++0x07
        line.quad 0x00 "CH1_AXI_IDREG,Channelx AXI ID Register"
            hexmask.quad.long 0x00 32.--63. 1. "RSVD_DMAC_CHx_AXI_IDREG_32to63,DMAC Channelx AXI ID Register (bits 32to63) Reserved bits - Read Only"
            newline
            hexmask.quad.word 0x00 18.--31. 1. "RSVD_DMAC_CHx_AXI_IDREG_IDW_L2NCm32to63,DMAC Channelx AXI ID Register (bits (IDW-L2NC-1)to32) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 16.--17. "AXI_WRITE_ID_SUFFIX,AXI Write ID Suffix" "0,1,2,3"
            newline
            hexmask.quad.word 0x00 2.--15. 1. "RSVD_DMAC_CHx_AXI_IDREG_IDW_L2NCm1to31,DMAC Channelx AXI ID Register (bits (IDW-L2NC-1)to31) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 0.--1. "AXI_READ_ID_SUFFIX,AXI Read ID Suffix These bits form part of the ARID output of AXI3/AXI4 master interface" "0,1,2,3"
    group.quad 0x158++0x07
        line.quad 0x00 "CH1_AXI_QOSREG,Channelx AXI QOS Register"
            hexmask.quad.quad 0x00 8.--63. 1. "RSVD_DMAC_CHx_AXI_QOSREG_8to63,DMAC Channelx AXI QOS Register (bits 8to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 4.--7. "AXI_ARQOS,AXI ARQOS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 0.--3. "AXI_AWQOS,AXI AWQOS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.quad 0x180++0x07
        line.quad 0x00 "CH1_INTSTATUS_ENABLEREG,Writing 1 to specific field enables the corresponding interrupt status generation in Channelx Interrupt Status Register(CH1_IntStatusReg)"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_32to63,DMAC Channelx Interrupt Status Enable Register (bits 32to63) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 35. "Enable_ECC_PROT_UIDMem_UnCorrERR_IntStat,Channel x Unique ID Memory Interface ECC Protection Uncorrectable Error Interrupt enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            rbitfld.quad 0x00 34. "Enable_ECC_PROT_UIDMem_CorrERR_IntStat,Channel x Unique ID Memory Interface ECC Protection Correctable Error Interrupt enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            bitfld.quad 0x00 33. "Enable_ECC_PROT_CHMem_UnCorrERR_IntStat,Channel x Channel Memory Interface ECC Protection Uncorrectable Error Interrupt enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 32. "Enable_ECC_PROT_CHMem_CorrERR_IntStat,Channel x Channel Memory Interface ECC Protection Correctable Error Interrupt enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 31. "Enable_CH_ABORTED_IntStat,Channel Aborted Status Enable" "0: Disable the generation of Channel Aborted..,1: Enable the generation of Channel Aborted.."
            newline
            bitfld.quad 0x00 30. "Enable_CH_DISABLED_IntStat,Channel Disabled Status Enable" "0: Disable the generation of Channel Disabled..,1: Enable the generation of Channel Disabled.."
            newline
            bitfld.quad 0x00 29. "Enable_CH_SUSPENDED_IntStat,Channel Suspended Status Enable" "0: Disable the generation of Channel Suspended..,1: Enable the generation of Channel Suspended.."
            newline
            bitfld.quad 0x00 28. "Enable_CH_SRC_SUSPENDED_IntStat,Channel Source Suspended Status Enable" "0: Disable the generation of Channel Source..,1: Enable the generation of Channel Source.."
            newline
            bitfld.quad 0x00 27. "Enable_CH_LOCK_CLEARED_IntStat,Channel Lock Cleared Status Enable" "0: Disable the generation of Channel LOCK..,1: Enable the generation of Channel LOCK CLEARED.."
            newline
            rbitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_26,DMAC Channelx Interrupt Status Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "Enable_SLVIF_WRPARITY_ERR_IntStat,Slave Interface Write Parity Error Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            rbitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_22to24,DMAC Channelx Interrupt Status Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "Enable_SLVIF_WRONHOLD_ERR_IntStat,Slave Interface Write On Hold Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 20. "Enable_SLVIF_SHADOWREG_WRON_VALID_ERR_IntStat,Shadow Register Write On Valid Error Status Enable" "0: Disable the generation of Shadow Register..,1: Enable the generation of Shadow register.."
            newline
            bitfld.quad 0x00 19. "Enable_SLVIF_WRONCHEN_ERR_IntStat,Slave Interface Write On Channel Enabled Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 18. "Enable_SLVIF_RD2RWO_ERR_IntStat,Slave Interface Read to write Only Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface Read.."
            newline
            bitfld.quad 0x00 17. "Enable_SLVIF_WR2RO_ERR_IntStat,Slave Interface Write to Read Only Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 16. "Enable_SLVIF_DEC_ERR_IntStat,Slave Interface Decode Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            rbitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_15,DMAC Channelx Interrupt Status Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "Enable_SLVIF_MULTIBLKTYPE_ERR_IntStat,Slave Interface Multi Block type Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 13. "Enable_SHADOWREG_OR_LLI_INVALID_ERR_IntStat,Shadow register or LLI Invalid Error Status Enable" "0: Disable the generation of Shadow Register or..,1: Enable the generation of Shadow Register or.."
            newline
            bitfld.quad 0x00 12. "Enable_LLI_WR_SLV_ERR_IntStat,LLI WRITE Slave Error Status Enable" "0: Disable the generation of LLI WRITE Slave..,1: Enable the generation of LLI WRITE Slave.."
            newline
            bitfld.quad 0x00 11. "Enable_LLI_RD_SLV_ERR_IntStat,LLI Read Slave Error Status Enable" "0: Disable the generation of LLI Read Slave..,1: Enable the generation of LLI Read Slave Error.."
            newline
            bitfld.quad 0x00 10. "Enable_LLI_WR_DEC_ERR_IntStat,LLI WRITE Decode Error Status Enable" "0: Disable the generation of LLI WRITE Decode..,1: Enable the generation of LLI WRITE Decode.."
            newline
            bitfld.quad 0x00 9. "Enable_LLI_RD_DEC_ERR_IntStat,LLI Read Decode Error Status Enable" "0: Disable the generation of LLI Read Decode..,1: Enable the generation of LLI Read Decode.."
            newline
            bitfld.quad 0x00 8. "Enable_DST_SLV_ERR_IntStat,Destination Slave Error Status Enable" "0: Disable the generation of Destination Slave..,1: Enable the generation of Destination Slave.."
            newline
            bitfld.quad 0x00 7. "Enable_SRC_SLV_ERR_IntStat,Source Slave Error Status Enable" "0: Disable the generation of Source Slave Error..,1: Enable the generation of Source Slave Error.."
            newline
            bitfld.quad 0x00 6. "Enable_DST_DEC_ERR_IntStat,Destination Decode Error Status Enable" "0: Disable the generation of Destination Decode..,1: Enable the generation of Destination Decode.."
            newline
            bitfld.quad 0x00 5. "Enable_SRC_DEC_ERR_IntStat,Source Decode Error Status Enable" "0: Disable the generation of Source Decode Error..,1: Enable the generation of Source Decode Error.."
            newline
            bitfld.quad 0x00 4. "Enable_DST_TRANSCOMP_IntStat,Destination Transaction Completed Status Enable" "0: Disable the generation of Destination..,1: Enable the generation of Destination.."
            newline
            bitfld.quad 0x00 3. "Enable_SRC_TRANSCOMP_IntStat,Source Transaction Completed Status Enable" "0: Disable the generation of Source Transaction..,1: Enable the generation of Source Transaction.."
            newline
            rbitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_2,DMAC Channelx Interrupt Status Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "Enable_DMA_TFR_DONE_IntStat,DMA Transfer Done Interrupt Status Enable" "0: Disable the generation of DMA Transfer Done..,1: Enable the generation of DMA Transfer Done.."
            newline
            bitfld.quad 0x00 0. "Enable_BLOCK_TFR_DONE_IntStat,Block Transfer Done Interrupt Status Enable" "0: Disable the generation of Block Transfer Done..,1: Enable the generation of Block Transfer Done.."

    rgroup.quad 0x188++0x07
        line.quad 0x00 "CH1_INTSTATUS,Channelx Interrupt Status Register captures the Channelx specific interrupts"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTSTATUSREG_36to63,DMAC Channelx Specific Interrupt Register (bits 36to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 35. "ECC_PROT_UIDMem_UnCorrERR_IntStat,Channel x UID Memory Interface ECC Protection related Uncorrectable Error Interrupt Status bit" "0: Channel x UID Memory Interface Uncorrectable..,1: Channel x UID Memory Interface Uncorrectable.."
            newline
            bitfld.quad 0x00 34. "ECC_PROT_UIDMem_CorrERR_IntStat,Channel x UID Memory Interface ECC Protection related Correctable Error Interrupt Status bit" "0: Channel x UID Memory Interface correctable..,1: Channel x UID Memory Interface correctable.."
            newline
            bitfld.quad 0x00 33. "ECC_PROT_CHMem_UnCorrERR_IntStat,Channel x FIFO Memory Interface ECC Protection related Uncorrectable Error Interrupt Status bit" "0: Channel x FIFO Memory Interface Uncorrectable..,1: Channel x FIFO Memory Interface Uncorrectable.."
            newline
            bitfld.quad 0x00 32. "ECC_PROT_CHMem_CorrERR_IntStat,Channel x FIFO Memory Interface ECC Protection related Correctable Error Interrupt Status bit" "0: Channel x FIFO Memory Interface correctable..,1: Channel x FIFO Memory Interface correctable.."
            newline
            bitfld.quad 0x00 31. "CH_ABORTED_IntStat,Channel Aborted" "0: Channel is not aborted,1: Channel is aborted"
            newline
            bitfld.quad 0x00 30. "CH_DISABLED_IntStat,Channel Disabled" "0: Channel is not disabled,1: Channel is disabled"
            newline
            bitfld.quad 0x00 29. "CH_SUSPENDED_IntStat,Channel Suspended" "0: Channel is not suspended,1: Channel is suspended"
            newline
            bitfld.quad 0x00 28. "CH_SRC_SUSPENDED_IntStat,Channel Source Suspended" "0: Channel source is not suspended,1: Channel Source is suspended"
            newline
            bitfld.quad 0x00 27. "CH_LOCK_CLEARED_IntStat,Channel Lock Cleared" "0: Channel locking is not cleared if present,1: Channel Locking is cleared"
            newline
            bitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTSTATUSREG_26,DMAC Channelx Specific Interrupt Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "SLVIF_WRPARITY_ERR_IntStat,Slave Interface Write Parity Error" "0: No Slave Interface Write Parity Errors,1: Slave Interface Write Parity Error detected"
            newline
            bitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTSTATUSREG_22to24,DMAC Channelx Specific Interrupt Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "SLVIF_WRONHOLD_ERR_IntStat,Slave Interface Write On Hold Error" "0: No Slave Interface Write On Hold Errors,1: Slave Interface Write On Hold Error detected"
            newline
            bitfld.quad 0x00 20. "SLVIF_SHADOWREG_WRON_VALID_ERR_IntStat,Shadow Register Write On Valid Error" "0: No Slave Interface Shadow Register Write On..,1: Slave Interface Shadow Register Write On.."
            newline
            bitfld.quad 0x00 19. "SLVIF_WRONCHEN_ERR_IntStat,Slave Interface Write On Channel Enabled Error" "0: No Slave Interface Write On Channel Enabled..,1: Slave Interface Write On Channel Enabled.."
            newline
            bitfld.quad 0x00 18. "SLVIF_RD2RWO_ERR_IntStat,Slave Interface Read to write Only Error" "0: No Slave Interface Read to Write Only Errors,1: Slave Interface Read to Write Only Error.."
            newline
            bitfld.quad 0x00 17. "SLVIF_WR2RO_ERR_IntStat,Slave Interface Write to Read Only Error" "0: No Slave Interface Write to Read Only Errors,1: Slave Interface Write to Read Only Error.."
            newline
            bitfld.quad 0x00 16. "SLVIF_DEC_ERR_IntStat,Slave Interface Decode Error" "0: No Slave Interface Decode errors,1: Slave Interface Decode Error detected"
            newline
            bitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTSTATUSREG_15,DMAC Channelx Specific Interrupt Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "SLVIF_MULTIBLKTYPE_ERR_IntStat,Slave Interface Multi Block type Error" "0: No Multi-block transfer type Errors,1: Multi-block transfer type Error detected"
            newline
            bitfld.quad 0x00 13. "SHADOWREG_OR_LLI_INVALID_ERR_IntStat,Shadow register or LLI Invalid Error" "0: No Shadow Register / LLI Invalid errors,1: Shadow Register / LLI Invalid error detected"
            newline
            bitfld.quad 0x00 12. "LLI_WR_SLV_ERR_IntStat,LLI WRITE Slave Error" "0: No LLI write Slave Errors,1: LLI Write SLAVE Error detected"
            newline
            bitfld.quad 0x00 11. "LLI_RD_SLV_ERR_IntStat,LLI Read Slave Error" "0: No LLI Read Slave Errors,1: LLI read Slave Error detected"
            newline
            bitfld.quad 0x00 10. "LLI_WR_DEC_ERR_IntStat,LLI WRITE Decode Error" "0: NO LLI Write Decode Errors,1: LLI write Decode Error detected"
            newline
            bitfld.quad 0x00 9. "LLI_RD_DEC_ERR_IntStat,LLI Read Decode Error" "0: NO LLI Read Decode Errors,1: LLI Read Decode Error detected"
            newline
            bitfld.quad 0x00 8. "DST_SLV_ERR_IntStat,Destination Slave Error" "0: No Destination Slave Errors,1: Destination Slave Errors Detected"
            newline
            bitfld.quad 0x00 7. "SRC_SLV_ERR_IntStat,Source Slave Error" "0: No Source Slave Errors,1: Source Slave Error Detected"
            newline
            bitfld.quad 0x00 6. "DST_DEC_ERR_IntStat,Destination Decode Error" "0: No destination Decode Errors,1: Destination Decode Error Detected"
            newline
            bitfld.quad 0x00 5. "SRC_DEC_ERR_IntStat,Source Decode Error" "0: No Source Decode Errors,1: Source Decode Error detected"
            newline
            bitfld.quad 0x00 4. "DST_TRANSCOMP_IntStat,Destination Transaction Completed" "0: Destination transaction is not complete,1: Destination transaction is complete"
            newline
            bitfld.quad 0x00 3. "SRC_TRANSCOMP_IntStat,Source Transaction Completed" "0: Source transation is not complete,1: Source transaction is complete"
            newline
            bitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTSTATUSREG_2,DMAC Channelx Specific Interrupt Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "DMA_TFR_DONE_IntStat,DMA Transfer Done" "0: DMA Transfer not complete,1: DMA Transfer completed"
            newline
            bitfld.quad 0x00 0. "BLOCK_TFR_DONE_IntStat,Block Transfer Done" "0: Block Transfer not complete,1: Block Transfer completed"

    group.quad 0x190++0x07
        line.quad 0x00 "CH1_INTSIGNAL_ENABLEREG,This register contains fields that are used to enable the generation of port level interrupt at the channel level"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTSIGNAL_ENABLEREG_36to63,DMAC Channelx Interrupt Signal Enable Register (bits 36to63) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 35. "Enable_ECC_PROT_UIDMem_UnCorrERR_IntSignal,Channel x Unique ID Memory Interface ECC Protection Uncorrectable Error Interrupt Signal enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            rbitfld.quad 0x00 34. "Enable_ECC_PROT_UIDMem_CorrERR_IntSignal,Channel x Unique ID Memory Interface ECC Protection Correctable Error Interrupt Signal enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            bitfld.quad 0x00 33. "Enable_ECC_PROT_CHMem_UnCorrERR_IntSignal,Channel x Channel Memory Interface ECC Protection Uncorrectable Error Interrupt Signal enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 32. "Enable_ECC_PROT_CHMem_CorrERR_IntSignal,Channel x Channel Memory Interface ECC Protection Correctable Error Interrupt Signal enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 31. "Enable_CH_ABORTED_IntSignal,Channel Aborted Signal Enable" "0: Disable the propagation of Channel Aborted..,1: Enable the propagation of Channel Aborted.."
            newline
            bitfld.quad 0x00 30. "Enable_CH_DISABLED_IntSignal,Channel Disabled Signal Enable" "0: Disable the propagation of Channel Disabled..,1: Enable the propagation of Channel Disabled.."
            newline
            bitfld.quad 0x00 29. "Enable_CH_SUSPENDED_IntSignal,Channel Suspended Signal Enable" "0: Disable the propagation of Channel Suspended..,1: Enable the propagation of Channel Suspended.."
            newline
            bitfld.quad 0x00 28. "Enable_CH_SRC_SUSPENDED_IntSignal,Channel Source Suspended Signal Enable" "0: Disable the propagation of Channel Source..,1: Enable the propagation of Channel Source.."
            newline
            bitfld.quad 0x00 27. "Enable_CH_LOCK_CLEARED_IntSignal,Channel Lock Cleared Signal Enable" "0: Disable the propagation of Channel Lock..,1: Enable the propagation of Channel Lock.."
            newline
            rbitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTSIGNAL_ENABLEREG_26,DMAC Channelx Interrupt Signal Enable Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "Enable_SLVIF_WRPARITY_ERR_IntSignal,Slave Interface Write Parity Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            rbitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTSIGNAL_ENABLEREG_22to24,DMAC Channelx Interrupt Signal Enable Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "Enable_SLVIF_WRONHOLD_ERR_IntSignal,Slave Interface Write On Hold Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 20. "Enable_SLVIF_SHADOWREG_WRON_VALID_ERR_IntSignal,Shadow Register Write On Valid Error Signal Enable" "0: Disable the propagation of Shadow Register..,1: Enable the propagation of Shadow register.."
            newline
            bitfld.quad 0x00 19. "Enable_SLVIF_WRONCHEN_ERR_IntSignal,Slave Interface Write On Channel Enabled Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 18. "Enable_SLVIF_RD2RWO_ERR_IntSignal,Slave Interface Read to write Only Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 17. "Enable_SLVIF_WR2RO_ERR_IntSignal,Slave Interface Write to Read Only Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 16. "Enable_SLVIF_DEC_ERR_IntSignal,Slave Interface Decode Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            rbitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_15,DMAC Channelx Interrupt Status Enable Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "Enable_SLVIF_MULTIBLKTYPE_ERR_IntSignal,Slave Interface Multi Block type Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 13. "Enable_SHADOWREG_OR_LLI_INVALID_ERR_IntSignal,Shadow register or LLI Invalid Error Signal Enable" "0: Disable the propagation of Shadow Register or..,1: Enable the propagation of Shadow Register or.."
            newline
            bitfld.quad 0x00 12. "Enable_LLI_WR_SLV_ERR_IntSignal,LLI WRITE Slave Error Signal Enable" "0: Disable the propagation of LLI WRITE Slave..,1: Enable the propagation of LLI WRITE Slave.."
            newline
            bitfld.quad 0x00 11. "Enable_LLI_RD_SLV_ERR_IntSignal,LLI Read Slave Error Signal Enable" "0: Disable the propagation of LLI Read Slave..,1: Enable the propagation of LLI Read Slave.."
            newline
            bitfld.quad 0x00 10. "Enable_LLI_WR_DEC_ERR_IntSignal,LLI WRITE Decode Error Signal Enable" "0: Disable the propagation of LLI WRITE Decode..,1: Enable the propagation of LLI WRITE Decode.."
            newline
            bitfld.quad 0x00 9. "Enable_LLI_RD_DEC_ERR_IntSignal,LLI Read Decode Error Signal Enable" "0: Disable the propagation of LLI Read Decode..,1: Enable the propagation of LLI Read Decode.."
            newline
            bitfld.quad 0x00 8. "Enable_DST_SLV_ERR_IntSignal,Destination Slave Error Signal Enable" "0: Disable the propagation of Destination Slave..,1: Enable the propagation of Destination Slave.."
            newline
            bitfld.quad 0x00 7. "Enable_SRC_SLV_ERR_IntSignal,Source Slave Error Signal Enable" "0: Disable the propagation of Source Slave Error..,1: Enable the propagation of Source Slave Error.."
            newline
            bitfld.quad 0x00 6. "Enable_DST_DEC_ERR_IntSignal,Destination Decode Error Signal Enable" "0: Disable the propagation of Destination Decode..,1: Enable the propagation of Destination Decode.."
            newline
            bitfld.quad 0x00 5. "Enable_SRC_DEC_ERR_IntSignal,Source Decode Error Signal Enable" "0: Disable the propagation of Source Decode..,1: Enable the propagation of Source Decode Error.."
            newline
            bitfld.quad 0x00 4. "Enable_DST_TRANSCOMP_IntSignal,Destination Transaction Completed Signal Enable" "0: Disable the propagation of Destination..,1: Enable the propagation of Destination.."
            newline
            bitfld.quad 0x00 3. "Enable_SRC_TRANSCOMP_IntSignal,Source Transaction Completed Signal Enable" "0: Disable the propagation of Source Transaction..,1: Enable the propagation of Source Transaction.."
            newline
            rbitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_2,DMAC Channelx Interrupt Status Enable Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "Enable_DMA_TFR_DONE_IntSignal,DMA Transfer Done Interrupt Signal Enable" "0: Disable the propagation of DMA Transfer Done..,1: Enable the propagation of DMA Transfer Done.."
            newline
            bitfld.quad 0x00 0. "Enable_BLOCK_TFR_DONE_IntSignal,Block Transfer Done Interrupt Signal Enable" "0: Disable the propagation of Block Transfer..,1: Enable the propagation of Block Transfer Done.."

    wgroup.quad 0x198++0x07
        line.quad 0x00 "CH1_INTCLEARREG,Writing 1 to specific field will clear the corresponding field in Channelx Interrupt Status Register(CHx_IntStatusReg)"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTCLEARREG_36to63,DMAC Channelx Interrupt Clear Register (bits 36to63) Reserved bit - Read Only"
            newline
            bitfld.quad 0x00 35. "Clear_ECC_PROT_UIDMem_UnCorrERR_IntStat,ECC Protection Uncorrectable UID Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_UIDMem_UnCorrERR interrupt.."
            newline
            bitfld.quad 0x00 34. "Clear_ECC_PROT_UIDMem_CorrERR_IntStat,ECC Protection Correctable UID Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_UIDMem_CorrERR interrupt.."
            newline
            bitfld.quad 0x00 33. "Clear_ECC_PROT_CHMem_UnCorrERR_IntStat,ECC Protection Uncorrectable Channel Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_CHMem_UnCorrERR interrupt.."
            newline
            bitfld.quad 0x00 32. "Clear_ECC_PROT_CHMem_CorrERR_IntStat,ECC Protection Correctable Channel Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_CHMem_CorrERR interrupt in.."
            newline
            bitfld.quad 0x00 31. "Clear_CH_ABORTED_IntStat,Channel Aborted Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_ABORTED interrupt in the.."
            newline
            bitfld.quad 0x00 30. "Clear_CH_DISABLED_IntStat,Channel Disabled Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_DISABLED interrupt in the.."
            newline
            bitfld.quad 0x00 29. "Clear_CH_SUSPENDED_IntStat,Channel Suspended Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_SUSPENDED interrupt in the.."
            newline
            bitfld.quad 0x00 28. "Clear_CH_SRC_SUSPENDED_IntStat,Channel Source Suspended Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_SRC_SUSPENDED interrupt in the.."
            newline
            bitfld.quad 0x00 27. "Clear_CH_LOCK_CLEARED_IntStat,Channel Lock Cleared Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_LOCK_CLEARED interrupt in the.."
            newline
            bitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTCLEARREG_26,DMAC Channelx Interrupt Clear Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "Clear_SLVIF_WRPARITY_ERR_IntStat,Slave Interface Write Parity Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WRPARITY_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTCLEARREG_22to24,DMAC Channelx Interrupt Clear Register (bits 22to24) Reserved bit - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "Clear_SLVIF_WRONHOLD_ERR_IntStat,Slave Interface Write On Hold Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WRONHOLD_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 20. "Clear_SLVIF_SHADOWREG_WRON_VALID_ERR_IntStat,Shadow Register Write On Valid Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_SHADOWREG_WRON_VALID_ERR.."
            newline
            bitfld.quad 0x00 19. "Clear_SLVIF_WRONCHEN_ERR_IntStat,Slave Interface Write On Channel Enabled Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WRONCHEN_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 18. "Clear_SLVIF_RD2RWO_ERR_IntStat,Slave Interface Read to write Only Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_RD2RWO_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 17. "Clear_SLVIF_WR2RO_ERR_IntStat,Slave Interface Write to Read Only Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WR2RO_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 16. "Clear_SLVIF_DEC_ERR_IntStat,Slave Interface Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTCLEARREG_15,DMAC Channelx Interrupt Clear Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "Clear_SLVIF_MULTIBLKTYPE_ERR_IntStat,Slave Interface Multi Block type Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_MULTIBLKTYPE_ERR interrupt in.."
            newline
            bitfld.quad 0x00 13. "Clear_SHADOWREG_OR_LLI_INVALID_ERR_IntStat,Shadow register or LLI Invalid Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SHADOWREG_OR_LLI_INVALID_ERR.."
            newline
            bitfld.quad 0x00 12. "Clear_LLI_WR_SLV_ERR_IntStat,LLI WRITE Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_WR_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 11. "Clear_LLI_RD_SLV_ERR_IntStat,LLI Read Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_RD_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 10. "Clear_LLI_WR_DEC_ERR_IntStat,LLI WRITE Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_WR_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 9. "Clear_LLI_RD_DEC_ERR_IntStat,LLI Read Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_RD_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 8. "Clear_DST_SLV_ERR_IntStat,Destination Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the DST_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 7. "Clear_SRC_SLV_ERR_IntStat,Source Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SRC_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 6. "Clear_DST_DEC_ERR_IntStat,Destination Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the DST_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 5. "Clear_SRC_DEC_ERR_IntStat,Source Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SRC_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 4. "Clear_DST_TRANSCOMP_IntStat,Destination Transaction Completed Interrupt Clear Bit" "0: Inactive signal,1: Clear the DST_TRANSCOMP interrupt in the.."
            newline
            bitfld.quad 0x00 3. "Clear_SRC_TRANSCOMP_IntStat,Source Transaction Completed Interrupt Clear Bit" "0: Inactive signal,1: Clear the SRC_TRANSCOMP interrupt in the.."
            newline
            bitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTCLEARREG_2,DMAC Channelx Interrupt Clear Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "Clear_DMA_TFR_DONE_IntStat,DMA Transfer Done Interrupt Clear Bit" "0: Inactive signal,1: Clear the DMA_TFR_DONE interrupt in the.."
            newline
            bitfld.quad 0x00 0. "Clear_BLOCK_TFR_DONE_IntStat,Block Transfer Done Interrupt Clear Bit" "0: Inactive signal,1: Clear the interrupt in the Interrupt Status.."

    group.quad 0x200++0x07
        line.quad 0x00 "CH2_SAR,The starting source address is programmed by software before the DMA channel is enabled or by an LLI update before the start of the DMA transfer"
            hexmask.quad 0x00 0.--63. 1. "SAR,Current Source Address of DMA transfer"
    group.quad 0x208++0x07
        line.quad 0x00 "CH2_DAR,The starting destination address is programmed by the software before the DMA channel is enabled or by an LLI update before the start of the DMA transfer"
            hexmask.quad 0x00 0.--63. 1. "DAR,Current Destination Address of DMA transfer"
    group.quad 0x210++0x07
        line.quad 0x00 "CH2_BLOCK_TS,When DW_axi_dmac is the flow controller the DMAC uses this register before the channel is enabled for block-size"
            hexmask.quad.quad 0x00 22.--63. 1. "RSVD_DMAC_CHx_BLOCK_TSREG_63to22,DMAC Channelx Block Transfer Size Register (bits 63to22) Reserved bits - Read Only"
            newline
            hexmask.quad.tbyte 0x00 0.--21. 1. "BLOCK_TS,Block Transfer Size"
    group.quad 0x218++0x07
        line.quad 0x00 "CH2_CTL,This register contains fields that control the DMA transfer"
            bitfld.quad 0x00 63. "SHADOWREG_OR_LLI_VALID,Shadow Register content/Linked List Item valid" "0: Indicates shadowreg/LLI content is Invalid,1: Indicates shadowreg/LLI content is Valid"
            newline
            bitfld.quad 0x00 62. "SHADOWREG_OR_LLI_LAST,Last Shadow Register/Linked List Item" "0: Indicates shadowreg/LLI content is not the..,1: Indicates shadowreg/LLI content is the last one"
            newline
            rbitfld.quad 0x00 59.--61. "RSVD_DMAC_CHx_CTL_59to61,DMAC Channelx Control Transfer Register (bits 59to61) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 58. "IOC_BlkTfr,Interrupt On completion of Block Transfer This bit is used to control the block transfer completion interrupt generation on a block by block basis for shadow register or linked list based multi-block transfers" "0: Disables..,1: Enables.."
            newline
            rbitfld.quad 0x00 57. "DST_STAT_EN,Destination Status Enable Enable the logic to fetch status from destination peripheral of channel x pointed to by the content of CHx_DSTATAR register and stores it in CHx_DSTAT register" "0: No status fetch for Destination device,1: Enables status fetch for Destination and.."
            newline
            rbitfld.quad 0x00 56. "SRC_STAT_EN,Source Status Enable Enable the logic to fetch status from source peripheral of channel x pointed to by the content of CHx_SSTATAR register and stores it in CHx_SSTAT register" "0: No status fetch for Source device,1: Enables status fetch for Source and store the.."
            newline
            hexmask.quad.byte 0x00 48.--55. 1. "AWLEN,Destination Burst Length AXI Burst length used for destination data transfer"
            newline
            bitfld.quad 0x00 47. "AWLEN_EN,Destination Burst Length Enable If this bit is set to 1 DW_axi_dmac uses the value of CHx_CTL.AWLEN as AXI Burst length for destination data transfer till the extent possible remaining transfers use maximum possible burst length" "0: AXI Burst Length is any possible value <=..,1: AXI Burst Length is CH2_CTL.AWLEN (till the.."
            newline
            hexmask.quad.byte 0x00 39.--46. 1. "ARLEN,Source Burst Length AXI Burst length used for source data transfer"
            newline
            bitfld.quad 0x00 38. "ARLEN_EN,Source Burst Length Enable If this bit is set to 1 DW_axi_dmac uses the value of CHx_CTL.ARLEN as AXI Burst length for source data transfer till the extent possible remaining transfers use maximum possible burst length" "0: AXI Burst Length is any possible value <=..,1: AXI Burst Length is CH2_CTL.ARLEN (till the.."
            newline
            bitfld.quad 0x00 35.--37. "AW_PROT,AXI 'aw_prot' signal" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 32.--34. "AR_PROT,AXI 'ar_prot' signal" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 31. "RSVD_DMAC_CHx_CTL_31,DMAC Channelx Control Transfer Register bit31 Reserved bits - Read Only" "0,1"
            newline
            bitfld.quad 0x00 30. "NonPosted_LastWrite_En,Non Posted Last Write Enable This bit decides whether posted writes can be used throughout the block transfer" "0: Posted writes may be used throughout the..,1: Last write in the block must be non-posted"
            newline
            bitfld.quad 0x00 26.--29. "AW_CACHE,AXI 'aw_cache' signal" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 22.--25. "AR_CACHE,AXI 'ar_cache' signal" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 18.--21. "DST_MSIZE,Destination Burst Transaction Length" "0: 1 Data Item read from Destination in the..,1: 4 Data Item read from Destination in the..,2: 8 Data Item read from Destination in the..,3: 16 Data Item read from Destination in the..,4: 32 Data Item read from Destination in the..,5: 64 Data Item read from Destination in the..,6: 128 Data Item read from Destination in the..,7: 256 Data Item read from Destination in the..,8: 512 Data Item read from Destination in the..,9: 1024 Data Item read from Destination in the..,?..."
            newline
            bitfld.quad 0x00 14.--17. "SRC_MSIZE,Source Burst Transaction Length" "0: 1 Data Item read from Source in the burst..,1: 4 Data Item read from Source in the burst..,2: 8 Data Item read from Source in the burst..,3: 16 Data Item read from Source in the burst..,4: 32 Data Item read from Source in the burst..,5: 64 Data Item read from Source in the burst..,6: 128 Data Item read from Source in the burst..,7: 256 Data Item read from Source in the burst..,8: 512 Data Item read from Source in the burst..,9: 1024 Data Item read from Source in the burst..,?..."
            newline
            bitfld.quad 0x00 11.--13. "DST_TR_WIDTH,Destination Transfer Width" "0: Destination Transfer Width is 8 bits,1: Destination Transfer Width is 16 bits,2: Destination Transfer Width is 32 bits,3: Destination Transfer Width is 64 bits,4: Destination Transfer Width is 128 bits,5: Destination Transfer Width is 256 bits,6: Destination Transfer Width is 512 bits,?..."
            newline
            bitfld.quad 0x00 8.--10. "SRC_TR_WIDTH,Source Transfer Width" "0: Source Transfer Width is 8 bits,1: Source Transfer Width is 16 bits,2: Source Transfer Width is 32 bits,3: Source Transfer Width is 64 bits,4: Source Transfer Width is 128 bits,5: Source Transfer Width is 256 bits,6: Source Transfer Width is 512 bits,?..."
            newline
            rbitfld.quad 0x00 7. "RSVD_DMAC_CHx_CTL_7,DMAC Channelx Control Transfer Register bit7 Reserved bits - Read Only" "0,1"
            newline
            bitfld.quad 0x00 6. "DINC,Destination Address Increment" "0: Destination address incremented on every..,1: Destination address is fixed"
            newline
            rbitfld.quad 0x00 5. "RSVD_DMAC_CHx_CTL_5,DMAC Channelx Control Transfer Register bit5 Reserved bits - Read Only" "0,1"
            newline
            bitfld.quad 0x00 4. "SINC,Source Address Increment" "0: Source address incremented on every source..,1: Source address is fixed"
            newline
            rbitfld.quad 0x00 3. "RSVD_DMAC_CHx_CTL_3,DMAC Channelx Control Transfer Register bit3 Reserved bits - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 2. "DMS,Destination Master Select" "0: Destination device on Master-1 interface layer,1: Destination device on Master-2 interface layer"
            newline
            rbitfld.quad 0x00 1. "RSVD_DMAC_CHx_CTL_1,DMAC Channelx Control Transfer Register bit1 Reserved bits - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 0. "SMS,Source Master Select" "0: Source device on Master-1 interface layer,1: Source device on Master-2 interface layer"
    group.quad 0x220++0x07
        line.quad 0x00 "CH2_CFG,This register contains fields that configure the DMA transfer"
            rbitfld.quad 0x00 63. "RSVD_DMAC_CHx_CFG_63,DMAC Channelx Transfer Configuration Register (63bit) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 59.--62. "DST_OSR_LMT,Destination Outstanding Request Limit - Maximum outstanding request supported is 16" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 55.--58. "SRC_OSR_LMT,Source Outstanding Request Limit - Maximum outstanding request supported is 16" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.quad 0x00 53.--54. "LOCK_CH_L,Channel Lock Level This bit indicates the duration over which CHx_CFG.LOCK_CH bit applies" "0: Duration of the Channel locking is for the..,1: Duration of the Channel locking is for the..,?..."
            newline
            rbitfld.quad 0x00 52. "LOCK_CH,Channel Lock bit When the channel is granted control of the master bus interface and if the CHx_CFG.LOCK_CH bit is asserted then no other channels are granted control of the master bus interface for the duration specified in CHx_CFG.LOCK_CH_L" "0: Channel is not locked during the transfers,1: Channel is locked and granted exclusive.."
            newline
            bitfld.quad 0x00 49.--51. "CH_PRIOR,Channel Priority A priority of DMAX_NUM_CHANNELS-1 is the highest priority and 0 is the lowest" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 48. "RSVD_DMAC_CHx_CFG_48,DMAC Channelx Transfer Configuration Register (48bit) Reserved bit - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 46.--47. "RSVD_DMAC_CHx_CFG_47_44,DMAC Channelx Transfer Configuration Register (bits (LOG2_DMAX_NUM_HS_IF+44) to 47) Reserved bits - Read Only" "0,1,2,3"
            newline
            bitfld.quad 0x00 44.--45. "DST_PER,Assigns a hardware handshaking interface (0 - DMAX_NUM_HS_IF-1) to the destination of Channelx if the CHx_CFG.HS_SEL_DST field is 0 otherwise this field is ignored" "0,1,2,3"
            newline
            rbitfld.quad 0x00 43. "RSVD_DMAC_CHx_CFG_43,DMAC Channelx Transfer Configuration Register (43bit) Reserved bit - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 41.--42. "RSVD_DMAC_CHx_CFG_42_39,DMAC Channelx Transfer Configuration Register (bits (LOG2_DMAX_NUM_HS_IF+39) to 42) Reserved bits - Read Only" "0,1,2,3"
            newline
            bitfld.quad 0x00 39.--40. "SRC_PER,Assigns a hardware handshaking interface (0 - DMAX_NUM_HS_IF-1) to the source of Channelx if the CHx_CFG.HS_SEL_SRC field is 0 otherwise this field is ignored" "0,1,2,3"
            newline
            rbitfld.quad 0x00 38. "DST_HWHS_POL,Destination Hardware Handshaking Interface Polarity" "0: Polarity of the Handshaking Interface used..,1: Polarity of the Handshaking Interface used.."
            newline
            rbitfld.quad 0x00 37. "SRC_HWHS_POL,Source Hardware Handshaking Interface Polarity" "0: Polarity of the Handshaking Interface used..,1: Polarity of the Handshaking Interface used.."
            newline
            bitfld.quad 0x00 36. "HS_SEL_DST,Destination Software or Hardware Handshaking Select" "0: Hardware Handshaking Interface is used for..,1: Software Handshaking Interface is used for.."
            newline
            bitfld.quad 0x00 35. "HS_SEL_SRC,Source Software or Hardware Handshaking Select" "0: Hardware Handshaking Interface is used for..,1: Software Handshaking Interface is used for.."
            newline
            bitfld.quad 0x00 32.--34. "TT_FC,Transfer Type and Flow Control" "0: Transfer Type is memory to memory and Flow..,1: Transfer Type is memory to peripheral and..,2: Transfer Type is peripheral to memory and..,3: Transfer Type is peripheral to peripheral and..,4: Transfer Type is peripheral to Memory and..,5: Transfer Type is peripheral to peripheral and..,6: Transfer Type is memory to peripheral and..,7: Transfer Type is peripheral to peripheral and.."
            newline
            rbitfld.quad 0x00 29.--31. "RSVD_DMAC_CHx_CFG_29to31,DMAC Channelx Transfer Configuration Register (bits 29to31) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 25.--28. "WR_UID,Defines the number of AXI Unique ID's supported for the AXI Write Channel" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_CFG_22to24,DMAC Channelx Transfer Configuration Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 18.--21. "RD_UID,Defines the number of AXI Unique ID's supported for the AXI Read Channel" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.quad.word 0x00 4.--17. 1. "RSVD_DMAC_CHx_CFG_4to17,DMAC Channelx Transfer Configuration Register (bits 4to17) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 2.--3. "DST_MULTBLK_TYPE,Destination Multi Block Transfer Type" "0: Contiguous Multiblock Type used for..,1: Reload Multiblock Type used for Destination..,2: Shadow Register based Multiblock Type used..,3: Linked List based Multiblock Type used for.."
            newline
            rbitfld.quad 0x00 0.--1. "SRC_MULTBLK_TYPE,Source Multi Block Transfer Type" "0: Contiguous Multiblock Type used for Source..,1: Reload Multiblock Type used for Source Transfer,2: Shadow Register based Multiblock Type used..,3: Linked List based Multiblock Type used for.."
    group.quad 0x228++0x07
        line.quad 0x00 "CH2_LLP,This is the Linked List Pointer register"
            hexmask.quad 0x00 6.--63. 1. "LOC,Starting Address Memory of LLI block Starting Address In Memory of next LLI if block chaining is enabled"
            newline
            rbitfld.quad 0x00 1.--5. "RSVD_DMAC_CHx_LLP_1to5,DMAC Channelx Linked List Pointer Register (bits 1to5) Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            rbitfld.quad 0x00 0. "LMS,LLI master Select This bit identifies the AXI layer/interface where the memory device that stores the next linked list item resides" "0: next Linked List item resides on AXI Master1..,1: next Linked List item resides on AXI Master2.."

    rgroup.quad 0x230++0x07
        line.quad 0x00 "CH2_STATUSREG,Channelx Status Register contains fields that indicate the status of DMA transfers for Channelx"
            hexmask.quad.tbyte 0x00 47.--63. 1. "RSVD_DMAC_CHx_STATUSREG_47to63,DMAC Channelx Status Register (bits 47to63) Reserved bits - Read Only"
            newline
            hexmask.quad.word 0x00 32.--46. 1. "DATA_LEFT_IN_FIFO,Data Left in FIFO"
            newline
            hexmask.quad.word 0x00 22.--31. 1. "RSVD_DMAC_CHx_STATUSREG_22to31,DMAC Channelx Status Register (bits 22to31) Reserved bits - Read Only"
            newline
            hexmask.quad.tbyte 0x00 0.--21. 1. "CMPLTD_BLK_TFR_SIZE,Completed Block Transfer Size"

    group.quad 0x238++0x07
        line.quad 0x00 "CH2_SWHSSRCREG,Channelx Software handshake Source Register"
            hexmask.quad 0x00 6.--63. 1. "RSVD_DMAC_CHx_SWHSSRCREG_6to63,DMAC Channelx Software Handshake Source Register (bits 6to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 5. "SWHS_LST_SRC_WE,Write Enable bit for Software Handshake Last Request for Channel Source" "0: Disables write to the SWHS_LAST_SRC bit,1: Enables write to the SWHS_LAST_SRC bit"
            newline
            bitfld.quad 0x00 4. "SWHS_LST_SRC,Software Handshake Last Request for Channel Source" "0: Source peripheral indication that the curent..,1: Source peripheral indication to dmac that the.."
            newline
            bitfld.quad 0x00 3. "SWHS_SGLREQ_SRC_WE,Write Enable bit for Software Handshake Single Request for Channel Source" "0: Disables write to the SWHS_SGLREQ_SRC bit,1: Enables write to the SWHS_SGLREQ_SRC bit"
            newline
            bitfld.quad 0x00 2. "SWHS_SGLREQ_SRC,Software Handshake Single Request for Channel Source" "0: Source peripheral is not requesting for a..,1: Source peripheral request for a single dma.."
            newline
            bitfld.quad 0x00 1. "SWHS_REQ_SRC_WE,Write Enable bit for Software Handshake Request for Channel Source" "0: Disables write to the SWHS_REQ_SRC bit,1: Enables write to the SWHS_REQ_SRC bit"
            newline
            bitfld.quad 0x00 0. "SWHS_REQ_SRC,Software Handshake Request for Channel Source" "0: Source peripheral is not requesting for a..,1: Source peripheral request for a dma transfer"
    group.quad 0x240++0x07
        line.quad 0x00 "CH2_SWHSDSTREG,Channelx Software handshake Destination Register"
            hexmask.quad 0x00 6.--63. 1. "RSVD_DMAC_CHx_SWHSDSTREG_6to63,DMAC Channelx Software Handshake Destination Register (bits 6to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 5. "SWHS_LST_DST_WE,Write Enable bit for Software Handshake Last Request for Channel Destination" "0: Disables write to the SWHS_LAST_DST bit,1: Enables write to the SWHS_LAST_DST bit"
            newline
            bitfld.quad 0x00 4. "SWHS_LST_DST,Software Handshake Last Request for Channel Destination" "0: Destination peripheral indication that the..,1: Destination peripheral indication to dmac.."
            newline
            bitfld.quad 0x00 3. "SWHS_SGLREQ_DST_WE,Write Enable bit for Software Handshake Single Request for Channel Destination" "0: Disables write to the SWHS_SGLREQ_DST bit,1: Enables write to the SWHS_SGLREQ_DST bit"
            newline
            bitfld.quad 0x00 2. "SWHS_SGLREQ_DST,Software Handshake Single Request for Channel Destination" "0: Destination peripheral is not requesting for..,1: Destination peripheral request for a single.."
            newline
            bitfld.quad 0x00 1. "SWHS_REQ_DST_WE,Write Enable bit for Software Handshake Request for Channel Destination" "0: Disables write to the SWHS_REQ_DST bit,1: Enables write to the SWHS_REQ_DST bit"
            newline
            bitfld.quad 0x00 0. "SWHS_REQ_DST,Software Handshake Request for Channel Destination" "0: Destination peripheral is not requesting for..,1: Destination peripheral request for a dma.."

    wgroup.quad 0x248++0x07
        line.quad 0x00 "CH2_BLK_TFR_RESUMEREQREG,Channelx Block Transfer Resume Request Register"
            hexmask.quad 0x00 1.--63. 1. "RSVD_DMAC_CHx_BLK_TFR_RESUMEREQREG_1to63,DMAC Channelx Block Transfer Resume Request Register (bits 1to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 0. "BLK_TFR_RESUMEREQ,Block Transfer Resume Request during Linked-List or Shadow-Register-based multi-block transfer" "0: No request to resume the block transfer,1: Request for resuming the block transfer"

    group.quad 0x250++0x07
        line.quad 0x00 "CH2_AXI_IDREG,Channelx AXI ID Register"
            hexmask.quad.long 0x00 32.--63. 1. "RSVD_DMAC_CHx_AXI_IDREG_32to63,DMAC Channelx AXI ID Register (bits 32to63) Reserved bits - Read Only"
            newline
            hexmask.quad.word 0x00 18.--31. 1. "RSVD_DMAC_CHx_AXI_IDREG_IDW_L2NCm32to63,DMAC Channelx AXI ID Register (bits (IDW-L2NC-1)to32) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 16.--17. "AXI_WRITE_ID_SUFFIX,AXI Write ID Suffix" "0,1,2,3"
            newline
            hexmask.quad.word 0x00 2.--15. 1. "RSVD_DMAC_CHx_AXI_IDREG_IDW_L2NCm1to31,DMAC Channelx AXI ID Register (bits (IDW-L2NC-1)to31) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 0.--1. "AXI_READ_ID_SUFFIX,AXI Read ID Suffix These bits form part of the ARID output of AXI3/AXI4 master interface" "0,1,2,3"
    group.quad 0x258++0x07
        line.quad 0x00 "CH2_AXI_QOSREG,Channelx AXI QOS Register"
            hexmask.quad.quad 0x00 8.--63. 1. "RSVD_DMAC_CHx_AXI_QOSREG_8to63,DMAC Channelx AXI QOS Register (bits 8to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 4.--7. "AXI_ARQOS,AXI ARQOS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 0.--3. "AXI_AWQOS,AXI AWQOS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.quad 0x280++0x07
        line.quad 0x00 "CH2_INTSTATUS_ENABLEREG,Writing 1 to specific field enables the corresponding interrupt status generation in Channelx Interrupt Status Register(CH2_IntStatusReg)"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_32to63,DMAC Channelx Interrupt Status Enable Register (bits 32to63) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 35. "Enable_ECC_PROT_UIDMem_UnCorrERR_IntStat,Channel x Unique ID Memory Interface ECC Protection Uncorrectable Error Interrupt enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            rbitfld.quad 0x00 34. "Enable_ECC_PROT_UIDMem_CorrERR_IntStat,Channel x Unique ID Memory Interface ECC Protection Correctable Error Interrupt enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            bitfld.quad 0x00 33. "Enable_ECC_PROT_CHMem_UnCorrERR_IntStat,Channel x Channel Memory Interface ECC Protection Uncorrectable Error Interrupt enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 32. "Enable_ECC_PROT_CHMem_CorrERR_IntStat,Channel x Channel Memory Interface ECC Protection Correctable Error Interrupt enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 31. "Enable_CH_ABORTED_IntStat,Channel Aborted Status Enable" "0: Disable the generation of Channel Aborted..,1: Enable the generation of Channel Aborted.."
            newline
            bitfld.quad 0x00 30. "Enable_CH_DISABLED_IntStat,Channel Disabled Status Enable" "0: Disable the generation of Channel Disabled..,1: Enable the generation of Channel Disabled.."
            newline
            bitfld.quad 0x00 29. "Enable_CH_SUSPENDED_IntStat,Channel Suspended Status Enable" "0: Disable the generation of Channel Suspended..,1: Enable the generation of Channel Suspended.."
            newline
            bitfld.quad 0x00 28. "Enable_CH_SRC_SUSPENDED_IntStat,Channel Source Suspended Status Enable" "0: Disable the generation of Channel Source..,1: Enable the generation of Channel Source.."
            newline
            bitfld.quad 0x00 27. "Enable_CH_LOCK_CLEARED_IntStat,Channel Lock Cleared Status Enable" "0: Disable the generation of Channel LOCK..,1: Enable the generation of Channel LOCK CLEARED.."
            newline
            rbitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_26,DMAC Channelx Interrupt Status Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "Enable_SLVIF_WRPARITY_ERR_IntStat,Slave Interface Write Parity Error Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            rbitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_22to24,DMAC Channelx Interrupt Status Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "Enable_SLVIF_WRONHOLD_ERR_IntStat,Slave Interface Write On Hold Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 20. "Enable_SLVIF_SHADOWREG_WRON_VALID_ERR_IntStat,Shadow Register Write On Valid Error Status Enable" "0: Disable the generation of Shadow Register..,1: Enable the generation of Shadow register.."
            newline
            bitfld.quad 0x00 19. "Enable_SLVIF_WRONCHEN_ERR_IntStat,Slave Interface Write On Channel Enabled Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 18. "Enable_SLVIF_RD2RWO_ERR_IntStat,Slave Interface Read to write Only Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface Read.."
            newline
            bitfld.quad 0x00 17. "Enable_SLVIF_WR2RO_ERR_IntStat,Slave Interface Write to Read Only Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 16. "Enable_SLVIF_DEC_ERR_IntStat,Slave Interface Decode Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            rbitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_15,DMAC Channelx Interrupt Status Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "Enable_SLVIF_MULTIBLKTYPE_ERR_IntStat,Slave Interface Multi Block type Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 13. "Enable_SHADOWREG_OR_LLI_INVALID_ERR_IntStat,Shadow register or LLI Invalid Error Status Enable" "0: Disable the generation of Shadow Register or..,1: Enable the generation of Shadow Register or.."
            newline
            bitfld.quad 0x00 12. "Enable_LLI_WR_SLV_ERR_IntStat,LLI WRITE Slave Error Status Enable" "0: Disable the generation of LLI WRITE Slave..,1: Enable the generation of LLI WRITE Slave.."
            newline
            bitfld.quad 0x00 11. "Enable_LLI_RD_SLV_ERR_IntStat,LLI Read Slave Error Status Enable" "0: Disable the generation of LLI Read Slave..,1: Enable the generation of LLI Read Slave Error.."
            newline
            bitfld.quad 0x00 10. "Enable_LLI_WR_DEC_ERR_IntStat,LLI WRITE Decode Error Status Enable" "0: Disable the generation of LLI WRITE Decode..,1: Enable the generation of LLI WRITE Decode.."
            newline
            bitfld.quad 0x00 9. "Enable_LLI_RD_DEC_ERR_IntStat,LLI Read Decode Error Status Enable" "0: Disable the generation of LLI Read Decode..,1: Enable the generation of LLI Read Decode.."
            newline
            bitfld.quad 0x00 8. "Enable_DST_SLV_ERR_IntStat,Destination Slave Error Status Enable" "0: Disable the generation of Destination Slave..,1: Enable the generation of Destination Slave.."
            newline
            bitfld.quad 0x00 7. "Enable_SRC_SLV_ERR_IntStat,Source Slave Error Status Enable" "0: Disable the generation of Source Slave Error..,1: Enable the generation of Source Slave Error.."
            newline
            bitfld.quad 0x00 6. "Enable_DST_DEC_ERR_IntStat,Destination Decode Error Status Enable" "0: Disable the generation of Destination Decode..,1: Enable the generation of Destination Decode.."
            newline
            bitfld.quad 0x00 5. "Enable_SRC_DEC_ERR_IntStat,Source Decode Error Status Enable" "0: Disable the generation of Source Decode Error..,1: Enable the generation of Source Decode Error.."
            newline
            bitfld.quad 0x00 4. "Enable_DST_TRANSCOMP_IntStat,Destination Transaction Completed Status Enable" "0: Disable the generation of Destination..,1: Enable the generation of Destination.."
            newline
            bitfld.quad 0x00 3. "Enable_SRC_TRANSCOMP_IntStat,Source Transaction Completed Status Enable" "0: Disable the generation of Source Transaction..,1: Enable the generation of Source Transaction.."
            newline
            rbitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_2,DMAC Channelx Interrupt Status Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "Enable_DMA_TFR_DONE_IntStat,DMA Transfer Done Interrupt Status Enable" "0: Disable the generation of DMA Transfer Done..,1: Enable the generation of DMA Transfer Done.."
            newline
            bitfld.quad 0x00 0. "Enable_BLOCK_TFR_DONE_IntStat,Block Transfer Done Interrupt Status Enable" "0: Disable the generation of Block Transfer Done..,1: Enable the generation of Block Transfer Done.."

    rgroup.quad 0x288++0x07
        line.quad 0x00 "CH2_INTSTATUS,Channelx Interrupt Status Register captures the Channelx specific interrupts"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTSTATUSREG_36to63,DMAC Channelx Specific Interrupt Register (bits 36to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 35. "ECC_PROT_UIDMem_UnCorrERR_IntStat,Channel x UID Memory Interface ECC Protection related Uncorrectable Error Interrupt Status bit" "0: Channel x UID Memory Interface Uncorrectable..,1: Channel x UID Memory Interface Uncorrectable.."
            newline
            bitfld.quad 0x00 34. "ECC_PROT_UIDMem_CorrERR_IntStat,Channel x UID Memory Interface ECC Protection related Correctable Error Interrupt Status bit" "0: Channel x UID Memory Interface correctable..,1: Channel x UID Memory Interface correctable.."
            newline
            bitfld.quad 0x00 33. "ECC_PROT_CHMem_UnCorrERR_IntStat,Channel x FIFO Memory Interface ECC Protection related Uncorrectable Error Interrupt Status bit" "0: Channel x FIFO Memory Interface Uncorrectable..,1: Channel x FIFO Memory Interface Uncorrectable.."
            newline
            bitfld.quad 0x00 32. "ECC_PROT_CHMem_CorrERR_IntStat,Channel x FIFO Memory Interface ECC Protection related Correctable Error Interrupt Status bit" "0: Channel x FIFO Memory Interface correctable..,1: Channel x FIFO Memory Interface correctable.."
            newline
            bitfld.quad 0x00 31. "CH_ABORTED_IntStat,Channel Aborted" "0: Channel is not aborted,1: Channel is aborted"
            newline
            bitfld.quad 0x00 30. "CH_DISABLED_IntStat,Channel Disabled" "0: Channel is not disabled,1: Channel is disabled"
            newline
            bitfld.quad 0x00 29. "CH_SUSPENDED_IntStat,Channel Suspended" "0: Channel is not suspended,1: Channel is suspended"
            newline
            bitfld.quad 0x00 28. "CH_SRC_SUSPENDED_IntStat,Channel Source Suspended" "0: Channel source is not suspended,1: Channel Source is suspended"
            newline
            bitfld.quad 0x00 27. "CH_LOCK_CLEARED_IntStat,Channel Lock Cleared" "0: Channel locking is not cleared if present,1: Channel Locking is cleared"
            newline
            bitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTSTATUSREG_26,DMAC Channelx Specific Interrupt Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "SLVIF_WRPARITY_ERR_IntStat,Slave Interface Write Parity Error" "0: No Slave Interface Write Parity Errors,1: Slave Interface Write Parity Error detected"
            newline
            bitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTSTATUSREG_22to24,DMAC Channelx Specific Interrupt Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "SLVIF_WRONHOLD_ERR_IntStat,Slave Interface Write On Hold Error" "0: No Slave Interface Write On Hold Errors,1: Slave Interface Write On Hold Error detected"
            newline
            bitfld.quad 0x00 20. "SLVIF_SHADOWREG_WRON_VALID_ERR_IntStat,Shadow Register Write On Valid Error" "0: No Slave Interface Shadow Register Write On..,1: Slave Interface Shadow Register Write On.."
            newline
            bitfld.quad 0x00 19. "SLVIF_WRONCHEN_ERR_IntStat,Slave Interface Write On Channel Enabled Error" "0: No Slave Interface Write On Channel Enabled..,1: Slave Interface Write On Channel Enabled.."
            newline
            bitfld.quad 0x00 18. "SLVIF_RD2RWO_ERR_IntStat,Slave Interface Read to write Only Error" "0: No Slave Interface Read to Write Only Errors,1: Slave Interface Read to Write Only Error.."
            newline
            bitfld.quad 0x00 17. "SLVIF_WR2RO_ERR_IntStat,Slave Interface Write to Read Only Error" "0: No Slave Interface Write to Read Only Errors,1: Slave Interface Write to Read Only Error.."
            newline
            bitfld.quad 0x00 16. "SLVIF_DEC_ERR_IntStat,Slave Interface Decode Error" "0: No Slave Interface Decode errors,1: Slave Interface Decode Error detected"
            newline
            bitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTSTATUSREG_15,DMAC Channelx Specific Interrupt Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "SLVIF_MULTIBLKTYPE_ERR_IntStat,Slave Interface Multi Block type Error" "0: No Multi-block transfer type Errors,1: Multi-block transfer type Error detected"
            newline
            bitfld.quad 0x00 13. "SHADOWREG_OR_LLI_INVALID_ERR_IntStat,Shadow register or LLI Invalid Error" "0: No Shadow Register / LLI Invalid errors,1: Shadow Register / LLI Invalid error detected"
            newline
            bitfld.quad 0x00 12. "LLI_WR_SLV_ERR_IntStat,LLI WRITE Slave Error" "0: No LLI write Slave Errors,1: LLI Write SLAVE Error detected"
            newline
            bitfld.quad 0x00 11. "LLI_RD_SLV_ERR_IntStat,LLI Read Slave Error" "0: No LLI Read Slave Errors,1: LLI read Slave Error detected"
            newline
            bitfld.quad 0x00 10. "LLI_WR_DEC_ERR_IntStat,LLI WRITE Decode Error" "0: NO LLI Write Decode Errors,1: LLI write Decode Error detected"
            newline
            bitfld.quad 0x00 9. "LLI_RD_DEC_ERR_IntStat,LLI Read Decode Error" "0: NO LLI Read Decode Errors,1: LLI Read Decode Error detected"
            newline
            bitfld.quad 0x00 8. "DST_SLV_ERR_IntStat,Destination Slave Error" "0: No Destination Slave Errors,1: Destination Slave Errors Detected"
            newline
            bitfld.quad 0x00 7. "SRC_SLV_ERR_IntStat,Source Slave Error" "0: No Source Slave Errors,1: Source Slave Error Detected"
            newline
            bitfld.quad 0x00 6. "DST_DEC_ERR_IntStat,Destination Decode Error" "0: No destination Decode Errors,1: Destination Decode Error Detected"
            newline
            bitfld.quad 0x00 5. "SRC_DEC_ERR_IntStat,Source Decode Error" "0: No Source Decode Errors,1: Source Decode Error detected"
            newline
            bitfld.quad 0x00 4. "DST_TRANSCOMP_IntStat,Destination Transaction Completed" "0: Destination transaction is not complete,1: Destination transaction is complete"
            newline
            bitfld.quad 0x00 3. "SRC_TRANSCOMP_IntStat,Source Transaction Completed" "0: Source transation is not complete,1: Source transaction is complete"
            newline
            bitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTSTATUSREG_2,DMAC Channelx Specific Interrupt Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "DMA_TFR_DONE_IntStat,DMA Transfer Done" "0: DMA Transfer not complete,1: DMA Transfer completed"
            newline
            bitfld.quad 0x00 0. "BLOCK_TFR_DONE_IntStat,Block Transfer Done" "0: Block Transfer not complete,1: Block Transfer completed"

    group.quad 0x290++0x07
        line.quad 0x00 "CH2_INTSIGNAL_ENABLEREG,This register contains fields that are used to enable the generation of port level interrupt at the channel level"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTSIGNAL_ENABLEREG_36to63,DMAC Channelx Interrupt Signal Enable Register (bits 36to63) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 35. "Enable_ECC_PROT_UIDMem_UnCorrERR_IntSignal,Channel x Unique ID Memory Interface ECC Protection Uncorrectable Error Interrupt Signal enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            rbitfld.quad 0x00 34. "Enable_ECC_PROT_UIDMem_CorrERR_IntSignal,Channel x Unique ID Memory Interface ECC Protection Correctable Error Interrupt Signal enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            bitfld.quad 0x00 33. "Enable_ECC_PROT_CHMem_UnCorrERR_IntSignal,Channel x Channel Memory Interface ECC Protection Uncorrectable Error Interrupt Signal enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 32. "Enable_ECC_PROT_CHMem_CorrERR_IntSignal,Channel x Channel Memory Interface ECC Protection Correctable Error Interrupt Signal enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 31. "Enable_CH_ABORTED_IntSignal,Channel Aborted Signal Enable" "0: Disable the propagation of Channel Aborted..,1: Enable the propagation of Channel Aborted.."
            newline
            bitfld.quad 0x00 30. "Enable_CH_DISABLED_IntSignal,Channel Disabled Signal Enable" "0: Disable the propagation of Channel Disabled..,1: Enable the propagation of Channel Disabled.."
            newline
            bitfld.quad 0x00 29. "Enable_CH_SUSPENDED_IntSignal,Channel Suspended Signal Enable" "0: Disable the propagation of Channel Suspended..,1: Enable the propagation of Channel Suspended.."
            newline
            bitfld.quad 0x00 28. "Enable_CH_SRC_SUSPENDED_IntSignal,Channel Source Suspended Signal Enable" "0: Disable the propagation of Channel Source..,1: Enable the propagation of Channel Source.."
            newline
            bitfld.quad 0x00 27. "Enable_CH_LOCK_CLEARED_IntSignal,Channel Lock Cleared Signal Enable" "0: Disable the propagation of Channel Lock..,1: Enable the propagation of Channel Lock.."
            newline
            rbitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTSIGNAL_ENABLEREG_26,DMAC Channelx Interrupt Signal Enable Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "Enable_SLVIF_WRPARITY_ERR_IntSignal,Slave Interface Write Parity Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            rbitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTSIGNAL_ENABLEREG_22to24,DMAC Channelx Interrupt Signal Enable Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "Enable_SLVIF_WRONHOLD_ERR_IntSignal,Slave Interface Write On Hold Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 20. "Enable_SLVIF_SHADOWREG_WRON_VALID_ERR_IntSignal,Shadow Register Write On Valid Error Signal Enable" "0: Disable the propagation of Shadow Register..,1: Enable the propagation of Shadow register.."
            newline
            bitfld.quad 0x00 19. "Enable_SLVIF_WRONCHEN_ERR_IntSignal,Slave Interface Write On Channel Enabled Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 18. "Enable_SLVIF_RD2RWO_ERR_IntSignal,Slave Interface Read to write Only Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 17. "Enable_SLVIF_WR2RO_ERR_IntSignal,Slave Interface Write to Read Only Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 16. "Enable_SLVIF_DEC_ERR_IntSignal,Slave Interface Decode Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            rbitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_15,DMAC Channelx Interrupt Status Enable Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "Enable_SLVIF_MULTIBLKTYPE_ERR_IntSignal,Slave Interface Multi Block type Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 13. "Enable_SHADOWREG_OR_LLI_INVALID_ERR_IntSignal,Shadow register or LLI Invalid Error Signal Enable" "0: Disable the propagation of Shadow Register or..,1: Enable the propagation of Shadow Register or.."
            newline
            bitfld.quad 0x00 12. "Enable_LLI_WR_SLV_ERR_IntSignal,LLI WRITE Slave Error Signal Enable" "0: Disable the propagation of LLI WRITE Slave..,1: Enable the propagation of LLI WRITE Slave.."
            newline
            bitfld.quad 0x00 11. "Enable_LLI_RD_SLV_ERR_IntSignal,LLI Read Slave Error Signal Enable" "0: Disable the propagation of LLI Read Slave..,1: Enable the propagation of LLI Read Slave.."
            newline
            bitfld.quad 0x00 10. "Enable_LLI_WR_DEC_ERR_IntSignal,LLI WRITE Decode Error Signal Enable" "0: Disable the propagation of LLI WRITE Decode..,1: Enable the propagation of LLI WRITE Decode.."
            newline
            bitfld.quad 0x00 9. "Enable_LLI_RD_DEC_ERR_IntSignal,LLI Read Decode Error Signal Enable" "0: Disable the propagation of LLI Read Decode..,1: Enable the propagation of LLI Read Decode.."
            newline
            bitfld.quad 0x00 8. "Enable_DST_SLV_ERR_IntSignal,Destination Slave Error Signal Enable" "0: Disable the propagation of Destination Slave..,1: Enable the propagation of Destination Slave.."
            newline
            bitfld.quad 0x00 7. "Enable_SRC_SLV_ERR_IntSignal,Source Slave Error Signal Enable" "0: Disable the propagation of Source Slave Error..,1: Enable the propagation of Source Slave Error.."
            newline
            bitfld.quad 0x00 6. "Enable_DST_DEC_ERR_IntSignal,Destination Decode Error Signal Enable" "0: Disable the propagation of Destination Decode..,1: Enable the propagation of Destination Decode.."
            newline
            bitfld.quad 0x00 5. "Enable_SRC_DEC_ERR_IntSignal,Source Decode Error Signal Enable" "0: Disable the propagation of Source Decode..,1: Enable the propagation of Source Decode Error.."
            newline
            bitfld.quad 0x00 4. "Enable_DST_TRANSCOMP_IntSignal,Destination Transaction Completed Signal Enable" "0: Disable the propagation of Destination..,1: Enable the propagation of Destination.."
            newline
            bitfld.quad 0x00 3. "Enable_SRC_TRANSCOMP_IntSignal,Source Transaction Completed Signal Enable" "0: Disable the propagation of Source Transaction..,1: Enable the propagation of Source Transaction.."
            newline
            rbitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_2,DMAC Channelx Interrupt Status Enable Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "Enable_DMA_TFR_DONE_IntSignal,DMA Transfer Done Interrupt Signal Enable" "0: Disable the propagation of DMA Transfer Done..,1: Enable the propagation of DMA Transfer Done.."
            newline
            bitfld.quad 0x00 0. "Enable_BLOCK_TFR_DONE_IntSignal,Block Transfer Done Interrupt Signal Enable" "0: Disable the propagation of Block Transfer..,1: Enable the propagation of Block Transfer Done.."

    wgroup.quad 0x298++0x07
        line.quad 0x00 "CH2_INTCLEARREG,Writing 1 to specific field will clear the corresponding field in Channelx Interrupt Status Register(CHx_IntStatusReg)"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTCLEARREG_36to63,DMAC Channelx Interrupt Clear Register (bits 36to63) Reserved bit - Read Only"
            newline
            bitfld.quad 0x00 35. "Clear_ECC_PROT_UIDMem_UnCorrERR_IntStat,ECC Protection Uncorrectable UID Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_UIDMem_UnCorrERR interrupt.."
            newline
            bitfld.quad 0x00 34. "Clear_ECC_PROT_UIDMem_CorrERR_IntStat,ECC Protection Correctable UID Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_UIDMem_CorrERR interrupt.."
            newline
            bitfld.quad 0x00 33. "Clear_ECC_PROT_CHMem_UnCorrERR_IntStat,ECC Protection Uncorrectable Channel Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_CHMem_UnCorrERR interrupt.."
            newline
            bitfld.quad 0x00 32. "Clear_ECC_PROT_CHMem_CorrERR_IntStat,ECC Protection Correctable Channel Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_CHMem_CorrERR interrupt in.."
            newline
            bitfld.quad 0x00 31. "Clear_CH_ABORTED_IntStat,Channel Aborted Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_ABORTED interrupt in the.."
            newline
            bitfld.quad 0x00 30. "Clear_CH_DISABLED_IntStat,Channel Disabled Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_DISABLED interrupt in the.."
            newline
            bitfld.quad 0x00 29. "Clear_CH_SUSPENDED_IntStat,Channel Suspended Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_SUSPENDED interrupt in the.."
            newline
            bitfld.quad 0x00 28. "Clear_CH_SRC_SUSPENDED_IntStat,Channel Source Suspended Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_SRC_SUSPENDED interrupt in the.."
            newline
            bitfld.quad 0x00 27. "Clear_CH_LOCK_CLEARED_IntStat,Channel Lock Cleared Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_LOCK_CLEARED interrupt in the.."
            newline
            bitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTCLEARREG_26,DMAC Channelx Interrupt Clear Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "Clear_SLVIF_WRPARITY_ERR_IntStat,Slave Interface Write Parity Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WRPARITY_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTCLEARREG_22to24,DMAC Channelx Interrupt Clear Register (bits 22to24) Reserved bit - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "Clear_SLVIF_WRONHOLD_ERR_IntStat,Slave Interface Write On Hold Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WRONHOLD_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 20. "Clear_SLVIF_SHADOWREG_WRON_VALID_ERR_IntStat,Shadow Register Write On Valid Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_SHADOWREG_WRON_VALID_ERR.."
            newline
            bitfld.quad 0x00 19. "Clear_SLVIF_WRONCHEN_ERR_IntStat,Slave Interface Write On Channel Enabled Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WRONCHEN_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 18. "Clear_SLVIF_RD2RWO_ERR_IntStat,Slave Interface Read to write Only Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_RD2RWO_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 17. "Clear_SLVIF_WR2RO_ERR_IntStat,Slave Interface Write to Read Only Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WR2RO_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 16. "Clear_SLVIF_DEC_ERR_IntStat,Slave Interface Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTCLEARREG_15,DMAC Channelx Interrupt Clear Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "Clear_SLVIF_MULTIBLKTYPE_ERR_IntStat,Slave Interface Multi Block type Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_MULTIBLKTYPE_ERR interrupt in.."
            newline
            bitfld.quad 0x00 13. "Clear_SHADOWREG_OR_LLI_INVALID_ERR_IntStat,Shadow register or LLI Invalid Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SHADOWREG_OR_LLI_INVALID_ERR.."
            newline
            bitfld.quad 0x00 12. "Clear_LLI_WR_SLV_ERR_IntStat,LLI WRITE Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_WR_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 11. "Clear_LLI_RD_SLV_ERR_IntStat,LLI Read Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_RD_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 10. "Clear_LLI_WR_DEC_ERR_IntStat,LLI WRITE Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_WR_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 9. "Clear_LLI_RD_DEC_ERR_IntStat,LLI Read Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_RD_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 8. "Clear_DST_SLV_ERR_IntStat,Destination Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the DST_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 7. "Clear_SRC_SLV_ERR_IntStat,Source Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SRC_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 6. "Clear_DST_DEC_ERR_IntStat,Destination Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the DST_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 5. "Clear_SRC_DEC_ERR_IntStat,Source Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SRC_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 4. "Clear_DST_TRANSCOMP_IntStat,Destination Transaction Completed Interrupt Clear Bit" "0: Inactive signal,1: Clear the DST_TRANSCOMP interrupt in the.."
            newline
            bitfld.quad 0x00 3. "Clear_SRC_TRANSCOMP_IntStat,Source Transaction Completed Interrupt Clear Bit" "0: Inactive signal,1: Clear the SRC_TRANSCOMP interrupt in the.."
            newline
            bitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTCLEARREG_2,DMAC Channelx Interrupt Clear Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "Clear_DMA_TFR_DONE_IntStat,DMA Transfer Done Interrupt Clear Bit" "0: Inactive signal,1: Clear the DMA_TFR_DONE interrupt in the.."
            newline
            bitfld.quad 0x00 0. "Clear_BLOCK_TFR_DONE_IntStat,Block Transfer Done Interrupt Clear Bit" "0: Inactive signal,1: Clear the interrupt in the Interrupt Status.."

    group.quad 0x300++0x07
        line.quad 0x00 "CH3_SAR,The starting source address is programmed by software before the DMA channel is enabled or by an LLI update before the start of the DMA transfer"
            hexmask.quad 0x00 0.--63. 1. "SAR,Current Source Address of DMA transfer"
    group.quad 0x308++0x07
        line.quad 0x00 "CH3_DAR,The starting destination address is programmed by the software before the DMA channel is enabled or by an LLI update before the start of the DMA transfer"
            hexmask.quad 0x00 0.--63. 1. "DAR,Current Destination Address of DMA transfer"
    group.quad 0x310++0x07
        line.quad 0x00 "CH3_BLOCK_TS,When DW_axi_dmac is the flow controller the DMAC uses this register before the channel is enabled for block-size"
            hexmask.quad.quad 0x00 22.--63. 1. "RSVD_DMAC_CHx_BLOCK_TSREG_63to22,DMAC Channelx Block Transfer Size Register (bits 63to22) Reserved bits - Read Only"
            newline
            hexmask.quad.tbyte 0x00 0.--21. 1. "BLOCK_TS,Block Transfer Size"
    group.quad 0x318++0x07
        line.quad 0x00 "CH3_CTL,This register contains fields that control the DMA transfer"
            bitfld.quad 0x00 63. "SHADOWREG_OR_LLI_VALID,Shadow Register content/Linked List Item valid" "0: Indicates shadowreg/LLI content is Invalid,1: Indicates shadowreg/LLI content is Valid"
            newline
            bitfld.quad 0x00 62. "SHADOWREG_OR_LLI_LAST,Last Shadow Register/Linked List Item" "0: Indicates shadowreg/LLI content is not the..,1: Indicates shadowreg/LLI content is the last one"
            newline
            rbitfld.quad 0x00 59.--61. "RSVD_DMAC_CHx_CTL_59to61,DMAC Channelx Control Transfer Register (bits 59to61) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 58. "IOC_BlkTfr,Interrupt On completion of Block Transfer This bit is used to control the block transfer completion interrupt generation on a block by block basis for shadow register or linked list based multi-block transfers" "0: Disables..,1: Enables.."
            newline
            rbitfld.quad 0x00 57. "DST_STAT_EN,Destination Status Enable Enable the logic to fetch status from destination peripheral of channel x pointed to by the content of CHx_DSTATAR register and stores it in CHx_DSTAT register" "0: No status fetch for Destination device,1: Enables status fetch for Destination and.."
            newline
            rbitfld.quad 0x00 56. "SRC_STAT_EN,Source Status Enable Enable the logic to fetch status from source peripheral of channel x pointed to by the content of CHx_SSTATAR register and stores it in CHx_SSTAT register" "0: No status fetch for Source device,1: Enables status fetch for Source and store the.."
            newline
            hexmask.quad.byte 0x00 48.--55. 1. "AWLEN,Destination Burst Length AXI Burst length used for destination data transfer"
            newline
            bitfld.quad 0x00 47. "AWLEN_EN,Destination Burst Length Enable If this bit is set to 1 DW_axi_dmac uses the value of CHx_CTL.AWLEN as AXI Burst length for destination data transfer till the extent possible remaining transfers use maximum possible burst length" "0: AXI Burst Length is any possible value <=..,1: AXI Burst Length is CH3_CTL.AWLEN (till the.."
            newline
            hexmask.quad.byte 0x00 39.--46. 1. "ARLEN,Source Burst Length AXI Burst length used for source data transfer"
            newline
            bitfld.quad 0x00 38. "ARLEN_EN,Source Burst Length Enable If this bit is set to 1 DW_axi_dmac uses the value of CHx_CTL.ARLEN as AXI Burst length for source data transfer till the extent possible remaining transfers use maximum possible burst length" "0: AXI Burst Length is any possible value <=..,1: AXI Burst Length is CH3_CTL.ARLEN (till the.."
            newline
            bitfld.quad 0x00 35.--37. "AW_PROT,AXI 'aw_prot' signal" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 32.--34. "AR_PROT,AXI 'ar_prot' signal" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 31. "RSVD_DMAC_CHx_CTL_31,DMAC Channelx Control Transfer Register bit31 Reserved bits - Read Only" "0,1"
            newline
            bitfld.quad 0x00 30. "NonPosted_LastWrite_En,Non Posted Last Write Enable This bit decides whether posted writes can be used throughout the block transfer" "0: Posted writes may be used throughout the..,1: Last write in the block must be non-posted"
            newline
            bitfld.quad 0x00 26.--29. "AW_CACHE,AXI 'aw_cache' signal" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 22.--25. "AR_CACHE,AXI 'ar_cache' signal" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 18.--21. "DST_MSIZE,Destination Burst Transaction Length" "0: 1 Data Item read from Destination in the..,1: 4 Data Item read from Destination in the..,2: 8 Data Item read from Destination in the..,3: 16 Data Item read from Destination in the..,4: 32 Data Item read from Destination in the..,5: 64 Data Item read from Destination in the..,6: 128 Data Item read from Destination in the..,7: 256 Data Item read from Destination in the..,8: 512 Data Item read from Destination in the..,9: 1024 Data Item read from Destination in the..,?..."
            newline
            bitfld.quad 0x00 14.--17. "SRC_MSIZE,Source Burst Transaction Length" "0: 1 Data Item read from Source in the burst..,1: 4 Data Item read from Source in the burst..,2: 8 Data Item read from Source in the burst..,3: 16 Data Item read from Source in the burst..,4: 32 Data Item read from Source in the burst..,5: 64 Data Item read from Source in the burst..,6: 128 Data Item read from Source in the burst..,7: 256 Data Item read from Source in the burst..,8: 512 Data Item read from Source in the burst..,9: 1024 Data Item read from Source in the burst..,?..."
            newline
            bitfld.quad 0x00 11.--13. "DST_TR_WIDTH,Destination Transfer Width" "0: Destination Transfer Width is 8 bits,1: Destination Transfer Width is 16 bits,2: Destination Transfer Width is 32 bits,3: Destination Transfer Width is 64 bits,4: Destination Transfer Width is 128 bits,5: Destination Transfer Width is 256 bits,6: Destination Transfer Width is 512 bits,?..."
            newline
            bitfld.quad 0x00 8.--10. "SRC_TR_WIDTH,Source Transfer Width" "0: Source Transfer Width is 8 bits,1: Source Transfer Width is 16 bits,2: Source Transfer Width is 32 bits,3: Source Transfer Width is 64 bits,4: Source Transfer Width is 128 bits,5: Source Transfer Width is 256 bits,6: Source Transfer Width is 512 bits,?..."
            newline
            rbitfld.quad 0x00 7. "RSVD_DMAC_CHx_CTL_7,DMAC Channelx Control Transfer Register bit7 Reserved bits - Read Only" "0,1"
            newline
            bitfld.quad 0x00 6. "DINC,Destination Address Increment" "0: Destination address incremented on every..,1: Destination address is fixed"
            newline
            rbitfld.quad 0x00 5. "RSVD_DMAC_CHx_CTL_5,DMAC Channelx Control Transfer Register bit5 Reserved bits - Read Only" "0,1"
            newline
            bitfld.quad 0x00 4. "SINC,Source Address Increment" "0: Source address incremented on every source..,1: Source address is fixed"
            newline
            rbitfld.quad 0x00 3. "RSVD_DMAC_CHx_CTL_3,DMAC Channelx Control Transfer Register bit3 Reserved bits - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 2. "DMS,Destination Master Select" "0: Destination device on Master-1 interface layer,1: Destination device on Master-2 interface layer"
            newline
            rbitfld.quad 0x00 1. "RSVD_DMAC_CHx_CTL_1,DMAC Channelx Control Transfer Register bit1 Reserved bits - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 0. "SMS,Source Master Select" "0: Source device on Master-1 interface layer,1: Source device on Master-2 interface layer"
    group.quad 0x320++0x07
        line.quad 0x00 "CH3_CFG,This register contains fields that configure the DMA transfer"
            rbitfld.quad 0x00 63. "RSVD_DMAC_CHx_CFG_63,DMAC Channelx Transfer Configuration Register (63bit) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 59.--62. "DST_OSR_LMT,Destination Outstanding Request Limit - Maximum outstanding request supported is 16" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 55.--58. "SRC_OSR_LMT,Source Outstanding Request Limit - Maximum outstanding request supported is 16" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.quad 0x00 53.--54. "LOCK_CH_L,Channel Lock Level This bit indicates the duration over which CHx_CFG.LOCK_CH bit applies" "0: Duration of the Channel locking is for the..,1: Duration of the Channel locking is for the..,?..."
            newline
            rbitfld.quad 0x00 52. "LOCK_CH,Channel Lock bit When the channel is granted control of the master bus interface and if the CHx_CFG.LOCK_CH bit is asserted then no other channels are granted control of the master bus interface for the duration specified in CHx_CFG.LOCK_CH_L" "0: Channel is not locked during the transfers,1: Channel is locked and granted exclusive.."
            newline
            bitfld.quad 0x00 49.--51. "CH_PRIOR,Channel Priority A priority of DMAX_NUM_CHANNELS-1 is the highest priority and 0 is the lowest" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 48. "RSVD_DMAC_CHx_CFG_48,DMAC Channelx Transfer Configuration Register (48bit) Reserved bit - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 46.--47. "RSVD_DMAC_CHx_CFG_47_44,DMAC Channelx Transfer Configuration Register (bits (LOG2_DMAX_NUM_HS_IF+44) to 47) Reserved bits - Read Only" "0,1,2,3"
            newline
            bitfld.quad 0x00 44.--45. "DST_PER,Assigns a hardware handshaking interface (0 - DMAX_NUM_HS_IF-1) to the destination of Channelx if the CHx_CFG.HS_SEL_DST field is 0 otherwise this field is ignored" "0,1,2,3"
            newline
            rbitfld.quad 0x00 43. "RSVD_DMAC_CHx_CFG_43,DMAC Channelx Transfer Configuration Register (43bit) Reserved bit - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 41.--42. "RSVD_DMAC_CHx_CFG_42_39,DMAC Channelx Transfer Configuration Register (bits (LOG2_DMAX_NUM_HS_IF+39) to 42) Reserved bits - Read Only" "0,1,2,3"
            newline
            bitfld.quad 0x00 39.--40. "SRC_PER,Assigns a hardware handshaking interface (0 - DMAX_NUM_HS_IF-1) to the source of Channelx if the CHx_CFG.HS_SEL_SRC field is 0 otherwise this field is ignored" "0,1,2,3"
            newline
            rbitfld.quad 0x00 38. "DST_HWHS_POL,Destination Hardware Handshaking Interface Polarity" "0: Polarity of the Handshaking Interface used..,1: Polarity of the Handshaking Interface used.."
            newline
            rbitfld.quad 0x00 37. "SRC_HWHS_POL,Source Hardware Handshaking Interface Polarity" "0: Polarity of the Handshaking Interface used..,1: Polarity of the Handshaking Interface used.."
            newline
            bitfld.quad 0x00 36. "HS_SEL_DST,Destination Software or Hardware Handshaking Select" "0: Hardware Handshaking Interface is used for..,1: Software Handshaking Interface is used for.."
            newline
            bitfld.quad 0x00 35. "HS_SEL_SRC,Source Software or Hardware Handshaking Select" "0: Hardware Handshaking Interface is used for..,1: Software Handshaking Interface is used for.."
            newline
            bitfld.quad 0x00 32.--34. "TT_FC,Transfer Type and Flow Control" "0: Transfer Type is memory to memory and Flow..,1: Transfer Type is memory to peripheral and..,2: Transfer Type is peripheral to memory and..,3: Transfer Type is peripheral to peripheral and..,4: Transfer Type is peripheral to Memory and..,5: Transfer Type is peripheral to peripheral and..,6: Transfer Type is memory to peripheral and..,7: Transfer Type is peripheral to peripheral and.."
            newline
            rbitfld.quad 0x00 29.--31. "RSVD_DMAC_CHx_CFG_29to31,DMAC Channelx Transfer Configuration Register (bits 29to31) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 25.--28. "WR_UID,Defines the number of AXI Unique ID's supported for the AXI Write Channel" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_CFG_22to24,DMAC Channelx Transfer Configuration Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 18.--21. "RD_UID,Defines the number of AXI Unique ID's supported for the AXI Read Channel" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.quad.word 0x00 4.--17. 1. "RSVD_DMAC_CHx_CFG_4to17,DMAC Channelx Transfer Configuration Register (bits 4to17) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 2.--3. "DST_MULTBLK_TYPE,Destination Multi Block Transfer Type" "0: Contiguous Multiblock Type used for..,1: Reload Multiblock Type used for Destination..,2: Shadow Register based Multiblock Type used..,3: Linked List based Multiblock Type used for.."
            newline
            rbitfld.quad 0x00 0.--1. "SRC_MULTBLK_TYPE,Source Multi Block Transfer Type" "0: Contiguous Multiblock Type used for Source..,1: Reload Multiblock Type used for Source Transfer,2: Shadow Register based Multiblock Type used..,3: Linked List based Multiblock Type used for.."
    group.quad 0x328++0x07
        line.quad 0x00 "CH3_LLP,This is the Linked List Pointer register"
            hexmask.quad 0x00 6.--63. 1. "LOC,Starting Address Memory of LLI block Starting Address In Memory of next LLI if block chaining is enabled"
            newline
            rbitfld.quad 0x00 1.--5. "RSVD_DMAC_CHx_LLP_1to5,DMAC Channelx Linked List Pointer Register (bits 1to5) Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            rbitfld.quad 0x00 0. "LMS,LLI master Select This bit identifies the AXI layer/interface where the memory device that stores the next linked list item resides" "0: next Linked List item resides on AXI Master1..,1: next Linked List item resides on AXI Master2.."

    rgroup.quad 0x330++0x07
        line.quad 0x00 "CH3_STATUSREG,Channelx Status Register contains fields that indicate the status of DMA transfers for Channelx"
            hexmask.quad.tbyte 0x00 47.--63. 1. "RSVD_DMAC_CHx_STATUSREG_47to63,DMAC Channelx Status Register (bits 47to63) Reserved bits - Read Only"
            newline
            hexmask.quad.word 0x00 32.--46. 1. "DATA_LEFT_IN_FIFO,Data Left in FIFO"
            newline
            hexmask.quad.word 0x00 22.--31. 1. "RSVD_DMAC_CHx_STATUSREG_22to31,DMAC Channelx Status Register (bits 22to31) Reserved bits - Read Only"
            newline
            hexmask.quad.tbyte 0x00 0.--21. 1. "CMPLTD_BLK_TFR_SIZE,Completed Block Transfer Size"

    group.quad 0x338++0x07
        line.quad 0x00 "CH3_SWHSSRCREG,Channelx Software handshake Source Register"
            hexmask.quad 0x00 6.--63. 1. "RSVD_DMAC_CHx_SWHSSRCREG_6to63,DMAC Channelx Software Handshake Source Register (bits 6to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 5. "SWHS_LST_SRC_WE,Write Enable bit for Software Handshake Last Request for Channel Source" "0: Disables write to the SWHS_LAST_SRC bit,1: Enables write to the SWHS_LAST_SRC bit"
            newline
            bitfld.quad 0x00 4. "SWHS_LST_SRC,Software Handshake Last Request for Channel Source" "0: Source peripheral indication that the curent..,1: Source peripheral indication to dmac that the.."
            newline
            bitfld.quad 0x00 3. "SWHS_SGLREQ_SRC_WE,Write Enable bit for Software Handshake Single Request for Channel Source" "0: Disables write to the SWHS_SGLREQ_SRC bit,1: Enables write to the SWHS_SGLREQ_SRC bit"
            newline
            bitfld.quad 0x00 2. "SWHS_SGLREQ_SRC,Software Handshake Single Request for Channel Source" "0: Source peripheral is not requesting for a..,1: Source peripheral request for a single dma.."
            newline
            bitfld.quad 0x00 1. "SWHS_REQ_SRC_WE,Write Enable bit for Software Handshake Request for Channel Source" "0: Disables write to the SWHS_REQ_SRC bit,1: Enables write to the SWHS_REQ_SRC bit"
            newline
            bitfld.quad 0x00 0. "SWHS_REQ_SRC,Software Handshake Request for Channel Source" "0: Source peripheral is not requesting for a..,1: Source peripheral request for a dma transfer"
    group.quad 0x340++0x07
        line.quad 0x00 "CH3_SWHSDSTREG,Channelx Software handshake Destination Register"
            hexmask.quad 0x00 6.--63. 1. "RSVD_DMAC_CHx_SWHSDSTREG_6to63,DMAC Channelx Software Handshake Destination Register (bits 6to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 5. "SWHS_LST_DST_WE,Write Enable bit for Software Handshake Last Request for Channel Destination" "0: Disables write to the SWHS_LAST_DST bit,1: Enables write to the SWHS_LAST_DST bit"
            newline
            bitfld.quad 0x00 4. "SWHS_LST_DST,Software Handshake Last Request for Channel Destination" "0: Destination peripheral indication that the..,1: Destination peripheral indication to dmac.."
            newline
            bitfld.quad 0x00 3. "SWHS_SGLREQ_DST_WE,Write Enable bit for Software Handshake Single Request for Channel Destination" "0: Disables write to the SWHS_SGLREQ_DST bit,1: Enables write to the SWHS_SGLREQ_DST bit"
            newline
            bitfld.quad 0x00 2. "SWHS_SGLREQ_DST,Software Handshake Single Request for Channel Destination" "0: Destination peripheral is not requesting for..,1: Destination peripheral request for a single.."
            newline
            bitfld.quad 0x00 1. "SWHS_REQ_DST_WE,Write Enable bit for Software Handshake Request for Channel Destination" "0: Disables write to the SWHS_REQ_DST bit,1: Enables write to the SWHS_REQ_DST bit"
            newline
            bitfld.quad 0x00 0. "SWHS_REQ_DST,Software Handshake Request for Channel Destination" "0: Destination peripheral is not requesting for..,1: Destination peripheral request for a dma.."

    wgroup.quad 0x348++0x07
        line.quad 0x00 "CH3_BLK_TFR_RESUMEREQREG,Channelx Block Transfer Resume Request Register"
            hexmask.quad 0x00 1.--63. 1. "RSVD_DMAC_CHx_BLK_TFR_RESUMEREQREG_1to63,DMAC Channelx Block Transfer Resume Request Register (bits 1to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 0. "BLK_TFR_RESUMEREQ,Block Transfer Resume Request during Linked-List or Shadow-Register-based multi-block transfer" "0: No request to resume the block transfer,1: Request for resuming the block transfer"

    group.quad 0x350++0x07
        line.quad 0x00 "CH3_AXI_IDREG,Channelx AXI ID Register"
            hexmask.quad.long 0x00 32.--63. 1. "RSVD_DMAC_CHx_AXI_IDREG_32to63,DMAC Channelx AXI ID Register (bits 32to63) Reserved bits - Read Only"
            newline
            hexmask.quad.word 0x00 18.--31. 1. "RSVD_DMAC_CHx_AXI_IDREG_IDW_L2NCm32to63,DMAC Channelx AXI ID Register (bits (IDW-L2NC-1)to32) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 16.--17. "AXI_WRITE_ID_SUFFIX,AXI Write ID Suffix" "0,1,2,3"
            newline
            hexmask.quad.word 0x00 2.--15. 1. "RSVD_DMAC_CHx_AXI_IDREG_IDW_L2NCm1to31,DMAC Channelx AXI ID Register (bits (IDW-L2NC-1)to31) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 0.--1. "AXI_READ_ID_SUFFIX,AXI Read ID Suffix These bits form part of the ARID output of AXI3/AXI4 master interface" "0,1,2,3"
    group.quad 0x358++0x07
        line.quad 0x00 "CH3_AXI_QOSREG,Channelx AXI QOS Register"
            hexmask.quad.quad 0x00 8.--63. 1. "RSVD_DMAC_CHx_AXI_QOSREG_8to63,DMAC Channelx AXI QOS Register (bits 8to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 4.--7. "AXI_ARQOS,AXI ARQOS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 0.--3. "AXI_AWQOS,AXI AWQOS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.quad 0x380++0x07
        line.quad 0x00 "CH3_INTSTATUS_ENABLEREG,Writing 1 to specific field enables the corresponding interrupt status generation in Channelx Interrupt Status Register(CH3_IntStatusReg)"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_32to63,DMAC Channelx Interrupt Status Enable Register (bits 32to63) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 35. "Enable_ECC_PROT_UIDMem_UnCorrERR_IntStat,Channel x Unique ID Memory Interface ECC Protection Uncorrectable Error Interrupt enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            rbitfld.quad 0x00 34. "Enable_ECC_PROT_UIDMem_CorrERR_IntStat,Channel x Unique ID Memory Interface ECC Protection Correctable Error Interrupt enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            bitfld.quad 0x00 33. "Enable_ECC_PROT_CHMem_UnCorrERR_IntStat,Channel x Channel Memory Interface ECC Protection Uncorrectable Error Interrupt enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 32. "Enable_ECC_PROT_CHMem_CorrERR_IntStat,Channel x Channel Memory Interface ECC Protection Correctable Error Interrupt enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 31. "Enable_CH_ABORTED_IntStat,Channel Aborted Status Enable" "0: Disable the generation of Channel Aborted..,1: Enable the generation of Channel Aborted.."
            newline
            bitfld.quad 0x00 30. "Enable_CH_DISABLED_IntStat,Channel Disabled Status Enable" "0: Disable the generation of Channel Disabled..,1: Enable the generation of Channel Disabled.."
            newline
            bitfld.quad 0x00 29. "Enable_CH_SUSPENDED_IntStat,Channel Suspended Status Enable" "0: Disable the generation of Channel Suspended..,1: Enable the generation of Channel Suspended.."
            newline
            bitfld.quad 0x00 28. "Enable_CH_SRC_SUSPENDED_IntStat,Channel Source Suspended Status Enable" "0: Disable the generation of Channel Source..,1: Enable the generation of Channel Source.."
            newline
            bitfld.quad 0x00 27. "Enable_CH_LOCK_CLEARED_IntStat,Channel Lock Cleared Status Enable" "0: Disable the generation of Channel LOCK..,1: Enable the generation of Channel LOCK CLEARED.."
            newline
            rbitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_26,DMAC Channelx Interrupt Status Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "Enable_SLVIF_WRPARITY_ERR_IntStat,Slave Interface Write Parity Error Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            rbitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_22to24,DMAC Channelx Interrupt Status Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "Enable_SLVIF_WRONHOLD_ERR_IntStat,Slave Interface Write On Hold Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 20. "Enable_SLVIF_SHADOWREG_WRON_VALID_ERR_IntStat,Shadow Register Write On Valid Error Status Enable" "0: Disable the generation of Shadow Register..,1: Enable the generation of Shadow register.."
            newline
            bitfld.quad 0x00 19. "Enable_SLVIF_WRONCHEN_ERR_IntStat,Slave Interface Write On Channel Enabled Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 18. "Enable_SLVIF_RD2RWO_ERR_IntStat,Slave Interface Read to write Only Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface Read.."
            newline
            bitfld.quad 0x00 17. "Enable_SLVIF_WR2RO_ERR_IntStat,Slave Interface Write to Read Only Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 16. "Enable_SLVIF_DEC_ERR_IntStat,Slave Interface Decode Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            rbitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_15,DMAC Channelx Interrupt Status Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "Enable_SLVIF_MULTIBLKTYPE_ERR_IntStat,Slave Interface Multi Block type Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 13. "Enable_SHADOWREG_OR_LLI_INVALID_ERR_IntStat,Shadow register or LLI Invalid Error Status Enable" "0: Disable the generation of Shadow Register or..,1: Enable the generation of Shadow Register or.."
            newline
            bitfld.quad 0x00 12. "Enable_LLI_WR_SLV_ERR_IntStat,LLI WRITE Slave Error Status Enable" "0: Disable the generation of LLI WRITE Slave..,1: Enable the generation of LLI WRITE Slave.."
            newline
            bitfld.quad 0x00 11. "Enable_LLI_RD_SLV_ERR_IntStat,LLI Read Slave Error Status Enable" "0: Disable the generation of LLI Read Slave..,1: Enable the generation of LLI Read Slave Error.."
            newline
            bitfld.quad 0x00 10. "Enable_LLI_WR_DEC_ERR_IntStat,LLI WRITE Decode Error Status Enable" "0: Disable the generation of LLI WRITE Decode..,1: Enable the generation of LLI WRITE Decode.."
            newline
            bitfld.quad 0x00 9. "Enable_LLI_RD_DEC_ERR_IntStat,LLI Read Decode Error Status Enable" "0: Disable the generation of LLI Read Decode..,1: Enable the generation of LLI Read Decode.."
            newline
            bitfld.quad 0x00 8. "Enable_DST_SLV_ERR_IntStat,Destination Slave Error Status Enable" "0: Disable the generation of Destination Slave..,1: Enable the generation of Destination Slave.."
            newline
            bitfld.quad 0x00 7. "Enable_SRC_SLV_ERR_IntStat,Source Slave Error Status Enable" "0: Disable the generation of Source Slave Error..,1: Enable the generation of Source Slave Error.."
            newline
            bitfld.quad 0x00 6. "Enable_DST_DEC_ERR_IntStat,Destination Decode Error Status Enable" "0: Disable the generation of Destination Decode..,1: Enable the generation of Destination Decode.."
            newline
            bitfld.quad 0x00 5. "Enable_SRC_DEC_ERR_IntStat,Source Decode Error Status Enable" "0: Disable the generation of Source Decode Error..,1: Enable the generation of Source Decode Error.."
            newline
            bitfld.quad 0x00 4. "Enable_DST_TRANSCOMP_IntStat,Destination Transaction Completed Status Enable" "0: Disable the generation of Destination..,1: Enable the generation of Destination.."
            newline
            bitfld.quad 0x00 3. "Enable_SRC_TRANSCOMP_IntStat,Source Transaction Completed Status Enable" "0: Disable the generation of Source Transaction..,1: Enable the generation of Source Transaction.."
            newline
            rbitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_2,DMAC Channelx Interrupt Status Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "Enable_DMA_TFR_DONE_IntStat,DMA Transfer Done Interrupt Status Enable" "0: Disable the generation of DMA Transfer Done..,1: Enable the generation of DMA Transfer Done.."
            newline
            bitfld.quad 0x00 0. "Enable_BLOCK_TFR_DONE_IntStat,Block Transfer Done Interrupt Status Enable" "0: Disable the generation of Block Transfer Done..,1: Enable the generation of Block Transfer Done.."

    rgroup.quad 0x388++0x07
        line.quad 0x00 "CH3_INTSTATUS,Channelx Interrupt Status Register captures the Channelx specific interrupts"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTSTATUSREG_36to63,DMAC Channelx Specific Interrupt Register (bits 36to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 35. "ECC_PROT_UIDMem_UnCorrERR_IntStat,Channel x UID Memory Interface ECC Protection related Uncorrectable Error Interrupt Status bit" "0: Channel x UID Memory Interface Uncorrectable..,1: Channel x UID Memory Interface Uncorrectable.."
            newline
            bitfld.quad 0x00 34. "ECC_PROT_UIDMem_CorrERR_IntStat,Channel x UID Memory Interface ECC Protection related Correctable Error Interrupt Status bit" "0: Channel x UID Memory Interface correctable..,1: Channel x UID Memory Interface correctable.."
            newline
            bitfld.quad 0x00 33. "ECC_PROT_CHMem_UnCorrERR_IntStat,Channel x FIFO Memory Interface ECC Protection related Uncorrectable Error Interrupt Status bit" "0: Channel x FIFO Memory Interface Uncorrectable..,1: Channel x FIFO Memory Interface Uncorrectable.."
            newline
            bitfld.quad 0x00 32. "ECC_PROT_CHMem_CorrERR_IntStat,Channel x FIFO Memory Interface ECC Protection related Correctable Error Interrupt Status bit" "0: Channel x FIFO Memory Interface correctable..,1: Channel x FIFO Memory Interface correctable.."
            newline
            bitfld.quad 0x00 31. "CH_ABORTED_IntStat,Channel Aborted" "0: Channel is not aborted,1: Channel is aborted"
            newline
            bitfld.quad 0x00 30. "CH_DISABLED_IntStat,Channel Disabled" "0: Channel is not disabled,1: Channel is disabled"
            newline
            bitfld.quad 0x00 29. "CH_SUSPENDED_IntStat,Channel Suspended" "0: Channel is not suspended,1: Channel is suspended"
            newline
            bitfld.quad 0x00 28. "CH_SRC_SUSPENDED_IntStat,Channel Source Suspended" "0: Channel source is not suspended,1: Channel Source is suspended"
            newline
            bitfld.quad 0x00 27. "CH_LOCK_CLEARED_IntStat,Channel Lock Cleared" "0: Channel locking is not cleared if present,1: Channel Locking is cleared"
            newline
            bitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTSTATUSREG_26,DMAC Channelx Specific Interrupt Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "SLVIF_WRPARITY_ERR_IntStat,Slave Interface Write Parity Error" "0: No Slave Interface Write Parity Errors,1: Slave Interface Write Parity Error detected"
            newline
            bitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTSTATUSREG_22to24,DMAC Channelx Specific Interrupt Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "SLVIF_WRONHOLD_ERR_IntStat,Slave Interface Write On Hold Error" "0: No Slave Interface Write On Hold Errors,1: Slave Interface Write On Hold Error detected"
            newline
            bitfld.quad 0x00 20. "SLVIF_SHADOWREG_WRON_VALID_ERR_IntStat,Shadow Register Write On Valid Error" "0: No Slave Interface Shadow Register Write On..,1: Slave Interface Shadow Register Write On.."
            newline
            bitfld.quad 0x00 19. "SLVIF_WRONCHEN_ERR_IntStat,Slave Interface Write On Channel Enabled Error" "0: No Slave Interface Write On Channel Enabled..,1: Slave Interface Write On Channel Enabled.."
            newline
            bitfld.quad 0x00 18. "SLVIF_RD2RWO_ERR_IntStat,Slave Interface Read to write Only Error" "0: No Slave Interface Read to Write Only Errors,1: Slave Interface Read to Write Only Error.."
            newline
            bitfld.quad 0x00 17. "SLVIF_WR2RO_ERR_IntStat,Slave Interface Write to Read Only Error" "0: No Slave Interface Write to Read Only Errors,1: Slave Interface Write to Read Only Error.."
            newline
            bitfld.quad 0x00 16. "SLVIF_DEC_ERR_IntStat,Slave Interface Decode Error" "0: No Slave Interface Decode errors,1: Slave Interface Decode Error detected"
            newline
            bitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTSTATUSREG_15,DMAC Channelx Specific Interrupt Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "SLVIF_MULTIBLKTYPE_ERR_IntStat,Slave Interface Multi Block type Error" "0: No Multi-block transfer type Errors,1: Multi-block transfer type Error detected"
            newline
            bitfld.quad 0x00 13. "SHADOWREG_OR_LLI_INVALID_ERR_IntStat,Shadow register or LLI Invalid Error" "0: No Shadow Register / LLI Invalid errors,1: Shadow Register / LLI Invalid error detected"
            newline
            bitfld.quad 0x00 12. "LLI_WR_SLV_ERR_IntStat,LLI WRITE Slave Error" "0: No LLI write Slave Errors,1: LLI Write SLAVE Error detected"
            newline
            bitfld.quad 0x00 11. "LLI_RD_SLV_ERR_IntStat,LLI Read Slave Error" "0: No LLI Read Slave Errors,1: LLI read Slave Error detected"
            newline
            bitfld.quad 0x00 10. "LLI_WR_DEC_ERR_IntStat,LLI WRITE Decode Error" "0: NO LLI Write Decode Errors,1: LLI write Decode Error detected"
            newline
            bitfld.quad 0x00 9. "LLI_RD_DEC_ERR_IntStat,LLI Read Decode Error" "0: NO LLI Read Decode Errors,1: LLI Read Decode Error detected"
            newline
            bitfld.quad 0x00 8. "DST_SLV_ERR_IntStat,Destination Slave Error" "0: No Destination Slave Errors,1: Destination Slave Errors Detected"
            newline
            bitfld.quad 0x00 7. "SRC_SLV_ERR_IntStat,Source Slave Error" "0: No Source Slave Errors,1: Source Slave Error Detected"
            newline
            bitfld.quad 0x00 6. "DST_DEC_ERR_IntStat,Destination Decode Error" "0: No destination Decode Errors,1: Destination Decode Error Detected"
            newline
            bitfld.quad 0x00 5. "SRC_DEC_ERR_IntStat,Source Decode Error" "0: No Source Decode Errors,1: Source Decode Error detected"
            newline
            bitfld.quad 0x00 4. "DST_TRANSCOMP_IntStat,Destination Transaction Completed" "0: Destination transaction is not complete,1: Destination transaction is complete"
            newline
            bitfld.quad 0x00 3. "SRC_TRANSCOMP_IntStat,Source Transaction Completed" "0: Source transation is not complete,1: Source transaction is complete"
            newline
            bitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTSTATUSREG_2,DMAC Channelx Specific Interrupt Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "DMA_TFR_DONE_IntStat,DMA Transfer Done" "0: DMA Transfer not complete,1: DMA Transfer completed"
            newline
            bitfld.quad 0x00 0. "BLOCK_TFR_DONE_IntStat,Block Transfer Done" "0: Block Transfer not complete,1: Block Transfer completed"

    group.quad 0x390++0x07
        line.quad 0x00 "CH3_INTSIGNAL_ENABLEREG,This register contains fields that are used to enable the generation of port level interrupt at the channel level"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTSIGNAL_ENABLEREG_36to63,DMAC Channelx Interrupt Signal Enable Register (bits 36to63) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 35. "Enable_ECC_PROT_UIDMem_UnCorrERR_IntSignal,Channel x Unique ID Memory Interface ECC Protection Uncorrectable Error Interrupt Signal enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            rbitfld.quad 0x00 34. "Enable_ECC_PROT_UIDMem_CorrERR_IntSignal,Channel x Unique ID Memory Interface ECC Protection Correctable Error Interrupt Signal enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            bitfld.quad 0x00 33. "Enable_ECC_PROT_CHMem_UnCorrERR_IntSignal,Channel x Channel Memory Interface ECC Protection Uncorrectable Error Interrupt Signal enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 32. "Enable_ECC_PROT_CHMem_CorrERR_IntSignal,Channel x Channel Memory Interface ECC Protection Correctable Error Interrupt Signal enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 31. "Enable_CH_ABORTED_IntSignal,Channel Aborted Signal Enable" "0: Disable the propagation of Channel Aborted..,1: Enable the propagation of Channel Aborted.."
            newline
            bitfld.quad 0x00 30. "Enable_CH_DISABLED_IntSignal,Channel Disabled Signal Enable" "0: Disable the propagation of Channel Disabled..,1: Enable the propagation of Channel Disabled.."
            newline
            bitfld.quad 0x00 29. "Enable_CH_SUSPENDED_IntSignal,Channel Suspended Signal Enable" "0: Disable the propagation of Channel Suspended..,1: Enable the propagation of Channel Suspended.."
            newline
            bitfld.quad 0x00 28. "Enable_CH_SRC_SUSPENDED_IntSignal,Channel Source Suspended Signal Enable" "0: Disable the propagation of Channel Source..,1: Enable the propagation of Channel Source.."
            newline
            bitfld.quad 0x00 27. "Enable_CH_LOCK_CLEARED_IntSignal,Channel Lock Cleared Signal Enable" "0: Disable the propagation of Channel Lock..,1: Enable the propagation of Channel Lock.."
            newline
            rbitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTSIGNAL_ENABLEREG_26,DMAC Channelx Interrupt Signal Enable Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "Enable_SLVIF_WRPARITY_ERR_IntSignal,Slave Interface Write Parity Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            rbitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTSIGNAL_ENABLEREG_22to24,DMAC Channelx Interrupt Signal Enable Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "Enable_SLVIF_WRONHOLD_ERR_IntSignal,Slave Interface Write On Hold Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 20. "Enable_SLVIF_SHADOWREG_WRON_VALID_ERR_IntSignal,Shadow Register Write On Valid Error Signal Enable" "0: Disable the propagation of Shadow Register..,1: Enable the propagation of Shadow register.."
            newline
            bitfld.quad 0x00 19. "Enable_SLVIF_WRONCHEN_ERR_IntSignal,Slave Interface Write On Channel Enabled Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 18. "Enable_SLVIF_RD2RWO_ERR_IntSignal,Slave Interface Read to write Only Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 17. "Enable_SLVIF_WR2RO_ERR_IntSignal,Slave Interface Write to Read Only Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 16. "Enable_SLVIF_DEC_ERR_IntSignal,Slave Interface Decode Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            rbitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_15,DMAC Channelx Interrupt Status Enable Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "Enable_SLVIF_MULTIBLKTYPE_ERR_IntSignal,Slave Interface Multi Block type Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 13. "Enable_SHADOWREG_OR_LLI_INVALID_ERR_IntSignal,Shadow register or LLI Invalid Error Signal Enable" "0: Disable the propagation of Shadow Register or..,1: Enable the propagation of Shadow Register or.."
            newline
            bitfld.quad 0x00 12. "Enable_LLI_WR_SLV_ERR_IntSignal,LLI WRITE Slave Error Signal Enable" "0: Disable the propagation of LLI WRITE Slave..,1: Enable the propagation of LLI WRITE Slave.."
            newline
            bitfld.quad 0x00 11. "Enable_LLI_RD_SLV_ERR_IntSignal,LLI Read Slave Error Signal Enable" "0: Disable the propagation of LLI Read Slave..,1: Enable the propagation of LLI Read Slave.."
            newline
            bitfld.quad 0x00 10. "Enable_LLI_WR_DEC_ERR_IntSignal,LLI WRITE Decode Error Signal Enable" "0: Disable the propagation of LLI WRITE Decode..,1: Enable the propagation of LLI WRITE Decode.."
            newline
            bitfld.quad 0x00 9. "Enable_LLI_RD_DEC_ERR_IntSignal,LLI Read Decode Error Signal Enable" "0: Disable the propagation of LLI Read Decode..,1: Enable the propagation of LLI Read Decode.."
            newline
            bitfld.quad 0x00 8. "Enable_DST_SLV_ERR_IntSignal,Destination Slave Error Signal Enable" "0: Disable the propagation of Destination Slave..,1: Enable the propagation of Destination Slave.."
            newline
            bitfld.quad 0x00 7. "Enable_SRC_SLV_ERR_IntSignal,Source Slave Error Signal Enable" "0: Disable the propagation of Source Slave Error..,1: Enable the propagation of Source Slave Error.."
            newline
            bitfld.quad 0x00 6. "Enable_DST_DEC_ERR_IntSignal,Destination Decode Error Signal Enable" "0: Disable the propagation of Destination Decode..,1: Enable the propagation of Destination Decode.."
            newline
            bitfld.quad 0x00 5. "Enable_SRC_DEC_ERR_IntSignal,Source Decode Error Signal Enable" "0: Disable the propagation of Source Decode..,1: Enable the propagation of Source Decode Error.."
            newline
            bitfld.quad 0x00 4. "Enable_DST_TRANSCOMP_IntSignal,Destination Transaction Completed Signal Enable" "0: Disable the propagation of Destination..,1: Enable the propagation of Destination.."
            newline
            bitfld.quad 0x00 3. "Enable_SRC_TRANSCOMP_IntSignal,Source Transaction Completed Signal Enable" "0: Disable the propagation of Source Transaction..,1: Enable the propagation of Source Transaction.."
            newline
            rbitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_2,DMAC Channelx Interrupt Status Enable Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "Enable_DMA_TFR_DONE_IntSignal,DMA Transfer Done Interrupt Signal Enable" "0: Disable the propagation of DMA Transfer Done..,1: Enable the propagation of DMA Transfer Done.."
            newline
            bitfld.quad 0x00 0. "Enable_BLOCK_TFR_DONE_IntSignal,Block Transfer Done Interrupt Signal Enable" "0: Disable the propagation of Block Transfer..,1: Enable the propagation of Block Transfer Done.."

    wgroup.quad 0x398++0x07
        line.quad 0x00 "CH3_INTCLEARREG,Writing 1 to specific field will clear the corresponding field in Channelx Interrupt Status Register(CHx_IntStatusReg)"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTCLEARREG_36to63,DMAC Channelx Interrupt Clear Register (bits 36to63) Reserved bit - Read Only"
            newline
            bitfld.quad 0x00 35. "Clear_ECC_PROT_UIDMem_UnCorrERR_IntStat,ECC Protection Uncorrectable UID Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_UIDMem_UnCorrERR interrupt.."
            newline
            bitfld.quad 0x00 34. "Clear_ECC_PROT_UIDMem_CorrERR_IntStat,ECC Protection Correctable UID Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_UIDMem_CorrERR interrupt.."
            newline
            bitfld.quad 0x00 33. "Clear_ECC_PROT_CHMem_UnCorrERR_IntStat,ECC Protection Uncorrectable Channel Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_CHMem_UnCorrERR interrupt.."
            newline
            bitfld.quad 0x00 32. "Clear_ECC_PROT_CHMem_CorrERR_IntStat,ECC Protection Correctable Channel Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_CHMem_CorrERR interrupt in.."
            newline
            bitfld.quad 0x00 31. "Clear_CH_ABORTED_IntStat,Channel Aborted Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_ABORTED interrupt in the.."
            newline
            bitfld.quad 0x00 30. "Clear_CH_DISABLED_IntStat,Channel Disabled Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_DISABLED interrupt in the.."
            newline
            bitfld.quad 0x00 29. "Clear_CH_SUSPENDED_IntStat,Channel Suspended Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_SUSPENDED interrupt in the.."
            newline
            bitfld.quad 0x00 28. "Clear_CH_SRC_SUSPENDED_IntStat,Channel Source Suspended Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_SRC_SUSPENDED interrupt in the.."
            newline
            bitfld.quad 0x00 27. "Clear_CH_LOCK_CLEARED_IntStat,Channel Lock Cleared Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_LOCK_CLEARED interrupt in the.."
            newline
            bitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTCLEARREG_26,DMAC Channelx Interrupt Clear Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "Clear_SLVIF_WRPARITY_ERR_IntStat,Slave Interface Write Parity Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WRPARITY_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTCLEARREG_22to24,DMAC Channelx Interrupt Clear Register (bits 22to24) Reserved bit - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "Clear_SLVIF_WRONHOLD_ERR_IntStat,Slave Interface Write On Hold Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WRONHOLD_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 20. "Clear_SLVIF_SHADOWREG_WRON_VALID_ERR_IntStat,Shadow Register Write On Valid Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_SHADOWREG_WRON_VALID_ERR.."
            newline
            bitfld.quad 0x00 19. "Clear_SLVIF_WRONCHEN_ERR_IntStat,Slave Interface Write On Channel Enabled Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WRONCHEN_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 18. "Clear_SLVIF_RD2RWO_ERR_IntStat,Slave Interface Read to write Only Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_RD2RWO_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 17. "Clear_SLVIF_WR2RO_ERR_IntStat,Slave Interface Write to Read Only Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WR2RO_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 16. "Clear_SLVIF_DEC_ERR_IntStat,Slave Interface Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTCLEARREG_15,DMAC Channelx Interrupt Clear Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "Clear_SLVIF_MULTIBLKTYPE_ERR_IntStat,Slave Interface Multi Block type Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_MULTIBLKTYPE_ERR interrupt in.."
            newline
            bitfld.quad 0x00 13. "Clear_SHADOWREG_OR_LLI_INVALID_ERR_IntStat,Shadow register or LLI Invalid Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SHADOWREG_OR_LLI_INVALID_ERR.."
            newline
            bitfld.quad 0x00 12. "Clear_LLI_WR_SLV_ERR_IntStat,LLI WRITE Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_WR_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 11. "Clear_LLI_RD_SLV_ERR_IntStat,LLI Read Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_RD_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 10. "Clear_LLI_WR_DEC_ERR_IntStat,LLI WRITE Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_WR_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 9. "Clear_LLI_RD_DEC_ERR_IntStat,LLI Read Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_RD_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 8. "Clear_DST_SLV_ERR_IntStat,Destination Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the DST_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 7. "Clear_SRC_SLV_ERR_IntStat,Source Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SRC_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 6. "Clear_DST_DEC_ERR_IntStat,Destination Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the DST_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 5. "Clear_SRC_DEC_ERR_IntStat,Source Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SRC_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 4. "Clear_DST_TRANSCOMP_IntStat,Destination Transaction Completed Interrupt Clear Bit" "0: Inactive signal,1: Clear the DST_TRANSCOMP interrupt in the.."
            newline
            bitfld.quad 0x00 3. "Clear_SRC_TRANSCOMP_IntStat,Source Transaction Completed Interrupt Clear Bit" "0: Inactive signal,1: Clear the SRC_TRANSCOMP interrupt in the.."
            newline
            bitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTCLEARREG_2,DMAC Channelx Interrupt Clear Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "Clear_DMA_TFR_DONE_IntStat,DMA Transfer Done Interrupt Clear Bit" "0: Inactive signal,1: Clear the DMA_TFR_DONE interrupt in the.."
            newline
            bitfld.quad 0x00 0. "Clear_BLOCK_TFR_DONE_IntStat,Block Transfer Done Interrupt Clear Bit" "0: Inactive signal,1: Clear the interrupt in the Interrupt Status.."

    group.quad 0x400++0x07
        line.quad 0x00 "CH4_SAR,The starting source address is programmed by software before the DMA channel is enabled or by an LLI update before the start of the DMA transfer"
            hexmask.quad 0x00 0.--63. 1. "SAR,Current Source Address of DMA transfer"
    group.quad 0x408++0x07
        line.quad 0x00 "CH4_DAR,The starting destination address is programmed by the software before the DMA channel is enabled or by an LLI update before the start of the DMA transfer"
            hexmask.quad 0x00 0.--63. 1. "DAR,Current Destination Address of DMA transfer"
    group.quad 0x410++0x07
        line.quad 0x00 "CH4_BLOCK_TS,When DW_axi_dmac is the flow controller the DMAC uses this register before the channel is enabled for block-size"
            hexmask.quad.quad 0x00 22.--63. 1. "RSVD_DMAC_CHx_BLOCK_TSREG_63to22,DMAC Channelx Block Transfer Size Register (bits 63to22) Reserved bits - Read Only"
            newline
            hexmask.quad.tbyte 0x00 0.--21. 1. "BLOCK_TS,Block Transfer Size"
    group.quad 0x418++0x07
        line.quad 0x00 "CH4_CTL,This register contains fields that control the DMA transfer"
            bitfld.quad 0x00 63. "SHADOWREG_OR_LLI_VALID,Shadow Register content/Linked List Item valid" "0: Indicates shadowreg/LLI content is Invalid,1: Indicates shadowreg/LLI content is Valid"
            newline
            bitfld.quad 0x00 62. "SHADOWREG_OR_LLI_LAST,Last Shadow Register/Linked List Item" "0: Indicates shadowreg/LLI content is not the..,1: Indicates shadowreg/LLI content is the last one"
            newline
            rbitfld.quad 0x00 59.--61. "RSVD_DMAC_CHx_CTL_59to61,DMAC Channelx Control Transfer Register (bits 59to61) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 58. "IOC_BlkTfr,Interrupt On completion of Block Transfer This bit is used to control the block transfer completion interrupt generation on a block by block basis for shadow register or linked list based multi-block transfers" "0: Disables..,1: Enables.."
            newline
            rbitfld.quad 0x00 57. "DST_STAT_EN,Destination Status Enable Enable the logic to fetch status from destination peripheral of channel x pointed to by the content of CHx_DSTATAR register and stores it in CHx_DSTAT register" "0: No status fetch for Destination device,1: Enables status fetch for Destination and.."
            newline
            rbitfld.quad 0x00 56. "SRC_STAT_EN,Source Status Enable Enable the logic to fetch status from source peripheral of channel x pointed to by the content of CHx_SSTATAR register and stores it in CHx_SSTAT register" "0: No status fetch for Source device,1: Enables status fetch for Source and store the.."
            newline
            hexmask.quad.byte 0x00 48.--55. 1. "AWLEN,Destination Burst Length AXI Burst length used for destination data transfer"
            newline
            bitfld.quad 0x00 47. "AWLEN_EN,Destination Burst Length Enable If this bit is set to 1 DW_axi_dmac uses the value of CHx_CTL.AWLEN as AXI Burst length for destination data transfer till the extent possible remaining transfers use maximum possible burst length" "0: AXI Burst Length is any possible value <=..,1: AXI Burst Length is CH4_CTL.AWLEN (till the.."
            newline
            hexmask.quad.byte 0x00 39.--46. 1. "ARLEN,Source Burst Length AXI Burst length used for source data transfer"
            newline
            bitfld.quad 0x00 38. "ARLEN_EN,Source Burst Length Enable If this bit is set to 1 DW_axi_dmac uses the value of CHx_CTL.ARLEN as AXI Burst length for source data transfer till the extent possible remaining transfers use maximum possible burst length" "0: AXI Burst Length is any possible value <=..,1: AXI Burst Length is CH4_CTL.ARLEN (till the.."
            newline
            bitfld.quad 0x00 35.--37. "AW_PROT,AXI 'aw_prot' signal" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 32.--34. "AR_PROT,AXI 'ar_prot' signal" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 31. "RSVD_DMAC_CHx_CTL_31,DMAC Channelx Control Transfer Register bit31 Reserved bits - Read Only" "0,1"
            newline
            bitfld.quad 0x00 30. "NonPosted_LastWrite_En,Non Posted Last Write Enable This bit decides whether posted writes can be used throughout the block transfer" "0: Posted writes may be used throughout the..,1: Last write in the block must be non-posted"
            newline
            bitfld.quad 0x00 26.--29. "AW_CACHE,AXI 'aw_cache' signal" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 22.--25. "AR_CACHE,AXI 'ar_cache' signal" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 18.--21. "DST_MSIZE,Destination Burst Transaction Length" "0: 1 Data Item read from Destination in the..,1: 4 Data Item read from Destination in the..,2: 8 Data Item read from Destination in the..,3: 16 Data Item read from Destination in the..,4: 32 Data Item read from Destination in the..,5: 64 Data Item read from Destination in the..,6: 128 Data Item read from Destination in the..,7: 256 Data Item read from Destination in the..,8: 512 Data Item read from Destination in the..,9: 1024 Data Item read from Destination in the..,?..."
            newline
            bitfld.quad 0x00 14.--17. "SRC_MSIZE,Source Burst Transaction Length" "0: 1 Data Item read from Source in the burst..,1: 4 Data Item read from Source in the burst..,2: 8 Data Item read from Source in the burst..,3: 16 Data Item read from Source in the burst..,4: 32 Data Item read from Source in the burst..,5: 64 Data Item read from Source in the burst..,6: 128 Data Item read from Source in the burst..,7: 256 Data Item read from Source in the burst..,8: 512 Data Item read from Source in the burst..,9: 1024 Data Item read from Source in the burst..,?..."
            newline
            bitfld.quad 0x00 11.--13. "DST_TR_WIDTH,Destination Transfer Width" "0: Destination Transfer Width is 8 bits,1: Destination Transfer Width is 16 bits,2: Destination Transfer Width is 32 bits,3: Destination Transfer Width is 64 bits,4: Destination Transfer Width is 128 bits,5: Destination Transfer Width is 256 bits,6: Destination Transfer Width is 512 bits,?..."
            newline
            bitfld.quad 0x00 8.--10. "SRC_TR_WIDTH,Source Transfer Width" "0: Source Transfer Width is 8 bits,1: Source Transfer Width is 16 bits,2: Source Transfer Width is 32 bits,3: Source Transfer Width is 64 bits,4: Source Transfer Width is 128 bits,5: Source Transfer Width is 256 bits,6: Source Transfer Width is 512 bits,?..."
            newline
            rbitfld.quad 0x00 7. "RSVD_DMAC_CHx_CTL_7,DMAC Channelx Control Transfer Register bit7 Reserved bits - Read Only" "0,1"
            newline
            bitfld.quad 0x00 6. "DINC,Destination Address Increment" "0: Destination address incremented on every..,1: Destination address is fixed"
            newline
            rbitfld.quad 0x00 5. "RSVD_DMAC_CHx_CTL_5,DMAC Channelx Control Transfer Register bit5 Reserved bits - Read Only" "0,1"
            newline
            bitfld.quad 0x00 4. "SINC,Source Address Increment" "0: Source address incremented on every source..,1: Source address is fixed"
            newline
            rbitfld.quad 0x00 3. "RSVD_DMAC_CHx_CTL_3,DMAC Channelx Control Transfer Register bit3 Reserved bits - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 2. "DMS,Destination Master Select" "0: Destination device on Master-1 interface layer,1: Destination device on Master-2 interface layer"
            newline
            rbitfld.quad 0x00 1. "RSVD_DMAC_CHx_CTL_1,DMAC Channelx Control Transfer Register bit1 Reserved bits - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 0. "SMS,Source Master Select" "0: Source device on Master-1 interface layer,1: Source device on Master-2 interface layer"
    group.quad 0x420++0x07
        line.quad 0x00 "CH4_CFG,This register contains fields that configure the DMA transfer"
            rbitfld.quad 0x00 63. "RSVD_DMAC_CHx_CFG_63,DMAC Channelx Transfer Configuration Register (63bit) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 59.--62. "DST_OSR_LMT,Destination Outstanding Request Limit - Maximum outstanding request supported is 16" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 55.--58. "SRC_OSR_LMT,Source Outstanding Request Limit - Maximum outstanding request supported is 16" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.quad 0x00 53.--54. "LOCK_CH_L,Channel Lock Level This bit indicates the duration over which CHx_CFG.LOCK_CH bit applies" "0: Duration of the Channel locking is for the..,1: Duration of the Channel locking is for the..,?..."
            newline
            rbitfld.quad 0x00 52. "LOCK_CH,Channel Lock bit When the channel is granted control of the master bus interface and if the CHx_CFG.LOCK_CH bit is asserted then no other channels are granted control of the master bus interface for the duration specified in CHx_CFG.LOCK_CH_L" "0: Channel is not locked during the transfers,1: Channel is locked and granted exclusive.."
            newline
            bitfld.quad 0x00 49.--51. "CH_PRIOR,Channel Priority A priority of DMAX_NUM_CHANNELS-1 is the highest priority and 0 is the lowest" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 48. "RSVD_DMAC_CHx_CFG_48,DMAC Channelx Transfer Configuration Register (48bit) Reserved bit - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 46.--47. "RSVD_DMAC_CHx_CFG_47_44,DMAC Channelx Transfer Configuration Register (bits (LOG2_DMAX_NUM_HS_IF+44) to 47) Reserved bits - Read Only" "0,1,2,3"
            newline
            bitfld.quad 0x00 44.--45. "DST_PER,Assigns a hardware handshaking interface (0 - DMAX_NUM_HS_IF-1) to the destination of Channelx if the CHx_CFG.HS_SEL_DST field is 0 otherwise this field is ignored" "0,1,2,3"
            newline
            rbitfld.quad 0x00 43. "RSVD_DMAC_CHx_CFG_43,DMAC Channelx Transfer Configuration Register (43bit) Reserved bit - Read Only" "0,1"
            newline
            rbitfld.quad 0x00 41.--42. "RSVD_DMAC_CHx_CFG_42_39,DMAC Channelx Transfer Configuration Register (bits (LOG2_DMAX_NUM_HS_IF+39) to 42) Reserved bits - Read Only" "0,1,2,3"
            newline
            bitfld.quad 0x00 39.--40. "SRC_PER,Assigns a hardware handshaking interface (0 - DMAX_NUM_HS_IF-1) to the source of Channelx if the CHx_CFG.HS_SEL_SRC field is 0 otherwise this field is ignored" "0,1,2,3"
            newline
            rbitfld.quad 0x00 38. "DST_HWHS_POL,Destination Hardware Handshaking Interface Polarity" "0: Polarity of the Handshaking Interface used..,1: Polarity of the Handshaking Interface used.."
            newline
            rbitfld.quad 0x00 37. "SRC_HWHS_POL,Source Hardware Handshaking Interface Polarity" "0: Polarity of the Handshaking Interface used..,1: Polarity of the Handshaking Interface used.."
            newline
            bitfld.quad 0x00 36. "HS_SEL_DST,Destination Software or Hardware Handshaking Select" "0: Hardware Handshaking Interface is used for..,1: Software Handshaking Interface is used for.."
            newline
            bitfld.quad 0x00 35. "HS_SEL_SRC,Source Software or Hardware Handshaking Select" "0: Hardware Handshaking Interface is used for..,1: Software Handshaking Interface is used for.."
            newline
            bitfld.quad 0x00 32.--34. "TT_FC,Transfer Type and Flow Control" "0: Transfer Type is memory to memory and Flow..,1: Transfer Type is memory to peripheral and..,2: Transfer Type is peripheral to memory and..,3: Transfer Type is peripheral to peripheral and..,4: Transfer Type is peripheral to Memory and..,5: Transfer Type is peripheral to peripheral and..,6: Transfer Type is memory to peripheral and..,7: Transfer Type is peripheral to peripheral and.."
            newline
            rbitfld.quad 0x00 29.--31. "RSVD_DMAC_CHx_CFG_29to31,DMAC Channelx Transfer Configuration Register (bits 29to31) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 25.--28. "WR_UID,Defines the number of AXI Unique ID's supported for the AXI Write Channel" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_CFG_22to24,DMAC Channelx Transfer Configuration Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.quad 0x00 18.--21. "RD_UID,Defines the number of AXI Unique ID's supported for the AXI Read Channel" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.quad.word 0x00 4.--17. 1. "RSVD_DMAC_CHx_CFG_4to17,DMAC Channelx Transfer Configuration Register (bits 4to17) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 2.--3. "DST_MULTBLK_TYPE,Destination Multi Block Transfer Type" "0: Contiguous Multiblock Type used for..,1: Reload Multiblock Type used for Destination..,2: Shadow Register based Multiblock Type used..,3: Linked List based Multiblock Type used for.."
            newline
            rbitfld.quad 0x00 0.--1. "SRC_MULTBLK_TYPE,Source Multi Block Transfer Type" "0: Contiguous Multiblock Type used for Source..,1: Reload Multiblock Type used for Source Transfer,2: Shadow Register based Multiblock Type used..,3: Linked List based Multiblock Type used for.."
    group.quad 0x428++0x07
        line.quad 0x00 "CH4_LLP,This is the Linked List Pointer register"
            hexmask.quad 0x00 6.--63. 1. "LOC,Starting Address Memory of LLI block Starting Address In Memory of next LLI if block chaining is enabled"
            newline
            rbitfld.quad 0x00 1.--5. "RSVD_DMAC_CHx_LLP_1to5,DMAC Channelx Linked List Pointer Register (bits 1to5) Reserved bits - Read Only" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            rbitfld.quad 0x00 0. "LMS,LLI master Select This bit identifies the AXI layer/interface where the memory device that stores the next linked list item resides" "0: next Linked List item resides on AXI Master1..,1: next Linked List item resides on AXI Master2.."

    rgroup.quad 0x430++0x07
        line.quad 0x00 "CH4_STATUSREG,Channelx Status Register contains fields that indicate the status of DMA transfers for Channelx"
            hexmask.quad.tbyte 0x00 47.--63. 1. "RSVD_DMAC_CHx_STATUSREG_47to63,DMAC Channelx Status Register (bits 47to63) Reserved bits - Read Only"
            newline
            hexmask.quad.word 0x00 32.--46. 1. "DATA_LEFT_IN_FIFO,Data Left in FIFO"
            newline
            hexmask.quad.word 0x00 22.--31. 1. "RSVD_DMAC_CHx_STATUSREG_22to31,DMAC Channelx Status Register (bits 22to31) Reserved bits - Read Only"
            newline
            hexmask.quad.tbyte 0x00 0.--21. 1. "CMPLTD_BLK_TFR_SIZE,Completed Block Transfer Size"

    group.quad 0x438++0x07
        line.quad 0x00 "CH4_SWHSSRCREG,Channelx Software handshake Source Register"
            hexmask.quad 0x00 6.--63. 1. "RSVD_DMAC_CHx_SWHSSRCREG_6to63,DMAC Channelx Software Handshake Source Register (bits 6to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 5. "SWHS_LST_SRC_WE,Write Enable bit for Software Handshake Last Request for Channel Source" "0: Disables write to the SWHS_LAST_SRC bit,1: Enables write to the SWHS_LAST_SRC bit"
            newline
            bitfld.quad 0x00 4. "SWHS_LST_SRC,Software Handshake Last Request for Channel Source" "0: Source peripheral indication that the curent..,1: Source peripheral indication to dmac that the.."
            newline
            bitfld.quad 0x00 3. "SWHS_SGLREQ_SRC_WE,Write Enable bit for Software Handshake Single Request for Channel Source" "0: Disables write to the SWHS_SGLREQ_SRC bit,1: Enables write to the SWHS_SGLREQ_SRC bit"
            newline
            bitfld.quad 0x00 2. "SWHS_SGLREQ_SRC,Software Handshake Single Request for Channel Source" "0: Source peripheral is not requesting for a..,1: Source peripheral request for a single dma.."
            newline
            bitfld.quad 0x00 1. "SWHS_REQ_SRC_WE,Write Enable bit for Software Handshake Request for Channel Source" "0: Disables write to the SWHS_REQ_SRC bit,1: Enables write to the SWHS_REQ_SRC bit"
            newline
            bitfld.quad 0x00 0. "SWHS_REQ_SRC,Software Handshake Request for Channel Source" "0: Source peripheral is not requesting for a..,1: Source peripheral request for a dma transfer"
    group.quad 0x440++0x07
        line.quad 0x00 "CH4_SWHSDSTREG,Channelx Software handshake Destination Register"
            hexmask.quad 0x00 6.--63. 1. "RSVD_DMAC_CHx_SWHSDSTREG_6to63,DMAC Channelx Software Handshake Destination Register (bits 6to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 5. "SWHS_LST_DST_WE,Write Enable bit for Software Handshake Last Request for Channel Destination" "0: Disables write to the SWHS_LAST_DST bit,1: Enables write to the SWHS_LAST_DST bit"
            newline
            bitfld.quad 0x00 4. "SWHS_LST_DST,Software Handshake Last Request for Channel Destination" "0: Destination peripheral indication that the..,1: Destination peripheral indication to dmac.."
            newline
            bitfld.quad 0x00 3. "SWHS_SGLREQ_DST_WE,Write Enable bit for Software Handshake Single Request for Channel Destination" "0: Disables write to the SWHS_SGLREQ_DST bit,1: Enables write to the SWHS_SGLREQ_DST bit"
            newline
            bitfld.quad 0x00 2. "SWHS_SGLREQ_DST,Software Handshake Single Request for Channel Destination" "0: Destination peripheral is not requesting for..,1: Destination peripheral request for a single.."
            newline
            bitfld.quad 0x00 1. "SWHS_REQ_DST_WE,Write Enable bit for Software Handshake Request for Channel Destination" "0: Disables write to the SWHS_REQ_DST bit,1: Enables write to the SWHS_REQ_DST bit"
            newline
            bitfld.quad 0x00 0. "SWHS_REQ_DST,Software Handshake Request for Channel Destination" "0: Destination peripheral is not requesting for..,1: Destination peripheral request for a dma.."

    wgroup.quad 0x448++0x07
        line.quad 0x00 "CH4_BLK_TFR_RESUMEREQREG,Channelx Block Transfer Resume Request Register"
            hexmask.quad 0x00 1.--63. 1. "RSVD_DMAC_CHx_BLK_TFR_RESUMEREQREG_1to63,DMAC Channelx Block Transfer Resume Request Register (bits 1to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 0. "BLK_TFR_RESUMEREQ,Block Transfer Resume Request during Linked-List or Shadow-Register-based multi-block transfer" "0: No request to resume the block transfer,1: Request for resuming the block transfer"

    group.quad 0x450++0x07
        line.quad 0x00 "CH4_AXI_IDREG,Channelx AXI ID Register"
            hexmask.quad.long 0x00 32.--63. 1. "RSVD_DMAC_CHx_AXI_IDREG_32to63,DMAC Channelx AXI ID Register (bits 32to63) Reserved bits - Read Only"
            newline
            hexmask.quad.word 0x00 18.--31. 1. "RSVD_DMAC_CHx_AXI_IDREG_IDW_L2NCm32to63,DMAC Channelx AXI ID Register (bits (IDW-L2NC-1)to32) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 16.--17. "AXI_WRITE_ID_SUFFIX,AXI Write ID Suffix" "0,1,2,3"
            newline
            hexmask.quad.word 0x00 2.--15. 1. "RSVD_DMAC_CHx_AXI_IDREG_IDW_L2NCm1to31,DMAC Channelx AXI ID Register (bits (IDW-L2NC-1)to31) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 0.--1. "AXI_READ_ID_SUFFIX,AXI Read ID Suffix These bits form part of the ARID output of AXI3/AXI4 master interface" "0,1,2,3"
    group.quad 0x458++0x07
        line.quad 0x00 "CH4_AXI_QOSREG,Channelx AXI QOS Register"
            hexmask.quad.quad 0x00 8.--63. 1. "RSVD_DMAC_CHx_AXI_QOSREG_8to63,DMAC Channelx AXI QOS Register (bits 8to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 4.--7. "AXI_ARQOS,AXI ARQOS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.quad 0x00 0.--3. "AXI_AWQOS,AXI AWQOS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.quad 0x480++0x07
        line.quad 0x00 "CH4_INTSTATUS_ENABLEREG,Writing 1 to specific field enables the corresponding interrupt status generation in Channelx Interrupt Status Register(CH4_IntStatusReg)"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_32to63,DMAC Channelx Interrupt Status Enable Register (bits 32to63) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 35. "Enable_ECC_PROT_UIDMem_UnCorrERR_IntStat,Channel x Unique ID Memory Interface ECC Protection Uncorrectable Error Interrupt enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            rbitfld.quad 0x00 34. "Enable_ECC_PROT_UIDMem_CorrERR_IntStat,Channel x Unique ID Memory Interface ECC Protection Correctable Error Interrupt enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            bitfld.quad 0x00 33. "Enable_ECC_PROT_CHMem_UnCorrERR_IntStat,Channel x Channel Memory Interface ECC Protection Uncorrectable Error Interrupt enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 32. "Enable_ECC_PROT_CHMem_CorrERR_IntStat,Channel x Channel Memory Interface ECC Protection Correctable Error Interrupt enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 31. "Enable_CH_ABORTED_IntStat,Channel Aborted Status Enable" "0: Disable the generation of Channel Aborted..,1: Enable the generation of Channel Aborted.."
            newline
            bitfld.quad 0x00 30. "Enable_CH_DISABLED_IntStat,Channel Disabled Status Enable" "0: Disable the generation of Channel Disabled..,1: Enable the generation of Channel Disabled.."
            newline
            bitfld.quad 0x00 29. "Enable_CH_SUSPENDED_IntStat,Channel Suspended Status Enable" "0: Disable the generation of Channel Suspended..,1: Enable the generation of Channel Suspended.."
            newline
            bitfld.quad 0x00 28. "Enable_CH_SRC_SUSPENDED_IntStat,Channel Source Suspended Status Enable" "0: Disable the generation of Channel Source..,1: Enable the generation of Channel Source.."
            newline
            bitfld.quad 0x00 27. "Enable_CH_LOCK_CLEARED_IntStat,Channel Lock Cleared Status Enable" "0: Disable the generation of Channel LOCK..,1: Enable the generation of Channel LOCK CLEARED.."
            newline
            rbitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_26,DMAC Channelx Interrupt Status Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "Enable_SLVIF_WRPARITY_ERR_IntStat,Slave Interface Write Parity Error Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            rbitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_22to24,DMAC Channelx Interrupt Status Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "Enable_SLVIF_WRONHOLD_ERR_IntStat,Slave Interface Write On Hold Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 20. "Enable_SLVIF_SHADOWREG_WRON_VALID_ERR_IntStat,Shadow Register Write On Valid Error Status Enable" "0: Disable the generation of Shadow Register..,1: Enable the generation of Shadow register.."
            newline
            bitfld.quad 0x00 19. "Enable_SLVIF_WRONCHEN_ERR_IntStat,Slave Interface Write On Channel Enabled Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 18. "Enable_SLVIF_RD2RWO_ERR_IntStat,Slave Interface Read to write Only Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface Read.."
            newline
            bitfld.quad 0x00 17. "Enable_SLVIF_WR2RO_ERR_IntStat,Slave Interface Write to Read Only Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 16. "Enable_SLVIF_DEC_ERR_IntStat,Slave Interface Decode Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            rbitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_15,DMAC Channelx Interrupt Status Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "Enable_SLVIF_MULTIBLKTYPE_ERR_IntStat,Slave Interface Multi Block type Error Status Enable" "0: Disable the generation of Slave Interface..,1: Enable the generation of Slave Interface.."
            newline
            bitfld.quad 0x00 13. "Enable_SHADOWREG_OR_LLI_INVALID_ERR_IntStat,Shadow register or LLI Invalid Error Status Enable" "0: Disable the generation of Shadow Register or..,1: Enable the generation of Shadow Register or.."
            newline
            bitfld.quad 0x00 12. "Enable_LLI_WR_SLV_ERR_IntStat,LLI WRITE Slave Error Status Enable" "0: Disable the generation of LLI WRITE Slave..,1: Enable the generation of LLI WRITE Slave.."
            newline
            bitfld.quad 0x00 11. "Enable_LLI_RD_SLV_ERR_IntStat,LLI Read Slave Error Status Enable" "0: Disable the generation of LLI Read Slave..,1: Enable the generation of LLI Read Slave Error.."
            newline
            bitfld.quad 0x00 10. "Enable_LLI_WR_DEC_ERR_IntStat,LLI WRITE Decode Error Status Enable" "0: Disable the generation of LLI WRITE Decode..,1: Enable the generation of LLI WRITE Decode.."
            newline
            bitfld.quad 0x00 9. "Enable_LLI_RD_DEC_ERR_IntStat,LLI Read Decode Error Status Enable" "0: Disable the generation of LLI Read Decode..,1: Enable the generation of LLI Read Decode.."
            newline
            bitfld.quad 0x00 8. "Enable_DST_SLV_ERR_IntStat,Destination Slave Error Status Enable" "0: Disable the generation of Destination Slave..,1: Enable the generation of Destination Slave.."
            newline
            bitfld.quad 0x00 7. "Enable_SRC_SLV_ERR_IntStat,Source Slave Error Status Enable" "0: Disable the generation of Source Slave Error..,1: Enable the generation of Source Slave Error.."
            newline
            bitfld.quad 0x00 6. "Enable_DST_DEC_ERR_IntStat,Destination Decode Error Status Enable" "0: Disable the generation of Destination Decode..,1: Enable the generation of Destination Decode.."
            newline
            bitfld.quad 0x00 5. "Enable_SRC_DEC_ERR_IntStat,Source Decode Error Status Enable" "0: Disable the generation of Source Decode Error..,1: Enable the generation of Source Decode Error.."
            newline
            bitfld.quad 0x00 4. "Enable_DST_TRANSCOMP_IntStat,Destination Transaction Completed Status Enable" "0: Disable the generation of Destination..,1: Enable the generation of Destination.."
            newline
            bitfld.quad 0x00 3. "Enable_SRC_TRANSCOMP_IntStat,Source Transaction Completed Status Enable" "0: Disable the generation of Source Transaction..,1: Enable the generation of Source Transaction.."
            newline
            rbitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_2,DMAC Channelx Interrupt Status Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "Enable_DMA_TFR_DONE_IntStat,DMA Transfer Done Interrupt Status Enable" "0: Disable the generation of DMA Transfer Done..,1: Enable the generation of DMA Transfer Done.."
            newline
            bitfld.quad 0x00 0. "Enable_BLOCK_TFR_DONE_IntStat,Block Transfer Done Interrupt Status Enable" "0: Disable the generation of Block Transfer Done..,1: Enable the generation of Block Transfer Done.."

    rgroup.quad 0x488++0x07
        line.quad 0x00 "CH4_INTSTATUS,Channelx Interrupt Status Register captures the Channelx specific interrupts"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTSTATUSREG_36to63,DMAC Channelx Specific Interrupt Register (bits 36to63) Reserved bits - Read Only"
            newline
            bitfld.quad 0x00 35. "ECC_PROT_UIDMem_UnCorrERR_IntStat,Channel x UID Memory Interface ECC Protection related Uncorrectable Error Interrupt Status bit" "0: Channel x UID Memory Interface Uncorrectable..,1: Channel x UID Memory Interface Uncorrectable.."
            newline
            bitfld.quad 0x00 34. "ECC_PROT_UIDMem_CorrERR_IntStat,Channel x UID Memory Interface ECC Protection related Correctable Error Interrupt Status bit" "0: Channel x UID Memory Interface correctable..,1: Channel x UID Memory Interface correctable.."
            newline
            bitfld.quad 0x00 33. "ECC_PROT_CHMem_UnCorrERR_IntStat,Channel x FIFO Memory Interface ECC Protection related Uncorrectable Error Interrupt Status bit" "0: Channel x FIFO Memory Interface Uncorrectable..,1: Channel x FIFO Memory Interface Uncorrectable.."
            newline
            bitfld.quad 0x00 32. "ECC_PROT_CHMem_CorrERR_IntStat,Channel x FIFO Memory Interface ECC Protection related Correctable Error Interrupt Status bit" "0: Channel x FIFO Memory Interface correctable..,1: Channel x FIFO Memory Interface correctable.."
            newline
            bitfld.quad 0x00 31. "CH_ABORTED_IntStat,Channel Aborted" "0: Channel is not aborted,1: Channel is aborted"
            newline
            bitfld.quad 0x00 30. "CH_DISABLED_IntStat,Channel Disabled" "0: Channel is not disabled,1: Channel is disabled"
            newline
            bitfld.quad 0x00 29. "CH_SUSPENDED_IntStat,Channel Suspended" "0: Channel is not suspended,1: Channel is suspended"
            newline
            bitfld.quad 0x00 28. "CH_SRC_SUSPENDED_IntStat,Channel Source Suspended" "0: Channel source is not suspended,1: Channel Source is suspended"
            newline
            bitfld.quad 0x00 27. "CH_LOCK_CLEARED_IntStat,Channel Lock Cleared" "0: Channel locking is not cleared if present,1: Channel Locking is cleared"
            newline
            bitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTSTATUSREG_26,DMAC Channelx Specific Interrupt Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "SLVIF_WRPARITY_ERR_IntStat,Slave Interface Write Parity Error" "0: No Slave Interface Write Parity Errors,1: Slave Interface Write Parity Error detected"
            newline
            bitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTSTATUSREG_22to24,DMAC Channelx Specific Interrupt Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "SLVIF_WRONHOLD_ERR_IntStat,Slave Interface Write On Hold Error" "0: No Slave Interface Write On Hold Errors,1: Slave Interface Write On Hold Error detected"
            newline
            bitfld.quad 0x00 20. "SLVIF_SHADOWREG_WRON_VALID_ERR_IntStat,Shadow Register Write On Valid Error" "0: No Slave Interface Shadow Register Write On..,1: Slave Interface Shadow Register Write On.."
            newline
            bitfld.quad 0x00 19. "SLVIF_WRONCHEN_ERR_IntStat,Slave Interface Write On Channel Enabled Error" "0: No Slave Interface Write On Channel Enabled..,1: Slave Interface Write On Channel Enabled.."
            newline
            bitfld.quad 0x00 18. "SLVIF_RD2RWO_ERR_IntStat,Slave Interface Read to write Only Error" "0: No Slave Interface Read to Write Only Errors,1: Slave Interface Read to Write Only Error.."
            newline
            bitfld.quad 0x00 17. "SLVIF_WR2RO_ERR_IntStat,Slave Interface Write to Read Only Error" "0: No Slave Interface Write to Read Only Errors,1: Slave Interface Write to Read Only Error.."
            newline
            bitfld.quad 0x00 16. "SLVIF_DEC_ERR_IntStat,Slave Interface Decode Error" "0: No Slave Interface Decode errors,1: Slave Interface Decode Error detected"
            newline
            bitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTSTATUSREG_15,DMAC Channelx Specific Interrupt Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "SLVIF_MULTIBLKTYPE_ERR_IntStat,Slave Interface Multi Block type Error" "0: No Multi-block transfer type Errors,1: Multi-block transfer type Error detected"
            newline
            bitfld.quad 0x00 13. "SHADOWREG_OR_LLI_INVALID_ERR_IntStat,Shadow register or LLI Invalid Error" "0: No Shadow Register / LLI Invalid errors,1: Shadow Register / LLI Invalid error detected"
            newline
            bitfld.quad 0x00 12. "LLI_WR_SLV_ERR_IntStat,LLI WRITE Slave Error" "0: No LLI write Slave Errors,1: LLI Write SLAVE Error detected"
            newline
            bitfld.quad 0x00 11. "LLI_RD_SLV_ERR_IntStat,LLI Read Slave Error" "0: No LLI Read Slave Errors,1: LLI read Slave Error detected"
            newline
            bitfld.quad 0x00 10. "LLI_WR_DEC_ERR_IntStat,LLI WRITE Decode Error" "0: NO LLI Write Decode Errors,1: LLI write Decode Error detected"
            newline
            bitfld.quad 0x00 9. "LLI_RD_DEC_ERR_IntStat,LLI Read Decode Error" "0: NO LLI Read Decode Errors,1: LLI Read Decode Error detected"
            newline
            bitfld.quad 0x00 8. "DST_SLV_ERR_IntStat,Destination Slave Error" "0: No Destination Slave Errors,1: Destination Slave Errors Detected"
            newline
            bitfld.quad 0x00 7. "SRC_SLV_ERR_IntStat,Source Slave Error" "0: No Source Slave Errors,1: Source Slave Error Detected"
            newline
            bitfld.quad 0x00 6. "DST_DEC_ERR_IntStat,Destination Decode Error" "0: No destination Decode Errors,1: Destination Decode Error Detected"
            newline
            bitfld.quad 0x00 5. "SRC_DEC_ERR_IntStat,Source Decode Error" "0: No Source Decode Errors,1: Source Decode Error detected"
            newline
            bitfld.quad 0x00 4. "DST_TRANSCOMP_IntStat,Destination Transaction Completed" "0: Destination transaction is not complete,1: Destination transaction is complete"
            newline
            bitfld.quad 0x00 3. "SRC_TRANSCOMP_IntStat,Source Transaction Completed" "0: Source transation is not complete,1: Source transaction is complete"
            newline
            bitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTSTATUSREG_2,DMAC Channelx Specific Interrupt Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "DMA_TFR_DONE_IntStat,DMA Transfer Done" "0: DMA Transfer not complete,1: DMA Transfer completed"
            newline
            bitfld.quad 0x00 0. "BLOCK_TFR_DONE_IntStat,Block Transfer Done" "0: Block Transfer not complete,1: Block Transfer completed"

    group.quad 0x490++0x07
        line.quad 0x00 "CH4_INTSIGNAL_ENABLEREG,This register contains fields that are used to enable the generation of port level interrupt at the channel level"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTSIGNAL_ENABLEREG_36to63,DMAC Channelx Interrupt Signal Enable Register (bits 36to63) Reserved bits - Read Only"
            newline
            rbitfld.quad 0x00 35. "Enable_ECC_PROT_UIDMem_UnCorrERR_IntSignal,Channel x Unique ID Memory Interface ECC Protection Uncorrectable Error Interrupt Signal enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            rbitfld.quad 0x00 34. "Enable_ECC_PROT_UIDMem_CorrERR_IntSignal,Channel x Unique ID Memory Interface ECC Protection Correctable Error Interrupt Signal enable" "0: Disable the propagation of UID Memory ECC..,1: Enable the propagation of UID Memory ECC.."
            newline
            bitfld.quad 0x00 33. "Enable_ECC_PROT_CHMem_UnCorrERR_IntSignal,Channel x Channel Memory Interface ECC Protection Uncorrectable Error Interrupt Signal enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 32. "Enable_ECC_PROT_CHMem_CorrERR_IntSignal,Channel x Channel Memory Interface ECC Protection Correctable Error Interrupt Signal enable" "0: Disable the propagation of Channel Memory ECC..,1: Enable the propagation of Channel Memory ECC.."
            newline
            bitfld.quad 0x00 31. "Enable_CH_ABORTED_IntSignal,Channel Aborted Signal Enable" "0: Disable the propagation of Channel Aborted..,1: Enable the propagation of Channel Aborted.."
            newline
            bitfld.quad 0x00 30. "Enable_CH_DISABLED_IntSignal,Channel Disabled Signal Enable" "0: Disable the propagation of Channel Disabled..,1: Enable the propagation of Channel Disabled.."
            newline
            bitfld.quad 0x00 29. "Enable_CH_SUSPENDED_IntSignal,Channel Suspended Signal Enable" "0: Disable the propagation of Channel Suspended..,1: Enable the propagation of Channel Suspended.."
            newline
            bitfld.quad 0x00 28. "Enable_CH_SRC_SUSPENDED_IntSignal,Channel Source Suspended Signal Enable" "0: Disable the propagation of Channel Source..,1: Enable the propagation of Channel Source.."
            newline
            bitfld.quad 0x00 27. "Enable_CH_LOCK_CLEARED_IntSignal,Channel Lock Cleared Signal Enable" "0: Disable the propagation of Channel Lock..,1: Enable the propagation of Channel Lock.."
            newline
            rbitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTSIGNAL_ENABLEREG_26,DMAC Channelx Interrupt Signal Enable Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "Enable_SLVIF_WRPARITY_ERR_IntSignal,Slave Interface Write Parity Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            rbitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTSIGNAL_ENABLEREG_22to24,DMAC Channelx Interrupt Signal Enable Register (bits 22to24) Reserved bits - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "Enable_SLVIF_WRONHOLD_ERR_IntSignal,Slave Interface Write On Hold Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 20. "Enable_SLVIF_SHADOWREG_WRON_VALID_ERR_IntSignal,Shadow Register Write On Valid Error Signal Enable" "0: Disable the propagation of Shadow Register..,1: Enable the propagation of Shadow register.."
            newline
            bitfld.quad 0x00 19. "Enable_SLVIF_WRONCHEN_ERR_IntSignal,Slave Interface Write On Channel Enabled Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 18. "Enable_SLVIF_RD2RWO_ERR_IntSignal,Slave Interface Read to write Only Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 17. "Enable_SLVIF_WR2RO_ERR_IntSignal,Slave Interface Write to Read Only Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 16. "Enable_SLVIF_DEC_ERR_IntSignal,Slave Interface Decode Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            rbitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_15,DMAC Channelx Interrupt Status Enable Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "Enable_SLVIF_MULTIBLKTYPE_ERR_IntSignal,Slave Interface Multi Block type Error Signal Enable" "0: Disable the propagation of Slave Interface..,1: Enable the propagation of Slave Interface.."
            newline
            bitfld.quad 0x00 13. "Enable_SHADOWREG_OR_LLI_INVALID_ERR_IntSignal,Shadow register or LLI Invalid Error Signal Enable" "0: Disable the propagation of Shadow Register or..,1: Enable the propagation of Shadow Register or.."
            newline
            bitfld.quad 0x00 12. "Enable_LLI_WR_SLV_ERR_IntSignal,LLI WRITE Slave Error Signal Enable" "0: Disable the propagation of LLI WRITE Slave..,1: Enable the propagation of LLI WRITE Slave.."
            newline
            bitfld.quad 0x00 11. "Enable_LLI_RD_SLV_ERR_IntSignal,LLI Read Slave Error Signal Enable" "0: Disable the propagation of LLI Read Slave..,1: Enable the propagation of LLI Read Slave.."
            newline
            bitfld.quad 0x00 10. "Enable_LLI_WR_DEC_ERR_IntSignal,LLI WRITE Decode Error Signal Enable" "0: Disable the propagation of LLI WRITE Decode..,1: Enable the propagation of LLI WRITE Decode.."
            newline
            bitfld.quad 0x00 9. "Enable_LLI_RD_DEC_ERR_IntSignal,LLI Read Decode Error Signal Enable" "0: Disable the propagation of LLI Read Decode..,1: Enable the propagation of LLI Read Decode.."
            newline
            bitfld.quad 0x00 8. "Enable_DST_SLV_ERR_IntSignal,Destination Slave Error Signal Enable" "0: Disable the propagation of Destination Slave..,1: Enable the propagation of Destination Slave.."
            newline
            bitfld.quad 0x00 7. "Enable_SRC_SLV_ERR_IntSignal,Source Slave Error Signal Enable" "0: Disable the propagation of Source Slave Error..,1: Enable the propagation of Source Slave Error.."
            newline
            bitfld.quad 0x00 6. "Enable_DST_DEC_ERR_IntSignal,Destination Decode Error Signal Enable" "0: Disable the propagation of Destination Decode..,1: Enable the propagation of Destination Decode.."
            newline
            bitfld.quad 0x00 5. "Enable_SRC_DEC_ERR_IntSignal,Source Decode Error Signal Enable" "0: Disable the propagation of Source Decode..,1: Enable the propagation of Source Decode Error.."
            newline
            bitfld.quad 0x00 4. "Enable_DST_TRANSCOMP_IntSignal,Destination Transaction Completed Signal Enable" "0: Disable the propagation of Destination..,1: Enable the propagation of Destination.."
            newline
            bitfld.quad 0x00 3. "Enable_SRC_TRANSCOMP_IntSignal,Source Transaction Completed Signal Enable" "0: Disable the propagation of Source Transaction..,1: Enable the propagation of Source Transaction.."
            newline
            rbitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTSTATUS_ENABLEREG_2,DMAC Channelx Interrupt Status Enable Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "Enable_DMA_TFR_DONE_IntSignal,DMA Transfer Done Interrupt Signal Enable" "0: Disable the propagation of DMA Transfer Done..,1: Enable the propagation of DMA Transfer Done.."
            newline
            bitfld.quad 0x00 0. "Enable_BLOCK_TFR_DONE_IntSignal,Block Transfer Done Interrupt Signal Enable" "0: Disable the propagation of Block Transfer..,1: Enable the propagation of Block Transfer Done.."

    wgroup.quad 0x498++0x07
        line.quad 0x00 "CH4_INTCLEARREG,Writing 1 to specific field will clear the corresponding field in Channelx Interrupt Status Register(CHx_IntStatusReg)"
            hexmask.quad.long 0x00 36.--63. 1. "RSVD_DMAC_CHx_INTCLEARREG_36to63,DMAC Channelx Interrupt Clear Register (bits 36to63) Reserved bit - Read Only"
            newline
            bitfld.quad 0x00 35. "Clear_ECC_PROT_UIDMem_UnCorrERR_IntStat,ECC Protection Uncorrectable UID Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_UIDMem_UnCorrERR interrupt.."
            newline
            bitfld.quad 0x00 34. "Clear_ECC_PROT_UIDMem_CorrERR_IntStat,ECC Protection Correctable UID Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_UIDMem_CorrERR interrupt.."
            newline
            bitfld.quad 0x00 33. "Clear_ECC_PROT_CHMem_UnCorrERR_IntStat,ECC Protection Uncorrectable Channel Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_CHMem_UnCorrERR interrupt.."
            newline
            bitfld.quad 0x00 32. "Clear_ECC_PROT_CHMem_CorrERR_IntStat,ECC Protection Correctable Channel Memory Interrupt Clear Bit" "0: Inactive signal,1: Clear the ECC_PROT_CHMem_CorrERR interrupt in.."
            newline
            bitfld.quad 0x00 31. "Clear_CH_ABORTED_IntStat,Channel Aborted Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_ABORTED interrupt in the.."
            newline
            bitfld.quad 0x00 30. "Clear_CH_DISABLED_IntStat,Channel Disabled Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_DISABLED interrupt in the.."
            newline
            bitfld.quad 0x00 29. "Clear_CH_SUSPENDED_IntStat,Channel Suspended Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_SUSPENDED interrupt in the.."
            newline
            bitfld.quad 0x00 28. "Clear_CH_SRC_SUSPENDED_IntStat,Channel Source Suspended Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_SRC_SUSPENDED interrupt in the.."
            newline
            bitfld.quad 0x00 27. "Clear_CH_LOCK_CLEARED_IntStat,Channel Lock Cleared Interrupt Clear Bit" "0: Inactive signal,1: Clear the CH_LOCK_CLEARED interrupt in the.."
            newline
            bitfld.quad 0x00 26. "RSVD_DMAC_CHx_INTCLEARREG_26,DMAC Channelx Interrupt Clear Register (bit 26) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 25. "Clear_SLVIF_WRPARITY_ERR_IntStat,Slave Interface Write Parity Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WRPARITY_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 22.--24. "RSVD_DMAC_CHx_INTCLEARREG_22to24,DMAC Channelx Interrupt Clear Register (bits 22to24) Reserved bit - Read Only" "0,1,2,3,4,5,6,7"
            newline
            bitfld.quad 0x00 21. "Clear_SLVIF_WRONHOLD_ERR_IntStat,Slave Interface Write On Hold Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WRONHOLD_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 20. "Clear_SLVIF_SHADOWREG_WRON_VALID_ERR_IntStat,Shadow Register Write On Valid Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_SHADOWREG_WRON_VALID_ERR.."
            newline
            bitfld.quad 0x00 19. "Clear_SLVIF_WRONCHEN_ERR_IntStat,Slave Interface Write On Channel Enabled Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WRONCHEN_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 18. "Clear_SLVIF_RD2RWO_ERR_IntStat,Slave Interface Read to write Only Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_RD2RWO_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 17. "Clear_SLVIF_WR2RO_ERR_IntStat,Slave Interface Write to Read Only Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_WR2RO_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 16. "Clear_SLVIF_DEC_ERR_IntStat,Slave Interface Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 15. "RSVD_DMAC_CHx_INTCLEARREG_15,DMAC Channelx Interrupt Clear Register (bit 15) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 14. "Clear_SLVIF_MULTIBLKTYPE_ERR_IntStat,Slave Interface Multi Block type Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SLVIF_MULTIBLKTYPE_ERR interrupt in.."
            newline
            bitfld.quad 0x00 13. "Clear_SHADOWREG_OR_LLI_INVALID_ERR_IntStat,Shadow register or LLI Invalid Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SHADOWREG_OR_LLI_INVALID_ERR.."
            newline
            bitfld.quad 0x00 12. "Clear_LLI_WR_SLV_ERR_IntStat,LLI WRITE Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_WR_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 11. "Clear_LLI_RD_SLV_ERR_IntStat,LLI Read Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_RD_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 10. "Clear_LLI_WR_DEC_ERR_IntStat,LLI WRITE Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_WR_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 9. "Clear_LLI_RD_DEC_ERR_IntStat,LLI Read Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the LLI_RD_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 8. "Clear_DST_SLV_ERR_IntStat,Destination Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the DST_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 7. "Clear_SRC_SLV_ERR_IntStat,Source Slave Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SRC_SLV_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 6. "Clear_DST_DEC_ERR_IntStat,Destination Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the DST_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 5. "Clear_SRC_DEC_ERR_IntStat,Source Decode Error Interrupt Clear Bit" "0: Inactive signal,1: Clear the SRC_DEC_ERR interrupt in the.."
            newline
            bitfld.quad 0x00 4. "Clear_DST_TRANSCOMP_IntStat,Destination Transaction Completed Interrupt Clear Bit" "0: Inactive signal,1: Clear the DST_TRANSCOMP interrupt in the.."
            newline
            bitfld.quad 0x00 3. "Clear_SRC_TRANSCOMP_IntStat,Source Transaction Completed Interrupt Clear Bit" "0: Inactive signal,1: Clear the SRC_TRANSCOMP interrupt in the.."
            newline
            bitfld.quad 0x00 2. "RSVD_DMAC_CHx_INTCLEARREG_2,DMAC Channelx Interrupt Clear Register (bit 2) Reserved bit - Read Only" "0,1"
            newline
            bitfld.quad 0x00 1. "Clear_DMA_TFR_DONE_IntStat,DMA Transfer Done Interrupt Clear Bit" "0: Inactive signal,1: Clear the DMA_TFR_DONE interrupt in the.."
            newline
            bitfld.quad 0x00 0. "Clear_BLOCK_TFR_DONE_IntStat,Block Transfer Done Interrupt Clear Bit" "0: Inactive signal,1: Clear the interrupt in the Interrupt Status.."
tree.end

tree "DSP ()"
    base ad:0x84401000
    group.long 0x00++0x03
        line.long 0x00 "DSP_CTRL,DSP Subsystem control register"
            bitfld.long 0x00 12. "OCD_HALT_ON_RESET,If this signal is asserted on reset the core entres in OCD HaltMode" "0,1"
            newline
            bitfld.long 0x00 8. "STAT_VECTOR_SEL,Provide the capability to enable an alternate reset vector (static vector)" "0: selects the default vector location,1: selects the alternate location"
            newline
            rbitfld.long 0x00 4. "PWAITMODE,Indicates that the processor is in sleep mode" "0,1"
            newline
            bitfld.long 0x00 0. "RUNSTALL,Control the processor execution" "0,1"
    group.long 0x04++0x03
        line.long 0x00 "ALT_RESET_VEC,Alternate Reset Vector Location register"
            hexmask.long 0x00 0.--31. 1. "ALT_RESET_VEC,Memory address at which the alternate reset vector is located when the STAT_VECTOR_SEL bit is set"

    rgroup.long 0x08++0x03
        line.long 0x00 "PFAULT_INFO_LO,Fault Information register [31:0]"
            hexmask.long 0x00 0.--31. 1. "PFAULT_INFO_LO,Mirrors the processor's internal Fault Information Register (FIR) using the same bit encoding to provide the source and severity of the fault"
    rgroup.long 0x0C++0x03
        line.long 0x00 "PFAULT_INFO_HI,Fault Information register [63:32]"
            hexmask.long 0x00 0.--31. 1. "PFAULT_INFO_HI,Mirrors the processor's internal Fault Information Register (FIR) using the same bit encoding to provide the source and severity of the fault"

    group.long 0x10++0x03
        line.long 0x00 "SP2DSP_INT,Supervisory Processor to DSP Interrupt register"
            bitfld.long 0x00 2. "SP2DSP_LVL3_IRQ,SP to DSP interrupt (priority level 3)" "0,1"
            newline
            bitfld.long 0x00 1. "SP2DSP_LVL2_IRQ,SP to DSP interrupt (priority level 2)" "0,1"
            newline
            bitfld.long 0x00 0. "SP2DSP_LVL1_IRQ,SP to DSP interrupt (priority level 1)" "0,1"
    group.long 0x14++0x03
        line.long 0x00 "FUSA_IRQ_ENA,FUSA - DSP to Supervisory Processor Interrupt Enable"
            bitfld.long 0x00 0.--5. "FUSA_SP_IRQ_ENA,FUSA - DSP to SP Interrupt Enable" "?,1: DSP has encountered an arithmetic exception,2: Indicates that a correctable error has been..,?,4: This signal is asserted when the PFaultInfo..,?,?,?,8: Indicates when the signals mirrored in..,?,?,?,?,?,?,?,16: This signal is asserted when a fatal error..,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,32: This signal is asserted every time a double..,?..."

    wgroup.long 0x18++0x03
        line.long 0x00 "FUSA_IRQ_CLR,DSP to Supervisory Processor Interrupt Clear"
            bitfld.long 0x00 0.--5. "FUSA_SP_IRQ_CLR,DSP to SP Interrupt Clear" "?,1: DSP has encountered an arithmetic exception,2: Indicates that a correctable error has been..,?,4: This signal is asserted when the PFaultInfo..,?,?,?,8: Indicates when the signals mirrored in..,?,?,?,?,?,?,?,16: This signal is asserted when a fatal error..,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,32: This signal is asserted every time a double..,?..."

    rgroup.long 0x1C++0x03
        line.long 0x00 "FUSA_IRQ_STS,DSP to Supervisory Processor Interrupt Status"
            bitfld.long 0x00 0.--5. "FUSA_SP_IRQ_STS,DSP to SP Interrupt Status" "?,1: DSP has encountered an arithmetic exception,2: Indicates that a correctable error has been..,?,4: This signal is asserted when the PFaultInfo..,?,?,?,8: Indicates when the signals mirrored in..,?,?,?,?,?,?,?,16: This signal is asserted when a fatal error..,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,32: This signal is asserted every time a double..,?..."
    rgroup.long 0x20++0x03
        line.long 0x00 "FUSA_IRQ_ACT,Supervisory Processor Interrupt Active"
            bitfld.long 0x00 0.--5. "FUSA_SP_IRQ_ACT,FUSA interrupt status" "?,1: DSP has encountered an arithmetic exception,2: Indicates that a correctable error has been..,?,4: This signal is asserted when the PFaultInfo..,?,?,?,8: Indicates when the signals mirrored in..,?,?,?,?,?,?,?,16: This signal is asserted when a fatal error..,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,32: This signal is asserted every time a double..,?..."

    group.long 0x24++0x03
        line.long 0x00 "IRQ_ENA,DSP to Supervisory Processor Interrupt Enable"
            bitfld.long 0x00 0.--5. "SP_IRQ_ENA,DSP to SP Interrupt Enable" "?,1: GPIO32 line 0 rising edge interrupt from BBE..,2: GPIO32 line 1 rising edge interrupt from BBE..,?,4: GPIO32 line 2 rising edge interrupt from BBE..,?,?,?,8: Is asserted when the processor is in Debug..,?,?,?,?,?,?,?,16: Is asserted when the processor is in OCD..,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,32: Indicates the completion of an iDMA..,?..."

    wgroup.long 0x28++0x03
        line.long 0x00 "IRQ_CLR,DSP to Supervisory Processor Interrupt Clear"
            bitfld.long 0x00 0.--5. "SP_IRQ_CLR,DSP to SP Interrupt Clear" "?,1: GPIO32 line 0 rising edge interrupt from BBE..,2: GPIO32 line 1 rising edge interrupt from BBE..,?,4: GPIO32 line 2 rising edge interrupt from BBE..,?,?,?,8: Is asserted when the processor is in Debug..,?,?,?,?,?,?,?,16: Is asserted when the processor is in OCD..,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,32: Indicates the completion of an iDMA..,?..."

    rgroup.long 0x2C++0x03
        line.long 0x00 "IRQ_STS,DSP to Supervisory Processor Interrupt Status"
            bitfld.long 0x00 0.--5. "SP_IRQ_STS,DSP to SP Interrupt Status" "?,1: GPIO32 line 0 rising edge interrupt from BBE..,2: GPIO32 line 1 rising edge interrupt from BBE..,?,4: GPIO32 line 2 rising edge interrupt from BBE..,?,?,?,8: Is asserted when the processor is in Debug..,?,?,?,?,?,?,?,16: Is asserted when the processor is in OCD..,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,32: Indicates the completion of an iDMA..,?..."
    rgroup.long 0x30++0x03
        line.long 0x00 "IRQ_ACT,Supervisory Processor Interrupt Active"
            bitfld.long 0x00 0.--5. "SP_IRQ_ACT,SP Interrupt Active" "?,1: GPIO32 line 0 rising edge interrupt from BBE..,2: GPIO32 line 1 rising edge interrupt from BBE..,?,4: GPIO32 line 2 rising edge interrupt from BBE..,?,?,?,8: Is asserted when the processor is in Debug..,?,?,?,?,?,?,?,16: Is asserted when the processor is in OCD..,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,32: Indicates the completion of an iDMA..,?..."

    group.long 0x34++0x03
        line.long 0x00 "BBE_INTERNAL_SIGNALS_ENA,BBE internal signals interrupt enable"
            bitfld.long 0x00 0.--2. "BBE_INTERNAL_SIGNALS_ENA,BBE internal signals interrupt enable" "?,1: Indicates that a correctable error has been..,2: The core is interrupted when an arithmetic..,?,4: The core is interrupted when the BBE's..,?..."

    wgroup.long 0x38++0x03
        line.long 0x00 "BBE_INTERNAL_SIGNALS_CLR,BBE internal signals interrupt clear"
            bitfld.long 0x00 0.--2. "BBE_INTERNAL_SIGNALS_CLR,BBE internal signals interrupt clear" "?,1: Indicates that a correctable error has been..,2: The core is interrupted when an arithmetic..,?,4: The core is interrupted when the BBE's..,?..."

    rgroup.long 0x3C++0x03
        line.long 0x00 "BBE_INTERNAL_SIGNALS_STS,BBE internal signals interrupt status"
            bitfld.long 0x00 0.--2. "BBE_INTERNAL_SIGNALS_STS,BBE internal signals interrupt status" "?,1: Indicates that a correctable error has been..,2: The core is interrupted when an arithmetic..,?,4: The core is interrupted when the BBE's..,?..."
    rgroup.long 0x40++0x03
        line.long 0x00 "BBE_INTERNAL_SIGNALS_ACT,BBE internal signals interrupt status"
            bitfld.long 0x00 0.--2. "BBE_INTERNAL_SIGNALS_ACT,BBE internal signals interrupt status" "?,1: Indicates that a correctable error has been..,2: The core is interrupted when an arithmetic..,?,4: The core is interrupted when the BBE's..,?..."

    group.long 0x44++0x03
        line.long 0x00 "WWDT,Windowed WatchDog"
            rbitfld.long 0x00 11. "WWDT_HEARTBEAT_RB,This signal serves as an indicator to the SP of the operational status of the BBE" "0,1"
            newline
            bitfld.long 0x00 10. "WWDT_COUNTER_DISABLE,The Supervisory Processor possesses the capability to halt the internal counter of the WWDT through the activation of this signal" "0,1"
            newline
            bitfld.long 0x00 9. "WWDT_CLEAR,This signal can be asserted between the reset request and early reset request" "0,1"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "WWDT_STATUS,Mirrors the WWDT status resigers (Wwdt_faultInfo)"
    group.long 0x48++0x03
        line.long 0x00 "TRIGIN_IDMA,Input iDMA trigger"
            bitfld.long 0x00 0. "TRIGIN_IDMA,Triggers the iDMA (TrigIn signal)" "0,1"
    group.long 0x4C++0x03
        line.long 0x00 "GPIO_IRQ_DEBOUNCE,GPIO External Output debounce circuit configuration"
            bitfld.long 0x00 26. "DEBOUNCE_BYPASS_2,Bypass the debounce circuit for GPIO2 such that the input is connected directly to the core" "0,1"
            newline
            bitfld.long 0x00 25. "DEBOUNCE_BYPASS_1,Bypass the debounce circuit for GPIO1 such that the input is connected directly to the core" "0,1"
            newline
            bitfld.long 0x00 24. "DEBOUNCE_BYPASS_0,Bypass the debounce circuit for GPIO0 such that the input is connected directly to the core" "0,1"
            newline
            bitfld.long 0x00 20.--23. "DEBOUNCE_HYST_LOW_TO_HIGH_2,Number of DSP clock cycles during which signal should be high to be considered a high state" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 16.--19. "DEBOUNCE_HYST_HIGH_TO_LOW_2,Number of DSP clock cycles during which signal should be low to be considered a low state" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 12.--15. "DEBOUNCE_HYST_LOW_TO_HIGH_1,Number of DSP clock cycles during which signal should be high to be considered a high state" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 8.--11. "DEBOUNCE_HYST_HIGH_TO_LOW_1,Number of DSP clock cycles during which signal should be low to be considered a low state" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 4.--7. "DEBOUNCE_HYST_LOW_TO_HIGH_0,Number of DSP clock cycles during which signal should be high to be considered a high state" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0.--3. "DEBOUNCE_HYST_HIGH_TO_LOW_0,Number of DSP clock cycles during which signal should be low to be considered a low state" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x50++0x03
        line.long 0x00 "IDMA_TRIG_SEL,Idma Trigger selection"
            bitfld.long 0x00 0.--2. "IDMA_TRIG_SEL,Determines the peripheral connected to iDMA hardware trigger" "?,1: The iDMA is trigerred by the R52 throught..,2: TrigIn and TrigOut are connected to RA..,?,4: TrigIn and TrigOut are connected to Auxiliary..,?..."
    group.long 0x54++0x03
        line.long 0x00 "TEST_MUX_CONTROL,TestMuxControl"
            bitfld.long 0x00 0.--4. "TEST_MUX_CTRL_1,TestMuxControl" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
    group.long 0x58++0x03
        line.long 0x00 "CTL_LOCK,Lock control"
            hexmask.long 0x00 0.--31. 1. "CTL_BBE_LOCK_KEY,Write 0X0BEEF678 to allow write access to this SFR bank"

    rgroup.long 0x5C++0x03
        line.long 0x00 "STS_LOCK,Lock status"
            bitfld.long 0x00 0. "STS_BBE_LOCK_N,Lock status for this SFR bank" "0,1"

    group.long 0x60++0x03
        line.long 0x00 "SPARE,Spare Register"
            hexmask.long 0x00 0.--31. 1. "SPARE,Spare registers"
tree.end

tree "ETHER ()"
    base ad:0x8A000000
    group.long 0x00++0x03
        line.long 0x00 "MAC_Configuration,The MAC Configuration Register establishes the operating mode of the MAC"
            bitfld.long 0x00 31. "ARPEN,ARP Offload Enable When this bit is set the MAC can recognize an incoming ARP request packet and schedules the ARP packet for transmission" "0: ARP Offload is disabled,1: ARP Offload is enabled"
            newline
            bitfld.long 0x00 28.--30. "SARC,Source Address Insertion or Replacement Control This field controls the source address insertion or replacement for all transmitted packets" "0: mti_sa_ctrl_i and ati_sa_ctrl_i input signals..,?,2: Contents of MAC Addr-0 inserted in SA field,3: Contents of MAC Addr-0 replaces SA field,?,?,6: Contents of MAC Addr-1 inserted in SA field,7: Contents of MAC Addr-1 replaces SA field"
            newline
            bitfld.long 0x00 27. "IPC,Checksum Offload When set this bit enables the IPv4 header checksum checking and IPv4 or IPv6 TCP UDP or ICMP payload checksum checking" "0: IP header/payload checksum checking is disabled,1: IP header/payload checksum checking is enabled"
            newline
            bitfld.long 0x00 24.--26. "IPG,Inter-Packet Gap These bits control the minimum IPG between packets during transmission" "0: 96 bit times IPG,1: 88 bit times IPG,2: 80 bit times IPG,3: 72 bit times IPG,4: 64 bit times IPG,5: 56 bit times IPG,6: 48 bit times IPG,7: 40 bit times IPG"
            newline
            bitfld.long 0x00 23. "GPSLCE,Giant Packet Size Limit Control Enable When this bit is set the MAC considers the value in GPSL field in MAC_Ext_Configuration register to declare a received packet as Giant packet" "0: Giant Packet Size Limit Control is disabled,1: Giant Packet Size Limit Control is enabled"
            newline
            bitfld.long 0x00 22. "S2KP,IEEE 802.3as Support for 2K Packets When this bit is set the MAC considers all packets with up to 2 000 bytes length as normal packets" "0: Support upto 2K packet is disabled,1: Support upto 2K packet is Enabled"
            newline
            bitfld.long 0x00 21. "CST,CRC stripping for Type packets" "0: CRC stripping for Type packets is disabled,1: CRC stripping for Type packets is enabled"
            newline
            bitfld.long 0x00 20. "ACS,Automatic Pad or CRC Stripping" "0: Automatic Pad or CRC Stripping is disabled,1: Automatic Pad or CRC Stripping is enabled"
            newline
            bitfld.long 0x00 19. "WD,Watchdog Disable When this bit is set the MAC disables the watchdog timer on the receiver" "0: Watchdog is enabled,1: Watchdog is disabled"
            newline
            bitfld.long 0x00 18. "BE,Packet Burst Enable When this bit is set the MAC allows packet bursting during transmission in the GMII half-duplex mode" "0: Packet Burst is disabled,1: Packet Burst is enabled"
            newline
            bitfld.long 0x00 17. "JD,Jabber Disable When this bit is set the MAC disables the jabber timer on the transmitter" "0: Jabber is enabled,1: Jabber is disabled"
            newline
            bitfld.long 0x00 16. "JE,Jumbo Packet Enable When this bit is set the MAC allows jumbo packets of 9 018 bytes (9 022 bytes for VLAN tagged packets) without reporting a giant packet error in the Rx packet status" "0: Jumbo packet is disabled,1: Jumbo packet is enabled"
            newline
            bitfld.long 0x00 15. "PS,Port Select This bit selects the Ethernet line speed" "0: For 1000 or 2500 Mbps operations,1: For 10 or 100 Mbps operations"
            newline
            bitfld.long 0x00 14. "FES,Speed This bit selects the speed mode" "0: 10 Mbps when PS bit is 1 and 1 Gbps when PS..,1: 100 Mbps when PS bit is 1 and 2.5 Gbps when.."
            newline
            bitfld.long 0x00 13. "DM,Duplex Mode When this bit is set the MAC operates in the full-duplex mode in which it can transmit and receive simultaneously" "0: Half-duplex mode,1: Full-duplex mode"
            newline
            bitfld.long 0x00 12. "LM,Loopback Mode When this bit is set the MAC operates in the loopback mode at GMII or MII" "0: Loopback is disabled,1: Loopback is enabled"
            newline
            bitfld.long 0x00 11. "ECRSFD,Enable Carrier Sense Before Transmission in Full-Duplex Mode When this bit is set the MAC transmitter checks the CRS signal before packet transmission in the full-duplex mode" "0: ECRSFD is disabled,1: ECRSFD is enabled"
            newline
            bitfld.long 0x00 10. "DO,Disable Receive Own When this bit is set the MAC disables the reception of packets when the gmii_txen_o is asserted in the half-duplex mode" "0: Enable Receive Own,1: Disable Receive Own"
            newline
            bitfld.long 0x00 9. "DCRS,Disable Carrier Sense During Transmission When this bit is set the MAC transmitter ignores the (G)MII CRS signal during packet transmission in the half-duplex mode" "0: Enable Carrier Sense During Transmission,1: Disable Carrier Sense During Transmission"
            newline
            bitfld.long 0x00 8. "DR,Disable Retry When this bit is set the MAC attempts only one transmission" "0: Enable Retry,1: Disable Retry"
            newline
            rbitfld.long 0x00 7. "Reserved_7,Reserved" "0,1"
            newline
            bitfld.long 0x00 5.--6. "BL,Back-Off Limit The back-off limit determines the random integer number (r) of slot time delays (4 096 bit times for 1000/2500 Mbps 512 bit times for 10/100 Mbps) for which the MAC waits before rescheduling a transmission attempt during retries after.." "0: k = min(n 10),1: k = min(n 8),2: k = min(n 4),3: k = min(n 1)"
            newline
            bitfld.long 0x00 4. "DC,Deferral Check When this bit is set the deferral check function is enabled in the MAC" "0: Deferral check function is disabled,1: Deferral check function is enabled"
            newline
            bitfld.long 0x00 2.--3. "PRELEN,Preamble Length for Transmit packets These bits control the number of preamble bytes that are added to the beginning of every Tx packet" "0: 7 bytes of preamble,1: 5 bytes of preamble,2: 3 bytes of preamble,?..."
            newline
            bitfld.long 0x00 1. "TE,Transmitter Enable When this bit is set the Tx state machine of the MAC is enabled for transmission on the GMII or MII interface" "0: Transmitter is disabled,1: Transmitter is enabled"
            newline
            bitfld.long 0x00 0. "RE,Receiver Enable When this bit is set the Rx state machine of the MAC is enabled for receiving packets from the GMII or MII interface" "0: Receiver is disabled,1: Receiver is enabled"
    group.long 0x04++0x03
        line.long 0x00 "MAC_Ext_Configuration,The MAC Extended Configuration Register establishes the operating mode of the MAC"
            rbitfld.long 0x00 31. "Reserved_FHE,Reserved" "0,1"
            newline
            bitfld.long 0x00 30. "APDIM,ARP Packet Drop if IP Address Mismatch When this bit is set Packet for which Target Protocol Address does not match IPv4 address is dropped in the MTL layer" "0: mux select to drop the arp packet if target..,1: mux select to drop the arp packet if target.."
            newline
            bitfld.long 0x00 25.--29. "EIPG,Extended Inter-Packet Gap The value in this field is applicable when the EIPGEN bit of this register is 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 24. "EIPGEN,Extended Inter-Packet Gap Enable" "0: Extended Inter-Packet Gap is disabled,1: Extended Inter-Packet Gap is enabled"
            newline
            rbitfld.long 0x00 23. "Reserved_23,Reserved" "0,1"
            newline
            bitfld.long 0x00 20.--22. "HDSMS,Maximum Size for Splitting the Header Data These bits indicate the maximum header size allowed for splitting the header data in the received packet" "0: Maximum Size for Splitting the Header Data is..,1: Maximum Size for Splitting the Header Data is..,2: Maximum Size for Splitting the Header Data is..,3: Maximum Size for Splitting the Header Data is..,4: Maximum Size for Splitting the Header Data is..,?..."
            newline
            bitfld.long 0x00 19. "PDC,Packet Duplication Control" "0: Packet Duplication Control is disabled,1: Packet Duplication Control is enabled"
            newline
            bitfld.long 0x00 18. "USP,Unicast Slow Protocol Packet Detect When this bit is set the MAC detects the Slow Protocol packets with unicast address of the station specified in the MAC_Address0_High and MAC_Address0_Low registers" "0: Unicast Slow Protocol Packet Detection is..,1: Unicast Slow Protocol Packet Detection is.."
            newline
            bitfld.long 0x00 17. "SPEN,Slow Protocol Detection Enable" "0: Slow Protocol Detection is disabled,1: Slow Protocol Detection is enabled"
            newline
            bitfld.long 0x00 16. "DCRCC,Disable CRC Checking for Received Packets When this bit is set the MAC receiver does not check the CRC field in the received packets" "0: CRC Checking is enabled,1: CRC Checking is disabled"
            newline
            rbitfld.long 0x00 14.--15. "Reserved_15_14,Reserved" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--13. 1. "GPSL,Giant Packet Size Limit If the received packet size is greater than the value programmed in this field in units of bytes the MAC declares the received packet as Giant packet"
    group.long 0x08++0x03
        line.long 0x00 "MAC_Packet_Filter,The MAC Packet Filter register contains the filter controls for receiving packets"
            bitfld.long 0x00 31. "RA,Receive All" "0: Receive All is disabled,1: Receive All is enabled"
            newline
            hexmask.long.word 0x00 22.--30. 1. "Reserved_30_22,Reserved"
            newline
            bitfld.long 0x00 21. "DNTU,Drop Non-TCP/UDP over IP Packets When this bit is set the MAC drops the non-TCP or UDP over IP packets" "0: Forward Non-TCP/UDP over IP Packets,1: Drop Non-TCP/UDP over IP Packets"
            newline
            bitfld.long 0x00 20. "IPFE,Layer 3 and Layer 4 Filter Enable When this bit is set the MAC drops packets that do not match the enabled Layer 3 and Layer 4 filters" "0: Layer 3 and Layer 4 Filters are disabled,1: Layer 3 and Layer 4 Filters are enabled"
            newline
            rbitfld.long 0x00 17.--19. "Reserved_19_17,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 16. "VTFE,VLAN Tag Filter Enable When this bit is set the MAC drops the VLAN tagged packets that do not match the VLAN Tag" "0: VLAN Tag Filter is disabled,1: VLAN Tag Filter is enabled"
            newline
            rbitfld.long 0x00 11.--15. "Reserved_15_11,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 10. "HPF,Hash or Perfect Filter When this bit is set the address filter passes a packet if it matches either the perfect filtering or hash filtering as set by the HMC or HUC bit" "0: Hash or Perfect Filter is disabled,1: Hash or Perfect Filter is enabled"
            newline
            bitfld.long 0x00 9. "SAF,Source Address Filter Enable" "0: SA Filtering is disabled,1: SA Filtering is enabled"
            newline
            bitfld.long 0x00 8. "SAIF,SA Inverse Filtering When this bit is set the Address Check block operates in the inverse filtering mode for SA address comparison" "0: SA Inverse Filtering is disabled,1: SA Inverse Filtering is enabled"
            newline
            bitfld.long 0x00 6.--7. "PCF,Pass Control Packets These bits control the forwarding of all control packets (including unicast and multicast Pause packets)" "0: MAC filters all control packets from reaching..,1: MAC forwards all control packets except Pause..,2: MAC forwards all control packets to the..,3: MAC forwards the control packets that pass.."
            newline
            bitfld.long 0x00 5. "DBF,Disable Broadcast Packets When this bit is set the AFM module blocks all the incoming broadcast packets" "0: Enable Broadcast Packets,1: Disable Broadcast Packets"
            newline
            bitfld.long 0x00 4. "PM,Pass All Multicast When this bit is set it indicates that all the received packets with a multicast destination address (first bit in the destination address field is '1') are passed" "0: Pass All Multicast is disabled,1: Pass All Multicast is enabled"
            newline
            bitfld.long 0x00 3. "DAIF,DA Inverse Filtering When this bit is set the Address Check block operates in inverse filtering mode for the DA address comparison for both unicast and multicast packets" "0: DA Inverse Filtering is disabled,1: DA Inverse Filtering is enabled"
            newline
            bitfld.long 0x00 2. "HMC,Hash Multicast" "0: Hash Multicast is disabled,1: Hash Multicast is enabled"
            newline
            bitfld.long 0x00 1. "HUC,Hash Unicast" "0: Hash Unicast is disabled,1: Hash Unicast is enabled"
            newline
            bitfld.long 0x00 0. "PR,Promiscuous Mode" "0: Promiscuous Mode is disabled,1: Promiscuous Mode is enabled"
    group.long 0x0C++0x03
        line.long 0x00 "MAC_WD_JB_Timeout,The Watchdog and Jabber Timeout register controls the watchdog timeout limit for received packets and jabber timeout limit for transmitted packets"
            hexmask.long.byte 0x00 25.--31. 1. "Reserved_31_25,Reserved"
            newline
            bitfld.long 0x00 24. "PJE,Programmable Jabber Enable When this bit is set and the JD bit of the MAC_Configuration register is reset the JTO field is used as jabber timeout limit for a transmitted packet" "0: Programmable Jabber is disabled,1: Programmable Jabber is enabled"
            newline
            rbitfld.long 0x00 20.--23. "Reserved_23_20,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 16.--19. "JTO,Jabber Timeout When the PJE bit is set and the JD bit of the MAC_Configuration register is reset this field is used as jabber timeout limit for a transmitted packet" "0: M_2KBYTES,1: M_3KBYTES,2: M_4KBYTES,3: M_5KBYTES,4: M_6KBYTES,5: M_7KBYTES,6: M_8KBYTES,7: M_9KBYTES,8: M_10KBYTES,9: M_11KBYTES,10: M_12KBYTES,11: M_13KBYTES,12: M_14KBYTES,13: M_15KBYTES,14: M_16383BYTES,?..."
            newline
            hexmask.long.byte 0x00 9.--15. 1. "Reserved_15_9,Reserved"
            newline
            bitfld.long 0x00 8. "PWE,Programmable Watchdog Enable When this bit is set and the WD bit of the MAC_Configuration register is reset the WTO field is used as watchdog timeout limit for a received packet" "0: Programmable Watchdog is disabled,1: Programmable Watchdog is enabled"
            newline
            rbitfld.long 0x00 4.--7. "Reserved_7_4,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 0.--3. "WTO,Watchdog Timeout When the PWE bit is set and the WD bit of the MAC_Configuration register is reset this field is used as watchdog timeout limit for a received packet" "0: M_2KBYTES,1: M_3KBYTES,2: M_4KBYTES,3: M_5KBYTES,4: M_6KBYTES,5: M_7KBYTES,6: M_8KBYTES,7: M_9KBYTES,8: M_10KBYTES,9: M_11KBYTES,10: M_12KBYTES,11: M_13KBYTES,12: M_14KBYTES,13: M_15KBYTES,14: M_16383BYTES,?..."
    group.long 0x10++0x03
        line.long 0x00 "MAC_Hash_Table_Reg0,The Hash Table Register 0 contains the first 32 bits of the hash table when the width of the hash table is 128 or 256 bits"
            hexmask.long 0x00 0.--31. 1. "HT31T0,MAC Hash Table First 32 Bits This field contains the first 32 Bits [31:0] of the Hash table"
    group.long 0x14++0x03
        line.long 0x00 "MAC_Hash_Table_Reg1,The Hash Table Register 1 contains the second 32 bits of the hash table"
            hexmask.long 0x00 0.--31. 1. "HT63T32,MAC Hash Table Second 32 Bits This field contains the second 32 Bits [63:32] of the Hash table"
    group.long 0x50++0x03
        line.long 0x00 "MAC_VLAN_Tag_Ctrl,This register is the redefined format of the MAC VLAN Tag Register"
            bitfld.long 0x00 31. "EIVLRXS,Enable Inner VLAN Tag in Rx Status" "0: Inner VLAN Tag in Rx status is disabled,1: Inner VLAN Tag in Rx status is enabled"
            newline
            rbitfld.long 0x00 30. "Reserved_30,Reserved" "0,1"
            newline
            bitfld.long 0x00 28.--29. "EIVLS,Enable Inner VLAN Tag Stripping on Receive This field indicates the stripping operation on inner VLAN Tag in received packet" "0: Do not strip,1: Strip if VLAN filter passes,2: Strip if VLAN filter fails,3: Always strip"
            newline
            bitfld.long 0x00 27. "ERIVLT,Enable Inner VLAN Tag Comparison When this bit VTHM bit and the EDVLP field are set the MAC receiver enables VLAN Hash filtering operation on the inner VLAN Tag (if present)" "0: Inner VLAN tag is disabled,1: Inner VLAN tag is enabled"
            newline
            bitfld.long 0x00 26. "EDVLP,Enable Double VLAN Processing" "0: Double VLAN Processing is disabled,1: Double VLAN Processing is enabled"
            newline
            bitfld.long 0x00 25. "VTHM,VLAN Tag Hash Table Match Enable" "0: VLAN Tag Hash Table Match is disabled,1: VLAN Tag Hash Table Match is enabled"
            newline
            bitfld.long 0x00 24. "EVLRXS,Enable VLAN Tag in Rx status" "0: VLAN Tag in Rx status is disabled,1: VLAN Tag in Rx status is enabled"
            newline
            rbitfld.long 0x00 23. "Reserved_23,Reserved" "0,1"
            newline
            bitfld.long 0x00 21.--22. "EVLS,Enable VLAN Tag Stripping on Receive This field indicates the stripping operation on the outer VLAN Tag in received packet" "0: Do not strip,1: Strip if VLAN filter passes,2: Strip if VLAN filter fails,3: Always strip"
            newline
            bitfld.long 0x00 20. "DOVLTC,Disable VLAN Type Check for VLAN Hash Filtering" "0: VLAN Type Check is enabled,1: VLAN Type Check is disabled"
            newline
            bitfld.long 0x00 19. "ERSVLM,Enable Receive S-VLAN Match for VLAN Hash Filtering" "0: Receive S-VLAN Match is disabled,1: Receive S-VLAN Match is enabled"
            newline
            bitfld.long 0x00 18. "ESVL,Enable S-VLAN" "0: S-VLAN is disabled,1: S-VLAN is enabled"
            newline
            bitfld.long 0x00 17. "VTIM,VLAN Tag Inverse Match Enable" "0: VLAN Tag Inverse Match is disabled,1: VLAN Tag Inverse Match is enabled"
            newline
            bitfld.long 0x00 16. "ETV,Enable 12-Bit VLAN Tag Comparison for VLAN Hash Filtering" "0: 12-Bit VLAN Tag Comparison is disabled,1: 12-Bit VLAN Tag Comparison is enabled"
            newline
            hexmask.long.word 0x00 7.--15. 1. "Reserved_15_y,Reserved"
            newline
            bitfld.long 0x00 2.--6. "OFS,Offset This field holds the address offset of the MAC VLAN Tag Filter Register which the application is trying to access" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 1. "CT,Command Type This bit indicates if the current register access is a read or a" "0: Write operation,1: Read operation"
            newline
            bitfld.long 0x00 0. "OB,Operation Busy - Software writes 1 in this bit to initiate an indirect read or write access to the MAC_VLAN_Tag register" "0: Operation Busy is disabled,1: Operation Busy is enabled"
    group.long 0x54++0x03
        line.long 0x00 "MAC_VLAN_Tag_Data,This register holds the read or write data for the indirect access of the MAC_VLAN_Tag_Filter(#i) registers"
            rbitfld.long 0x00 26.--31. "Reserved_31_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 25. "DMACHN,DMA Channel Number The DMA Channel number to which the VLAN Tagged Frame is to be routed if it passes this VLAN Tag Filter is programmed in this field" "0,1"
            newline
            bitfld.long 0x00 24. "DMACHEN,DMA Channel Number Enable" "0: DMA Channel Number is disabled,1: DMA Channel Number is enabled"
            newline
            rbitfld.long 0x00 21.--23. "Reserved_23_21,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 20. "ERIVLT,Enable Inner VLAN Tag Comparison This bit is valid only when Double VLAN Tag Enable of the Filter is set" "0: Inner VLAN tag comparison is disabled,1: Inner VLAN tag comparison is enabled"
            newline
            bitfld.long 0x00 19. "ERSVLM,Enable S-VLAN Match for received Frames This bit is valid only when you enable the VLAN Tag by programming the VEN field of the MAC_VLAN_Tag_Filter(#i) register" "0: Receive S-VLAN Match is disabled,1: Receive S-VLAN Match is enabled"
            newline
            bitfld.long 0x00 18. "DOVLTC,Disable VLAN Type Comparison This bit is valid only when you enable the VLAN Tag by programming the VEN field of the MAC_VLAN_Tag_Filter(#i) register" "0: VLAN type comparison is enabled,1: VLAN type comparison is disabled"
            newline
            bitfld.long 0x00 17. "ETV,12-Bit or 16-Bit VLAN Comparison This bit is valid only when you enable the VLAN Tag by programming the VEN field of the corresponding MAC_VLAN_Tag_Filter(#i) register" "0: 16 bit VLAN comparison,1: 12 bit VLAN comparison"
            newline
            bitfld.long 0x00 16. "VEN,VLAN Tag Enable This bit is used to enable or disable the VLAN Tag" "0: VLAN Tag is disabled,1: VLAN Tag is enabled"
            newline
            hexmask.long.word 0x00 0.--15. 1. "VID,VLAN Tag ID This field holds the VLAN Tag value which is used by the MAC for perfect comparison"
    group.long 0x58++0x03
        line.long 0x00 "MAC_VLAN_Hash_Table,When VTHM bit of the MAC_VLAN_Tag register is set the 16-bit VLAN Hash Table register is used for group address filtering based on the VLAN tag"
            hexmask.long.word 0x00 16.--31. 1. "Reserved_31_16,Reserved"
            newline
            hexmask.long.word 0x00 0.--15. 1. "VLHT,VLAN Hash Table This field contains the 16-bit VLAN Hash Table"
    group.long 0x60++0x03
        line.long 0x00 "MAC_VLAN_Incl,The VLAN Tag Inclusion or Replacement register contains the VLAN tag for insertion or replacement in the Transmit packets"
            rbitfld.long 0x00 31. "BUSY,Busy Indicates the status of the read operation from and write operation to the indirect access of the queue or channel specific VLAN inclusion register" "0: Busy status not detected,1: Busy status detected"
            newline
            bitfld.long 0x00 30. "RDWR,Read write control This bit controls the read or write operation for indirectly accessing the queue/channel specific VLAN Inclusion register" "0: Read operation of indirect access,1: Write operation of indirect access"
            newline
            rbitfld.long 0x00 26.--29. "Reserved_29_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 24.--25. "ADDR,Address This field selects one of the queue/channel specific VLAN Inclusion register for read/write access" "0,1,2,3"
            newline
            rbitfld.long 0x00 22.--23. "Reserved_23_22,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 21. "CBTI,Channel based tag insertion When this bit is set outer VLAN tag is inserted for every packets transmitted by the MAC" "0: Channel based tag insertion is disabled,1: Channel based tag insertion is enabled"
            newline
            bitfld.long 0x00 20. "VLTI,VLAN Tag Input When this bit is set it indicates that the VLAN tag to be inserted or replaced in Tx packet must be taken from: - The Tx descriptor" "0: VLAN Tag Input is disabled,1: VLAN Tag Input is enabled"
            newline
            bitfld.long 0x00 19. "CSVL,C-VLAN or S-VLAN When this bit is set S-VLAN type (0x88A8) is inserted or replaced in the 13th and 14th bytes of transmitted packets" "0: C-VLAN type (0x8100) is inserted or replaced,1: S-VLAN type (0x88A8) is inserted or replaced"
            newline
            bitfld.long 0x00 18. "VLP,VLAN Priority Control When this bit is set the control bits[17:16] are used for VLAN deletion insertion or replacement" "0: VLAN Priority Control is disabled,1: VLAN Priority Control is enabled"
            newline
            bitfld.long 0x00 16.--17. "VLC,VLAN Tag Control in Transmit Packets" "0: No VLAN tag deletion insertion or replacement,1: VLAN tag deletion,2: VLAN tag insertion,3: VLAN tag replacement"
            newline
            hexmask.long.word 0x00 0.--15. 1. "VLT,VLAN Tag for Transmit Packets This field contains the value of the VLAN tag to be inserted or replaced"
    group.long 0x64++0x03
        line.long 0x00 "MAC_Inner_VLAN_Incl,The Inner VLAN Tag Inclusion or Replacement register contains the inner VLAN tag to be inserted or replaced in the Transmit packet"
            hexmask.long.word 0x00 21.--31. 1. "Reserved_31_21,Reserved"
            newline
            bitfld.long 0x00 20. "VLTI,VLAN Tag Input When this bit is set it indicates that the VLAN tag to be inserted or replaced in Tx packet must be taken from: - The Tx descriptor" "0: VLAN Tag Input is disabled,1: VLAN Tag Input is enabled"
            newline
            bitfld.long 0x00 19. "CSVL,C-VLAN or S-VLAN" "0: C-VLAN type (0x8100) is inserted,1: S-VLAN type (0x88A8) is inserted"
            newline
            bitfld.long 0x00 18. "VLP,VLAN Priority Control" "0: VLAN Priority Control is disabled,1: VLAN Priority Control is enabled"
            newline
            bitfld.long 0x00 16.--17. "VLC,VLAN Tag Control in Transmit Packets" "0: No VLAN tag deletion insertion or replacement,1: VLAN tag deletion,2: VLAN tag insertion,3: VLAN tag replacement"
            newline
            hexmask.long.word 0x00 0.--15. 1. "VLT,VLAN Tag for Transmit Packets This field contains the value of the VLAN tag to be inserted or replaced"
    group.long 0x70++0x03
        line.long 0x00 "MAC_Q0_Tx_Flow_Ctrl,The Flow Control register controls the generation and reception of the Control (Pause Command) packets by the Flow control module of the MAC"
            hexmask.long.word 0x00 16.--31. 1. "PT,Pause Time This field holds the value to be used in the Pause Time field in the Tx control packet"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "Reserved_15_8,Reserved"
            newline
            bitfld.long 0x00 7. "DZPQ,Disable Zero-Quanta Pause When this bit is set it disables the automatic generation of the zero-quanta Pause packets on de-assertion of the flow-control signal from the FIFO layer (MTL or external sideband flow control signal sbd_flowctrl_i or.." "0: Zero-Quanta Pause packet generation is enabled,1: Zero-Quanta Pause packet generation is disabled"
            newline
            bitfld.long 0x00 4.--6. "PLT,Pause Low Threshold This field configures the threshold of the Pause timer at which the input flow control signal mti_flowctrl_i (or sbd_flowctrl_i) is checked for automatic retransmission of the Pause packet" "0: Pause Time minus 4 Slot Times (PT -4 slot..,1: Pause Time minus 28 Slot Times (PT -28 slot..,2: Pause Time minus 36 Slot Times (PT -36 slot..,3: Pause Time minus 144 Slot Times (PT -144 slot..,4: Pause Time minus 256 Slot Times (PT -256 slot..,5: Pause Time minus 512 Slot Times (PT -512 slot..,?..."
            newline
            rbitfld.long 0x00 2.--3. "Reserved_3_2,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 1. "TFE,Transmit Flow Control Enable Full-Duplex Mode: In the full-duplex mode when this bit is set the MAC enables the flow control operation to Tx Pause packets" "0: Transmit Flow Control is disabled,1: Transmit Flow Control is enabled"
            newline
            bitfld.long 0x00 0. "FCB_BPA,Flow Control Busy or Backpressure Activate This bit initiates a Pause packet in the full-duplex mode and activates the backpressure function in the half-duplex mode if the TFE bit is set" "0: Flow Control Busy or Backpressure Activate is..,1: Flow Control Busy or Backpressure Activate is.."
    group.long 0x74++0x03
        line.long 0x00 "MAC_Q1_Tx_Flow_Ctrl,This register controls the generation of PFC Control packets of priorities mapped as per the PSRQ1 field in the MAC_RxQ_Ctrl2/MAC_RxQ_Ctrl3 registers"
            hexmask.long.word 0x00 16.--31. 1. "PT,Pause Time This field holds the value to be used in the Pause Time field in the Tx control packet"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "Reserved_15_8,Reserved"
            newline
            bitfld.long 0x00 7. "DZPQ,Disable Zero-Quanta Pause When this bit is set it disables the automatic generation of the zero-quanta Pause packets on de-assertion of the flow-control signal from the FIFO layer (MTL or external sideband flow control signal sbd_flowctrl_i or.." "0: Zero-Quanta Pause packet generation is enabled,1: Zero-Quanta Pause packet generation is disabled"
            newline
            bitfld.long 0x00 4.--6. "PLT,Pause Low Threshold This field configures the threshold of the Pause timer at which the input flow control signal mti_flowctrl_i (or sbd_flowctrl_i) is checked for automatic retransmission of the Pause packet" "0: Pause Time minus 4 Slot Times (PT -4 slot..,1: Pause Time minus 28 Slot Times (PT -28 slot..,2: Pause Time minus 36 Slot Times (PT -36 slot..,3: Pause Time minus 144 Slot Times (PT -144 slot..,4: Pause Time minus 256 Slot Times (PT -256 slot..,5: Pause Time minus 512 Slot Times (PT -512 slot..,?..."
            newline
            rbitfld.long 0x00 2.--3. "Reserved_3_2,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 1. "TFE,Transmit Flow Control Enable When this bit is set in full-duplex mode the MAC enables the flow control operation to Tx pause packets" "0: Transmit Flow Control is disabled,1: Transmit Flow Control is enabled"
            newline
            bitfld.long 0x00 0. "FCB_BPA,Flow Control Busy This bit initiates a PFC packet if the TFE bit is set" "0: Flow Control Busy or Backpressure Activate is..,1: Flow Control Busy or Backpressure Activate is.."
    group.long 0x90++0x03
        line.long 0x00 "MAC_Rx_Flow_Ctrl,The Receive Flow Control register controls the pausing of MAC Transmit based on the received Pause packet"
            hexmask.long.tbyte 0x00 9.--31. 1. "Reserved_31_9,Reserved"
            newline
            bitfld.long 0x00 8. "PFCE,Priority Based Flow Control Enable When this bit is set it enables generation and reception of priority-based flow control (PFC) packets" "0: Priority Based Flow Control is disabled,1: Priority Based Flow Control is enabled"
            newline
            rbitfld.long 0x00 2.--7. "Reserved_7_2,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 1. "UP,Unicast Pause Packet Detect A pause packet is processed when it has the unique multicast address specified in the IEEE 802.3" "0: Unicast Pause Packet Detect disabled,1: Unicast Pause Packet Detect enabled"
            newline
            bitfld.long 0x00 0. "RFE,Receive Flow Control Enable When this bit is set and the MAC is operating in full-duplex mode the MAC decodes the received Pause packet and disables its transmitter for a specified (Pause) time" "0: Receive Flow Control is disabled,1: Receive Flow Control is enabled"
    group.long 0x94++0x03
        line.long 0x00 "MAC_RxQ_Ctrl4,The Receive Queue Control 4 register controls the routing of unicast and multicast packets that fail the Destination or Source address filter to the Rx queues"
            bitfld.long 0x00 31. "UDC,Unicast Packet Duplication Control When this bit is set along with PDC bit of the MAC_Ext_Configuration register the MAC provides DMA Channel number specified as one-hot value in DCS field of MAC_Address(#i)_High register that matched the Unicast.." "0: Unicast packet duplication is disabled,1: Unicast packet duplication is enabled"
            newline
            hexmask.long.word 0x00 18.--30. 1. "Reserved_30_y,Reserved"
            newline
            bitfld.long 0x00 17. "VFFQ,VLAN Tag Filter Fail Packets Queue This field holds the Rx queue number to which the tagged packets failing the Destination or Source Address filter (and UFFQE/MFFQE not enabled) or failing the VLAN tag filter must be routed to" "0,1"
            newline
            bitfld.long 0x00 16. "VFFQE,VLAN Tag Filter Fail Packets Queuing Enable When this bit is set the tagged packets which fail the Destination or Source address filter or fail the VLAN tag filter are routed to the Rx Queue Number programmed in the VFFQ" "0: VLAN tag Filter Fail Packets Queuing is..,1: VLAN tag Filter Fail Packets Queuing is enabled"
            newline
            rbitfld.long 0x00 10.--15. "Reserved_15_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 9. "MFFQ,Multicast Address Filter Fail Packets Queue" "0,1"
            newline
            bitfld.long 0x00 8. "MFFQE,Multicast Address Filter Fail Packets Queuing Enable" "0: Multicast Address Filter Fail Packets Queuing..,1: Multicast Address Filter Fail Packets Queuing.."
            newline
            rbitfld.long 0x00 2.--7. "Reserved_7_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 1. "UFFQ,Unicast Address Filter Fail Packets Queue" "0,1"
            newline
            bitfld.long 0x00 0. "UFFQE,Unicast Address Filter Fail Packets Queuing Enable" "0: Unicast Address Filter Fail Packets Queuing..,1: Unicast Address Filter Fail Packets Queuing.."
    group.long 0x98++0x03
        line.long 0x00 "MAC_TxQ_Prty_Map0,The Transmit Queue Priority Mapping 0 register contains the priority values assigned to Tx Queue 0 through Tx Queue 3"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_PSTQ3,Reserved"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "PSTQ2,Priorities Selected in Transmit Queue 2 This bit is similar to the PSTQ0 bit"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "PSTQ1,Priorities Selected in Transmit Queue 1 This bit is similar to the PSTQ0 bit"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "PSTQ0,Priorities Selected in Transmit Queue 0 This field holds the priorities assigned to Tx Queue 0 by the software"
    group.long 0xA0++0x03
        line.long 0x00 "MAC_RxQ_Ctrl0,The Receive Queue Control 0 register controls the queue management in the MAC Receiver"
            hexmask.long.word 0x00 16.--31. 1. "Reserved_31_16,Reserved"
            newline
            rbitfld.long 0x00 14.--15. "Reserved_RXQ7EN,Reserved" "0,1,2,3"
            newline
            rbitfld.long 0x00 12.--13. "Reserved_RXQ6EN,Reserved" "0,1,2,3"
            newline
            rbitfld.long 0x00 10.--11. "Reserved_RXQ5EN,Reserved" "0,1,2,3"
            newline
            rbitfld.long 0x00 8.--9. "Reserved_RXQ4EN,Reserved" "0,1,2,3"
            newline
            rbitfld.long 0x00 6.--7. "Reserved_RXQ3EN,Reserved" "0,1,2,3"
            newline
            rbitfld.long 0x00 4.--5. "Reserved_RXQ2EN,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 2.--3. "RXQ1EN,Receive Queue 1 Enable This field is similar to the RXQ0EN field" "0: Queue not enabled,1: Queue enabled for AV,2: Queue enabled for DCB/Generic,?..."
            newline
            bitfld.long 0x00 0.--1. "RXQ0EN,Receive Queue 0 Enable This field indicates whether Rx Queue 0 is enabled for AV (2'b01) or DCB (2'b10) or Generic (2'b10)" "0: Queue not enabled,1: Queue enabled for AV,2: Queue enabled for DCB/Generic,?..."
    group.long 0xA4++0x03
        line.long 0x00 "MAC_RxQ_Ctrl1,The Receive Queue Control 1 register controls the routing of multicast broadcast AV DCB and untagged packets to the Rx queues"
            rbitfld.long 0x00 30.--31. "Reserved_31_30,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 29. "TBRQE,Type Field Based Rx Queuing Enable When this bit is set it enables Type Field based Rx Queuing where the Type field of received packet is compared with programmed TYP field in MAC_TMRQ_Regs(#i) and if a match occurs the packet is routed to the.." "0,1"
            newline
            bitfld.long 0x00 28. "OMCBCQ,Over-riding MC-BC queue priority select" "0: overriding MCBCQ priority disabled,1: overriding MCBCQ priority enabled"
            newline
            rbitfld.long 0x00 27. "Reserved_27,Reserved" "0,1"
            newline
            rbitfld.long 0x00 24.--26. "Reserved_FPRQ,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 22.--23. "TPQC,Tagged PTP over Ethernet Packets Queuing Control" "0: VLAN Tagged PTPoE packets are routed as generic,1: VLAN Tagged PTPoE packets are routed to Rx..,2: VLAN Tagged PTPoE packets are routed to only AV,3: Reserved DCB/"
            newline
            bitfld.long 0x00 21. "TACPQE,Tagged AV Control Packets Queuing Enable" "0: Tagged AV Control Packets Queuing is disabled,1: Tagged AV Control Packets Queuing is enabled"
            newline
            bitfld.long 0x00 20. "MCBCQEN,Multicast and Broadcast Queue Enable This bit specifies that Multicast or Broadcast packets routing to the Rx Queue is enabled and the Multicast or Broadcast packets must be routed to Rx Queue specified in MCBCQ field" "0: Multicast and Broadcast Queue is disabled,1: Multicast and Broadcast Queue is enabled"
            newline
            rbitfld.long 0x00 19. "Reserved_19,Reserved" "0,1"
            newline
            bitfld.long 0x00 16.--18. "MCBCQ,Multicast and Broadcast Queue This field specifies the Rx Queue onto which Multicast or Broadcast Packets are routed" "0: Receive Queue 0,1: Receive Queue 1,?..."
            newline
            rbitfld.long 0x00 15. "Reserved_15,Reserved" "0,1"
            newline
            bitfld.long 0x00 12.--14. "UPQ,Untagged Packet Queue This field indicates the Rx Queue to which Untagged Packets are to be routed" "0: Receive Queue 0,1: Receive Queue 1,?..."
            newline
            rbitfld.long 0x00 11. "Reserved_11,Reserved" "0,1"
            newline
            bitfld.long 0x00 8.--10. "DCBCPQ,DCB Control Packets Queue This field specifies the Rx queue on which the received DCB control packets are routed" "0: Receive Queue 0,1: Receive Queue 1,?..."
            newline
            rbitfld.long 0x00 7. "Reserved_7,Reserved" "0,1"
            newline
            bitfld.long 0x00 4.--6. "PTPQ,PTP Packets Queue This field specifies the Rx queue on which the PTP packets sent over the Ethernet payload (not over IPv4 or IPv6) are routed" "0: Receive Queue 0,1: Receive Queue 1,?..."
            newline
            rbitfld.long 0x00 3. "Reserved_3,Reserved" "0,1"
            newline
            bitfld.long 0x00 0.--2. "AVCPQ,AV Untagged Control Packets Queue This field specifies the Receive queue on which the received AV tagged and untagged control packets are routed" "0: Receive Queue 0,1: Receive Queue 1,?..."
    group.long 0xA8++0x03
        line.long 0x00 "MAC_RxQ_Ctrl2,This register controls the routing of tagged packets based on the USP (user Priority) field of the received packets to the RxQueues 0 to 3"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_PSRQ3,Reserved"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "Reserved_PSRQ2,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "PSRQ1,Priorities Selected in the Receive Queue 1 This field decides the priorities assigned to Rx Queue 1"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "PSRQ0,Priorities Selected in the Receive Queue 0 This field decides the priorities assigned to Rx Queue 0"

    rgroup.long 0xB0++0x03
        line.long 0x00 "MAC_Interrupt_Status,The Interrupt Status register contains the status of interrupts"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_31_24,Reserved"
            newline
            bitfld.long 0x00 23. "Reserved_PCIS,Reserved" "0,1"
            newline
            bitfld.long 0x00 21.--22. "Reserved_22_21,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 20. "Reserved_MFRIS,Reserved" "0,1"
            newline
            bitfld.long 0x00 19. "Reserved_MFTIS,Reserved" "0,1"
            newline
            bitfld.long 0x00 18. "MDIOIS,MDIO Interrupt Status" "0: MDIO Interrupt status not active,1: MDIO Interrupt status active"
            newline
            bitfld.long 0x00 17. "Reserved_FPEIS,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "Reserved_16,Reserved" "0,1"
            newline
            bitfld.long 0x00 15. "Reserved_GPIIS,Reserved" "0,1"
            newline
            bitfld.long 0x00 14. "RXSTSIS,Receive Status Interrupt This bit indicates the status of received packets" "0: Receive Interrupt status not active,1: Receive Interrupt status active"
            newline
            bitfld.long 0x00 13. "TXSTSIS,Transmit Status Interrupt This bit indicates the status of transmitted packets" "0: Transmit Interrupt status not active,1: Transmit Interrupt status active"
            newline
            bitfld.long 0x00 12. "TSIS,Timestamp Interrupt Status this bit is 1 when any of the following conditions is true: - The system time value is equal to or exceeds the value you programmed in the MAC_PPS(#i)_Target_Time_Seconds and MAC_PPS(#i)_Target_Time_Nanoseconds" "0: Timestamp Interrupt status not active,1: Timestamp Interrupt status active"
            newline
            bitfld.long 0x00 11. "MMCRXIPIS,MMC Receive Checksum Offload Interrupt Status This bit is set high when an interrupt is generated in the MMC Receive Checksum Offload Interrupt Register" "0: MMC Receive Checksum Offload Interrupt status..,1: MMC Receive Checksum Offload Interrupt status.."
            newline
            bitfld.long 0x00 10. "MMCTXIS,MMC Transmit Interrupt Status This bit is set high when an interrupt is generated in the MMC Transmit Interrupt Register" "0: MMC Transmit Interrupt status not active,1: MMC Transmit Interrupt status active"
            newline
            bitfld.long 0x00 9. "MMCRXIS,MMC Receive Interrupt Status This bit is set high when an interrupt is generated in the MMC Receive Interrupt Register" "0: MMC Receive Interrupt status not active,1: MMC Receive Interrupt status active"
            newline
            bitfld.long 0x00 8. "MMCIS,MMC Interrupt Status This bit is set high when Bit 11 Bit 10 or Bit 9 is set high" "0: MMC Interrupt status not active,1: MMC Interrupt status active"
            newline
            bitfld.long 0x00 6.--7. "Reserved_7_6,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 5. "Reserved_LPIIS,Reserved" "0,1"
            newline
            bitfld.long 0x00 4. "Reserved_PMTIS,Reserved" "0,1"
            newline
            bitfld.long 0x00 3. "PHYIS,PHY Interrupt This bit is set when rising edge is detected on the phy_intr_i input" "0: PHY Interrupt not detected,1: PHY Interrupt detected"
            newline
            bitfld.long 0x00 2. "PCSANCIS,PCS Auto-Negotiation Complete This bit is set when auto-negotiation is completed in the TBI RTBI or SGMII PHY interface (see ANC bit in the MAC_AN_Status register)" "0: PCS Auto-Negotiation has not Completed,1: PCS Auto-Negotiation Completed"
            newline
            bitfld.long 0x00 1. "PCSLCHGIS,PCS Link Status Changed This bit is set because of any change in Link Status in the TBI RTBI or SGMII PHY interface (See LS bit in MAC_AN_Status register)" "0: PCS Link Status has not Changed,1: PCS Link Status Changed"
            newline
            bitfld.long 0x00 0. "RGSMIIIS,RGMII or SMII Interrupt Status This bit is set because of any change in value of the Link Status of RGMII or SMII interface (LNKSTS bit in MAC_PHYIF_Control_Status register)" "0: RGMII or SMII Interrupt Status is not active,1: RGMII or SMII Interrupt Status is active"

    group.long 0xB4++0x03
        line.long 0x00 "MAC_Interrupt_Enable,The Interrupt Enable register contains the masks for generating the interrupts"
            hexmask.long.word 0x00 19.--31. 1. "Reserved_31_19,Reserved"
            newline
            bitfld.long 0x00 18. "MDIOIE,MDIO Interrupt Enable When this bit is set it enables the assertion of the interrupt when MDIOIS field is set in the MAC_Interrupt_Status register" "0: MDIO Interrupt is disabled,1: MDIO Interrupt is enabled"
            newline
            rbitfld.long 0x00 17. "Reserved_FPEIE,Reserved" "0,1"
            newline
            rbitfld.long 0x00 16. "Reserved_16,Reserved" "0,1"
            newline
            rbitfld.long 0x00 15. "Reserved_15,Reserved" "0,1"
            newline
            bitfld.long 0x00 14. "RXSTSIE,Receive Status Interrupt Enable When this bit is set it enables the assertion of the interrupt signal because of the setting of RXSTSIS bit in the MAC_Interrupt_Status register" "0: Receive Status Interrupt is disabled,1: Receive Status Interrupt is enabled"
            newline
            bitfld.long 0x00 13. "TXSTSIE,Transmit Status Interrupt Enable When this bit is set it enables the assertion of the interrupt signal because of the setting of TXSTSIS bit in the MAC_Interrupt_Status register" "0: Timestamp Status Interrupt is disabled,1: Timestamp Status Interrupt is enabled"
            newline
            bitfld.long 0x00 12. "TSIE,Timestamp Interrupt Enable When this bit is set it enables the assertion of the interrupt signal because of the setting of TSIS bit in MAC_Interrupt_Status register" "0: Timestamp Interrupt is disabled,1: Timestamp Interrupt is enabled"
            newline
            rbitfld.long 0x00 6.--11. "Reserved_11_6,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            rbitfld.long 0x00 5. "Reserved_LPIIE,Reserved" "0,1"
            newline
            rbitfld.long 0x00 4. "Reserved_PMTIE,Reserved" "0,1"
            newline
            bitfld.long 0x00 3. "PHYIE,PHY Interrupt Enable When this bit is set it enables the assertion of the interrupt signal because of the setting of PHYIS bit in MAC_Interrupt_Status register" "0: PHY Interrupt is disabled,1: PHY Interrupt is enabled"
            newline
            bitfld.long 0x00 2. "PCSANCIE,PCS AN Completion Interrupt Enable When this bit is set it enables the assertion of the interrupt signal because of the setting of the PCSANCIS bit in MAC_Interrupt_Status register" "0: PCS AN Completion Interrupt is disabled,1: PCS AN Completion Interrupt is enabled"
            newline
            bitfld.long 0x00 1. "PCSLCHGIE,PCS Link Status Interrupt Enable When this bit is set it enables the assertion of the interrupt signal because of the setting of the PCSLCHGIS bit in MAC_Interrupt_Status register" "0: PCS Link Status Interrupt is disabled,1: PCS Link Status Interrupt is enabled"
            newline
            bitfld.long 0x00 0. "RGSMIIIE,RGMII or SMII Interrupt Enable When this bit is set it enables the assertion of the interrupt signal because of the setting of RGSMIIIS bit in MAC_Interrupt_Status register" "0: RGMII or SMII Interrupt is disabled,1: RGMII or SMII Interrupt is enabled"

    rgroup.long 0xB8++0x03
        line.long 0x00 "MAC_Rx_Tx_Status,The Receive Transmit Status register contains the Receive and Transmit Error status"
            hexmask.long.tbyte 0x00 9.--31. 1. "Reserved_31_9,Reserved"
            newline
            bitfld.long 0x00 8. "RWT,Receive Watchdog Timeout This bit is set when a packet with length greater than 2 048 bytes is received (10 240 bytes when Jumbo Packet mode is enabled) and the WD bit is reset in the MAC_Configuration register" "0: No receive watchdog timeout,1: Receive watchdog timed out"
            newline
            bitfld.long 0x00 6.--7. "Reserved_7_6,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 5. "EXCOL,Excessive Collisions When the DTXSTS bit is set in the MTL_Operation_Mode register this bit indicates that the transmission aborted after 16 successive collisions while attempting to transmit the current packet" "0: No collision,1: Excessive collision is sensed"
            newline
            bitfld.long 0x00 4. "LCOL,Late Collision When the DTXSTS bit is set in the MTL_Operation_Mode register this bit indicates that the packet transmission aborted because a collision occurred after the collision window (64 bytes including Preamble in MII mode 512 bytes.." "0: No collision,1: Late collision is sensed"
            newline
            bitfld.long 0x00 3. "EXDEF,Excessive Deferral When the DTXSTS bit is set in the MTL_Operation_Mode register and the DC bit is set in the MAC_Configuration register this bit indicates that the transmission ended because of excessive deferral of over 24 288 bit times (155 680.." "0: No Excessive deferral,1: Excessive deferral"
            newline
            bitfld.long 0x00 2. "LCARR,Loss of Carrier When the DTXSTS bit is set in the MTL_Operation_Mode register this bit indicates that the loss of carrier occurred during packet transmission that is the phy_crs_i signal was inactive for one or more transmission clock periods.." "0: Carrier is present,1: Loss of carrier"
            newline
            bitfld.long 0x00 1. "NCARR,No Carrier When the DTXSTS bit is set in the MTL_Operation_Mode register this bit indicates that the carrier signal from the PHY is not present at the end of preamble transmission" "0: Carrier is present,1: No carrier"
            newline
            bitfld.long 0x00 0. "TJT,Transmit Jabber Timeout This bit indicates that the Transmit Jabber Timer expired which happens when the packet size exceeds 2 048 bytes (10 240 bytes when the Jumbo packet is enabled) and JD bit is reset in the MAC_Configuration register" "0: No Transmit Jabber Timeout,1: Transmit Jabber Timeout occurred"

    group.long 0xE0++0x03
        line.long 0x00 "MAC_AN_Control,The AN Control register enables and restarts auto-negotiation"
            hexmask.long.word 0x00 19.--31. 1. "Reserved_31_19,Reserved"
            newline
            bitfld.long 0x00 18. "SGMRAL,SGMII RAL Control When this bit is set the SGMII RAL block operates in the speed configured in the Speed and Port Select bits of the MAC_Configuration register" "0: SGMII RAL Control is disabled,1: SGMII RAL Control is enabled"
            newline
            bitfld.long 0x00 17. "LR,Lock to Reference When this bit is set the PHY locks its PLL to the 125 MHz reference clock" "0: Lock to Reference is disabled,1: Lock to Reference is enabled"
            newline
            bitfld.long 0x00 16. "ECD,Enable Comma Detect When this bit is set the PHY is enabled for comma detection and word resynchronization" "0: Comma detect is disabled,1: Comma detect is enabled"
            newline
            rbitfld.long 0x00 15. "Reserved_15,Reserved" "0,1"
            newline
            bitfld.long 0x00 14. "ELE,External Loopback Enable When this bit is set it enables the PHY to loopback the Transmit data into the Receive path" "0: External Loopback is disabled,1: External Loopback is enabled"
            newline
            rbitfld.long 0x00 13. "Reserved_13,Reserved" "0,1"
            newline
            bitfld.long 0x00 12. "ANE,Auto-Negotiation Enable When this bit is set it enables the MAC to perform auto-negotiation with the link partner" "0: Auto-Negotiation is disabled,1: Auto-Negotiation is enabled"
            newline
            rbitfld.long 0x00 10.--11. "Reserved_11_10,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 9. "RAN,Restart Auto-Negotiation When this bit is set auto-negotiation is restarted if Bit 12 (ANE) is set" "0: Do not Restart Auto-Negotiation,1: Restart Auto-Negotiation"
            newline
            hexmask.long.word 0x00 0.--8. 1. "Reserved_8_0,Reserved"

    rgroup.long 0xE4++0x03
        line.long 0x00 "MAC_AN_Status,The AN Status register indicates the link and the auto-negotiation status"
            hexmask.long.tbyte 0x00 9.--31. 1. "Reserved_31_9,Reserved"
            newline
            bitfld.long 0x00 8. "ES,Extended Status This bit is tied to high if the TBI or RTBI interface is selected while configuring the IP indicating that the MAC supports extended status information in the MAC_TBI_Extended_Status register" "0: No Extended status,1: Extended status"
            newline
            bitfld.long 0x00 6.--7. "Reserved_7_6,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 5. "ANC,Auto-Negotiation Complete When this bit is set it indicates that the auto-negotiation process is complete" "0: Auto-Negotiation is not complete,1: Auto-Negotiation is complete"
            newline
            bitfld.long 0x00 4. "Reserved_4,Reserved" "0,1"
            newline
            bitfld.long 0x00 3. "ANA,Auto-Negotiation Ability This bit is always high because the MAC supports auto-negotiation" "0: MAC does not posses Auto-Negotiation Ability,1: MAC posses Auto-Negotiation Ability"
            newline
            bitfld.long 0x00 2. "LS,Link Status When this bit is set it indicates that the link is up between the MAC and the TBI RTBI or SGMII interface" "0: Link is down,1: Link is up"
            newline
            bitfld.long 0x00 0.--1. "Reserved_1_0,Reserved" "0,1,2,3"

    group.long 0xF8++0x03
        line.long 0x00 "MAC_PHYIF_Control_Status,The PHY Interface Control and Status register indicates the status signals received by the SGMII RGMII or SMII interface (selected at reset) from the PHY"
            hexmask.long.word 0x00 22.--31. 1. "Reserved_31_22,Reserved"
            newline
            rbitfld.long 0x00 21. "Reserved_FALSCARDET,Reserved" "0,1"
            newline
            rbitfld.long 0x00 20. "Reserved_JABTO,Reserved" "0,1"
            newline
            rbitfld.long 0x00 19. "LNKSTS,Link Status This bit indicates whether the link is up (1'b1) or down (1'b0)" "0: Link down,1: Link up"
            newline
            rbitfld.long 0x00 17.--18. "LNKSPEED,Link Speed This bit indicates the current speed of the link" "0: M_2500K,1: 25 MHz,2: 125 MHz,?..."
            newline
            rbitfld.long 0x00 16. "LNKMOD,Link Mode This bit indicates the current mode of operation of the link" "0: Half-duplex mode,1: Full-duplex mode"
            newline
            hexmask.long.word 0x00 5.--15. 1. "Reserved_15_5,Reserved"
            newline
            rbitfld.long 0x00 4. "Reserved_SMIDRXS,Reserved" "0,1"
            newline
            rbitfld.long 0x00 3. "Reserved_3,Reserved" "0,1"
            newline
            rbitfld.long 0x00 2. "Reserved_SFTERR,Reserved" "0,1"
            newline
            bitfld.long 0x00 1. "LUD,Link Up or Down This bit indicates whether the link is up or down during transmission of configuration in the RGMII SGMII or SMII interface" "0: Link down,1: Link up"
            newline
            bitfld.long 0x00 0. "TC,Transmit Configuration in RGMII SGMII or SMII When set this bit enables the transmission of duplex mode link speed and link up or down information to the PHY in the RGMII SMII or SGMII port" "0: Disable Transmit Configuration in RGMII SGMII..,1: Enable Transmit Configuration in RGMII SGMII.."

    rgroup.long 0x110++0x03
        line.long 0x00 "MAC_Version,The version register identifies the version of the DWC_ether_qos"
            hexmask.long.word 0x00 16.--31. 1. "Reserved_31_16,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "USERVER,User-defined Version (configured with coreConsultant)"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "SNPSVER,Synopsys-defined Version"
    rgroup.long 0x114++0x03
        line.long 0x00 "MAC_Debug,The Debug register provides the debug status of various MAC blocks"
            hexmask.long.word 0x00 19.--31. 1. "Reserved_31_19,Reserved"
            newline
            bitfld.long 0x00 17.--18. "TFCSTS,MAC Transmit Packet Controller Status This field indicates the state of the MAC Transmit Packet Controller module" "0: Idle state,1: Waiting for one of the following,2: Generating and transmitting a Pause control..,3: Transferring input packet for transmission"
            newline
            bitfld.long 0x00 16. "TPESTS,MAC GMII or MII Transmit Protocol Engine Status When this bit is set it indicates that the MAC GMII or MII transmit protocol engine is actively transmitting data and it is not in the Idle state" "0: MAC GMII or MII Transmit Protocol Engine..,1: MAC GMII or MII Transmit Protocol Engine.."
            newline
            hexmask.long.word 0x00 3.--15. 1. "Reserved_15_3,Reserved"
            newline
            bitfld.long 0x00 1.--2. "RFCFCSTS,MAC Receive Packet Controller FIFO Status When this bit is set this field indicates the active state of the small FIFO Read and Write controllers of the MAC Receive Packet Controller module" "0,1,2,3"
            newline
            bitfld.long 0x00 0. "RPESTS,MAC GMII or MII Receive Protocol Engine Status When this bit is set it indicates that the MAC GMII or MII receive protocol engine is actively receiving data and it is not in the Idle state" "0: MAC GMII or MII Receive Protocol Engine..,1: MAC GMII or MII Receive Protocol Engine.."
    rgroup.long 0x11C++0x03
        line.long 0x00 "MAC_HW_Feature0,This register indicates the presence of first set of the optional features or functions of the DWC_ether_qos"
            bitfld.long 0x00 28.--31. "ACTPHYSEL,Active PHY Selected When you have multiple PHY interfaces in your configuration this field indicates the sampled value of phy_intf_sel_i during reset de-assertion" "0: GMII or MII,1: RGMII,2: SGMII,?,4: RMII,?,?,?,8: B10T1S,?..."
            newline
            bitfld.long 0x00 27. "SAVLANINS,Source Address or VLAN Insertion Enable This bit is set to 1 when the Enable SA and VLAN Insertion on Tx option is selected" "0: Source Address or VLAN Insertion Enable..,1: Source Address or VLAN Insertion Enable.."
            newline
            bitfld.long 0x00 25.--26. "TSSTSSEL,Timestamp System Time Source This bit indicates the source of the Timestamp System Time" "?,1: Internal,2: External,3: RSVD"
            newline
            bitfld.long 0x00 24. "MACADR64SEL,MAC Addresses 64-127 Selected This bit is set to 1 when the Enable Additional 64 MAC Address Registers (64-127) option is selected" "0: MAC Addresses 64-127 Select option is not..,1: MAC Addresses 64-127 Select option is selected"
            newline
            bitfld.long 0x00 23. "MACADR32SEL,MAC Addresses 32-63 Selected This bit is set to 1 when the Enable Additional 32 MAC Address Registers (32-63) option is selected" "0: MAC Addresses 32-63 Select option is not..,1: MAC Addresses 32-63 Select option is selected"
            newline
            bitfld.long 0x00 18.--22. "ADDMACADRSEL,MAC Addresses 1-31 Selected This bit is set to 1 when the non-zero value is selected for Enable Additional 1-31 MAC Address Registers option" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 17. "Reserved_17,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "RXCOESEL,Receive Checksum Offload Enabled This bit is set to 1 when the Enable Receive TCP/IP Checksum Check option is selected" "0: Receive Checksum Offload Enable option is not..,1: Receive Checksum Offload Enable option is.."
            newline
            bitfld.long 0x00 15. "Reserved_15,Reserved" "0,1"
            newline
            bitfld.long 0x00 14. "TXCOESEL,Transmit Checksum Offload Enabled This bit is set to 1 when the Enable Transmit TCP/IP Checksum Insertion option is selected" "0: Transmit Checksum Offload Enable option is..,1: Transmit Checksum Offload Enable option is.."
            newline
            bitfld.long 0x00 13. "EEESEL,Energy Efficient Ethernet Enabled This bit is set to 1 when the Enable Energy Efficient Ethernet (EEE) option is selected" "0: Energy Efficient Ethernet Enable option is..,1: Energy Efficient Ethernet Enable option is.."
            newline
            bitfld.long 0x00 12. "TSSEL,IEEE 1588-2008 Timestamp Enabled This bit is set to 1 when the Enable IEEE 1588 Timestamp Support option is selected" "0: IEEE 1588-2008 Timestamp Enable option is not..,1: IEEE 1588-2008 Timestamp Enable option is.."
            newline
            bitfld.long 0x00 10.--11. "Reserved_11_10,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 9. "ARPOFFSEL,ARP Offload Enabled This bit is set to 1 when the Enable IPv4 ARP Offload option is selected" "0: ARP Offload Enable option is not selected,1: ARP Offload Enable option is selected"
            newline
            bitfld.long 0x00 8. "MMCSEL,RMON Module Enable This bit is set to 1 when the Enable MAC Management Counters (MMC) option is selected" "0: RMON Module Enable option is not selected,1: RMON Module Enable option is selected"
            newline
            bitfld.long 0x00 7. "MGKSEL,PMT Magic Packet Enable This bit is set to 1 when the Enable Magic Packet Detection option is selected" "0: PMT Magic Packet Enable option is not selected,1: PMT Magic Packet Enable option is selected"
            newline
            bitfld.long 0x00 6. "RWKSEL,PMT Remote Wake-up Packet Enable This bit is set to 1 when the Enable Remote Wake-Up Packet Detection option is selected" "0: PMT Remote Wake-up Packet Enable option is..,1: PMT Remote Wake-up Packet Enable option is.."
            newline
            bitfld.long 0x00 5. "SMASEL,SMA (MDIO) Interface This bit is set to 1 when the Enable Station Management (MDIO Interface) option is selected" "0: SMA (MDIO) Interface not selected,1: SMA (MDIO) Interface selected"
            newline
            bitfld.long 0x00 4. "VLHASH,VLAN Hash Filter Selected This bit is set to 1 when the Enable VLAN Hash Table Based Filtering option is selected" "0: VLAN Hash Filter not selected,1: VLAN Hash Filter selected"
            newline
            bitfld.long 0x00 3. "PCSSEL,PCS Registers (TBI SGMII or RTBI PHY interface) This bit is set to 1 when the TBI SGMII or RTBI PHY interface option is selected" "0: No PCS Registers (TBI SGMII or RTBI PHY..,1: PCS Registers (TBI SGMII or RTBI PHY interface)"
            newline
            bitfld.long 0x00 2. "HDSEL,Half-duplex Support This bit is set to 1 when the half-duplex mode is selected" "0: No Half-duplex support,1: Half-duplex support"
            newline
            bitfld.long 0x00 1. "GMIISEL,1000 Mbps Support This bit is set to 1 when 1000 Mbps is selected as the Mode of Operation" "0: No 1000 Mbps support,1: 1000 Mbps support"
            newline
            bitfld.long 0x00 0. "MIISEL,10 or 100 Mbps Support This bit is set to 1 when 10/100 Mbps is selected as the Mode of Operation" "0: No 10 or 100 Mbps support,1: 10 or 100 Mbps support"
    rgroup.long 0x120++0x03
        line.long 0x00 "MAC_HW_Feature1,This register indicates the presence of second set of the optional features or functions of the DWC_ether_qos"
            bitfld.long 0x00 31. "Reserved_31,Reserved" "0,1"
            newline
            bitfld.long 0x00 27.--30. "L3L4FNUM,Total number of L3 or L4 Filters This field indicates the total number of L3 or L4 filters" "0: No L3 or L4 Filter,1: 1 L3 or L4 Filter,2: 2 L3 or L4 Filters,3: 3 L3 or L4 Filters,4: 4 L3 or L4 Filters,5: 5 L3 or L4 Filters,6: 6 L3 or L4 Filters,7: 7 L3 or L4 Filters,8: 8 L3 or L4 Filters,?..."
            newline
            bitfld.long 0x00 26. "Reserved_26,Reserved" "0,1"
            newline
            bitfld.long 0x00 24.--25. "HASHTBLSZ,Hash Table Size This field indicates the size of the hash table" "0: No hash table,1: M_64,2: M_128,3: M_256"
            newline
            bitfld.long 0x00 23. "POUOST,One Step for PTP over UDP/IP Feature Enable This bit is set to 1 when the Enable One step timestamp for PTP over UDP/IP feature is selected" "0: One Step for PTP over UDP/IP Feature is not..,1: One Step for PTP over UDP/IP Feature is.."
            newline
            bitfld.long 0x00 22. "Reserved_22,Reserved" "0,1"
            newline
            bitfld.long 0x00 21. "RAVSEL,Rx Side Only AV Feature Enable This bit is set to 1 when the Enable Audio Video Bridging option on Rx Side Only is selected" "0: Rx Side Only AV Feature is not selected,1: Rx Side Only AV Feature is selected"
            newline
            bitfld.long 0x00 20. "AVSEL,AV Feature Enable This bit is set to 1 when the Enable Audio Video Bridging option is selected" "0: AV Feature is not selected,1: AV Feature is selected"
            newline
            bitfld.long 0x00 19. "DBGMEMA,DMA Debug Registers Enable This bit is set to 1 when the Debug Mode Enable option is selected" "0: DMA Debug Registers option is not selected,1: DMA Debug Registers option is selected"
            newline
            bitfld.long 0x00 18. "TSOEN,TCP Segmentation Offload Enable This bit is set to 1 when the Enable TCP Segmentation Offloading for TCP/IP Packets option is selected" "0: TCP Segmentation Offload Feature is not..,1: TCP Segmentation Offload Feature is selected"
            newline
            bitfld.long 0x00 17. "SPHEN,Split Header Feature Enable This bit is set to 1 when the Enable Split Header Structure option is selected" "0: Split Header Feature is not selected,1: Split Header Feature is selected"
            newline
            bitfld.long 0x00 16. "DCBEN,DCB Feature Enable This bit is set to 1 when the Enable Data Center Bridging option is selected" "0: DCB Feature is not selected,1: DCB Feature is selected"
            newline
            bitfld.long 0x00 14.--15. "ADDR64,Address Width" "0: M_32,1: M_40,2: M_48,?..."
            newline
            bitfld.long 0x00 13. "ADVTHWORD,IEEE 1588 High Word Register Enable This bit is set to 1 when the Add IEEE 1588 Higher Word Register option is selected" "0: IEEE 1588 High Word Register option is not..,1: IEEE 1588 High Word Register option is selected"
            newline
            bitfld.long 0x00 12. "PTOEN,PTP Offload Enable This bit is set to 1 when the Enable PTP Timestamp Offload Feature is selected" "0: PTP Offload feature is not selected,1: PTP Offload feature is selected"
            newline
            bitfld.long 0x00 11. "OSTEN,One-Step Timestamping Enable This bit is set to 1 when the Enable One-Step Timestamp Feature is selected" "0: One-Step Timestamping feature is not selected,1: One-Step Timestamping feature is selected"
            newline
            bitfld.long 0x00 6.--10. "TXFIFOSIZE,MTL Transmit FIFO Size This field contains the configured value of MTL Tx FIFO in bytes expressed as Log to base 2 minus 7 that is Log2(TXFIFO_SIZE) -7" "0: 128 bytes,1: 256 bytes,2: 512 bytes,3: 1024 bytes,4: 2048 bytes,5: 4096 bytes,6: 8192 bytes,7: 16384 bytes,8: M_32KB,9: M_64KB,10: M_128KB,?..."
            newline
            bitfld.long 0x00 5. "SPRAM,Single Port RAM Enable This bit is set to 1 when the Use single port RAM Feature is selected" "0: Single Port RAM feature is not selected,1: Single Port RAM feature is selected"
            newline
            bitfld.long 0x00 0.--4. "RXFIFOSIZE,MTL Receive FIFO Size This field contains the configured value of MTL Rx FIFO in bytes expressed as Log to base 2 minus 7 that is Log2(RXFIFO_SIZE) -7" "0: 128 bytes,1: 256 bytes,2: 512 bytes,3: 1024 bytes,4: 2048 bytes,5: 4096 bytes,6: 8192 bytes,7: 16384 bytes,8: M_32KB,9: M_64KB,10: M_128KB,11: M_256KB,?..."
    rgroup.long 0x124++0x03
        line.long 0x00 "MAC_HW_Feature2,This register indicates the presence of third set of the optional features or functions of the DWC_ether_qos"
            bitfld.long 0x00 31. "Reserved_31,Reserved" "0,1"
            newline
            bitfld.long 0x00 28.--30. "AUXSNAPNUM,Number of Auxiliary Snapshot Inputs This field indicates the number of auxiliary snapshot inputs" "0: No auxiliary input,?,2: 2 auxiliary input,?..."
            newline
            bitfld.long 0x00 27. "Reserved_27,Reserved" "0,1"
            newline
            bitfld.long 0x00 24.--26. "PPSOUTNUM,Number of PPS Outputs This field indicates the number of PPS outputs" "0: No PPS output,?,?,?,4: 4 PPS output,?..."
            newline
            bitfld.long 0x00 22.--23. "TDCSZ,Tx DMA Descriptor Cache Size in terms of 16-bytes descriptors" "0: Desc Cache not configured,?,?,3: M_3TDCSZ"
            newline
            bitfld.long 0x00 18.--21. "TXCHCNT,Number of DMA Transmit Channels This field indicates the number of DMA Transmit channels" "?,?,2: 3 DMA Tx Channels,?..."
            newline
            bitfld.long 0x00 16.--17. "RDCSZ,Rx DMA Descriptor Cache Size in terms of 16-bytes descriptors" "0: Desc Cache not configured,?,?,3: M_3RDCSZ"
            newline
            bitfld.long 0x00 12.--15. "RXCHCNT,Number of DMA Receive Channels This field indicates the number of DMA Receive channels" "?,1: 2 DMA Rx Channels,?..."
            newline
            bitfld.long 0x00 10.--11. "Reserved_11_10,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 6.--9. "TXQCNT,Number of MTL Transmit Queues This field indicates the number of MTL Transmit queues" "?,?,2: 3 MTL Tx Queues,?..."
            newline
            bitfld.long 0x00 4.--5. "Reserved_5_4,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--3. "RXQCNT,Number of MTL Receive Queues This field indicates the number of MTL Receive queues" "?,1: 2 MTL Rx Queues,?..."
    rgroup.long 0x128++0x03
        line.long 0x00 "MAC_HW_Feature3,This register indicates the presence of fourth set the optional features or functions of the DWC_ether_qos"
            bitfld.long 0x00 30.--31. "Reserved_31_30,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 28.--29. "ASP,Automotive Safety Package Following are the encoding for the different Safety features" "0: No Safety features selected,?,?,3: All the Automotive Safety features are.."
            newline
            bitfld.long 0x00 27. "TBSSEL,Time Based Scheduling Enable This bit is set to 1 when the Time Based Scheduling feature is selected" "0: Time Based Scheduling Enable feature is not..,1: Time Based Scheduling Enable feature is.."
            newline
            bitfld.long 0x00 26. "FPESEL,Frame Preemption Enable This bit is set to 1 when the Enable Frame preemption feature is selected" "0: Frame Preemption Enable feature is not selected,1: Frame Preemption Enable feature is selected"
            newline
            bitfld.long 0x00 22.--25. "Reserved_25_22,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 20.--21. "ESTWID,Width of the Time Interval field in the Gate Control List This field indicates the width of the Configured Time Interval Field" "0: Width not configured,?,?,3: WIDTH24"
            newline
            bitfld.long 0x00 17.--19. "ESTDEP,Depth of the Gate Control List Indicates the depth of Gate Control list in bytes" "0: No Depth configured,?,?,?,4: DEPTH512,?..."
            newline
            bitfld.long 0x00 16. "ESTSEL,Enhancements to Scheduled Traffic Enable This bit is set to 1 when the Enable Enhancements to Scheduling Traffic feature is selected" "0: Enable Enhancements to Scheduling Traffic..,1: Enable Enhancements to Scheduling Traffic.."
            newline
            bitfld.long 0x00 15. "Reserved_15,Reserved" "0,1"
            newline
            bitfld.long 0x00 13.--14. "FRPES,Flexible Receive Parser Table Entries size This field indicates the Max Number of Parser Entries supported by Flexible Receive Parser" "?,?,2: 256 Entries,?..."
            newline
            bitfld.long 0x00 11.--12. "FRPBS,Flexible Receive Parser Buffer size This field indicates the supported Max Number of bytes of the packet data to be Parsed by Flexible Receive Parser" "?,?,2: M_256BYTES,?..."
            newline
            bitfld.long 0x00 10. "FRPSEL,Flexible Receive Parser Selected This bit is set to 1 when the Enable Flexible Programmable Receive Parser option is selected" "0: Flexible Receive Parser feature is not selected,1: Flexible Receive Parser feature is selected"
            newline
            bitfld.long 0x00 9. "PDUPSEL,Broadcast/Multicast Packet Duplication This bit is set to 1 when the Broadcast/Multicast Packet Duplication feature is selected" "0: Broadcast/Multicast Packet Duplication..,1: Broadcast/Multicast Packet Duplication.."
            newline
            bitfld.long 0x00 6.--8. "Reserved_7_6,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 5. "DVLAN,Double VLAN Tag Processing Selected This bit is set to 1 when the Enable Double VLAN Processing Feature is selected" "0: Double VLAN option is not selected,1: Double VLAN option is selected"
            newline
            bitfld.long 0x00 4. "CBTISEL,Queue/Channel based VLAN tag insertion on Tx Enable This bit is set to 1 when the Enable Queue/Channel based VLAN tag insertion on Tx Feature is selected" "0: Enable Queue/Channel based VLAN tag insertion..,1: Enable Queue/Channel based VLAN tag insertion.."
            newline
            bitfld.long 0x00 3. "Reserved_3,Reserved" "0,1"
            newline
            bitfld.long 0x00 0.--2. "NRVF,Number of Extended VLAN Tag Filters Enabled This field indicates the Number of Extended VLAN Tag Filters selected" "0: No Extended Rx VLAN Filters,1: 4 Extended Rx VLAN Filters,2: 8 Extended Rx VLAN Filters,3: 16 Extended Rx VLAN Filters,4: 24 Extended Rx VLAN Filters,5: 32 Extended Rx VLAN Filters,?..."
    rgroup.long 0x12C++0x03
        line.long 0x00 "MAC_HW_Feature4,This register indicates the presence of the fifth set of optional features or functions of the DWC_ether_qos"
            hexmask.long 0x00 2.--31. 1. "Reserved_31_2,Reserved"
            newline
            bitfld.long 0x00 0.--1. "PCSEL,Policing Counters Selected This field indicates the Number of Policing Counters selected" "0: Policing counter feature is not selected,1: 16 Policing counters are selected,2: 32 Policing counters are selected,?..."

    group.long 0x140++0x03
        line.long 0x00 "MAC_DPP_FSM_Interrupt_Status,This register contains the status of Automotive Safety related Data Path Parity Errors Interface Timeout Errors FSM State Parity Errors and FSM State Timeout Errors"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 28. "DCPES,Descriptor Cache data path Parity checker Error Status This field when set indicates that parity error is detected on the Descriptor Cache data interface (or at PC-dbg as shown in DCACHE parity protection diagram)" "0: Descriptor Cache data path Parity checker..,1: Descriptor Cache data path Parity checker.."
            newline
            bitfld.long 0x00 27. "MRWCPES,MTL RWC data path Parity checker Error Status This field when set indicates that parity error is detected on the MTL RWC data interface (or at PC12 as shown in Recieve data path parity protection diagram)" "0: MTL RWC data path Parity checker Error Status..,1: MTL RWC data path Parity checker Error Status.."
            newline
            bitfld.long 0x00 26. "MTFCPES,MAC TFC data path Parity checker Error Status This field when set indicates that parity error is detected on the MAC TFC data interface (or at PC11 as shown in Transmit data path parity protection diagram)" "0: MAC TFC data path Parity checker Error Status..,1: MAC TFC data path Parity checker Error Status.."
            newline
            bitfld.long 0x00 25. "MTBUPES,MAC TBU data path Parity checker Error Status This field when set indicates that parity error is detected on the MAC TBU data interface (or at PC10 as shown in Transmit data path parity protection diagram)" "0: MAC TBU data path Parity checker Error Status..,1: MAC TBU data path Parity checker Error Status.."
            newline
            bitfld.long 0x00 24. "FSMPES,FSM State Parity Error Status This field when set indicates one of the FSMs State registers has a parity error detected" "0: FSM State Parity Error Status not detected,1: FSM State Parity Error Status detected"
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_18,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            rbitfld.long 0x00 17. "Reserved_SLVTES,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "MSTTES,Master Read/Write Timeout Error Status This field when set indicates that an Application/CSR Timeout has occurred on the master (AXI/AHB/ARI/ATI) interface" "0: Master Read/Write Timeout Error Status not..,1: Master Read/Write Timeout Error Status detected"
            newline
            rbitfld.long 0x00 15. "Reserved_RVCTES,Reserved" "0,1"
            newline
            bitfld.long 0x00 14. "R125ES,Rx125 FSM Timeout Error Status This field when set indicates that one of the Rx125 FSM Timeout has occurred" "0: Rx125 FSM Timeout Error Status not detected,1: Rx125 FSM Timeout Error Status detected"
            newline
            bitfld.long 0x00 13. "T125ES,Tx125 FSM Timeout Error Status This field when set indicates that one of the Tx125 FSM Timeout has occurred" "0: Tx125 FSM Timeout Error Status not detected,1: Tx125 FSM Timeout Error Status detected"
            newline
            bitfld.long 0x00 12. "PTES,PTP FSM Timeout Error Status This field when set indicates that one of the PTP FSM Timeout has occurred" "0: PTP FSM Timeout Error Status not detected,1: PTP FSM Timeout Error Status detected"
            newline
            bitfld.long 0x00 11. "ATES,APP FSM Timeout Error Status This field when set indicates that one of the APP FSM Timeout has occurred" "0: APP FSM Timeout Error Status not detected,1: APP FSM Timeout Error Status detected"
            newline
            bitfld.long 0x00 10. "CTES,CSR FSM Timeout Error Status This field when set indicates that one of the CSR FSM Timeout has occurred" "0: CSR FSM Timeout Error Status not detected,1: CSR FSM Timeout Error Status detected"
            newline
            bitfld.long 0x00 9. "RTES,Rx FSM Timeout Error Status This field when set indicates that one of the Rx FSM Timeout has occurred" "0: Rx FSM Timeout Error Status not detected,1: Rx FSM Timeout Error Status detected"
            newline
            bitfld.long 0x00 8. "TTES,Tx FSM Timeout Error Status This field when set indicates that one of the Tx FSM Timeout has occurred" "0: Tx FSM Timeout Error Status not detected,1: Tx FSM Timeout Error Status detected"
            newline
            rbitfld.long 0x00 7. "Reserved_ASRPES,Reserved" "0,1"
            newline
            bitfld.long 0x00 6. "CWPES,CSR Write data path Parity checker Error Status This bit when set indicates that parity error is detected at the CSR write data interface on mci_wdata_i (or at PC8 checker as shown in AXI slave Interface Data path parity protection diagram)" "0: CSR Write data path Parity checker Error..,1: CSR Write data path Parity checker Error.."
            newline
            bitfld.long 0x00 5. "ARPES,Application Receive interface data path Parity Error Status This bit when set indicates that a parity error is detected at the following checkers based on the system configuration: - In MTL configuration (DWC_EQOS_SYS=1) parity checker (PC6 as.." "0: Application Receive interface data path..,1: Application Receive interface data path.."
            newline
            bitfld.long 0x00 4. "MTSPES,MTL TX Status data path Parity checker Error Status This field when set indicates that parity error is detected on the MTL TX Status data on ati interface (or at PC5 as shown in Transmit data path parity protection diagram)" "0: MTL TX Status data path Parity checker Error..,1: MTL TX Status data path Parity checker Error.."
            newline
            bitfld.long 0x00 3. "MPES,MTL data path Parity checker Error Status This bit when set indicates that a parity error is detected at the MTL transmit write controller parity checker (or at PC4 as shown in Transmit data path parity protection diagram)" "0: MTL data path Parity checker Error Status not..,1: MTL data path Parity checker Error Status.."
            newline
            bitfld.long 0x00 2. "RDPES,Read Descriptor Parity checker Error Status This bit when set indicates that a parity error is detected at the DMA Read descriptor parity checker (or at PC3 as shown in Transmit data path parity protection diagram)" "0: Read Descriptor Parity checker Error Status..,1: Read Descriptor Parity checker Error Status.."
            newline
            bitfld.long 0x00 1. "TPES,TSO data path Parity checker Error Status This bit when set indicates that a parity error is detected at the DMA TSO parity checker (or at PC2 as shown in Transmit data path parity protection diagram)" "0: TSO data path Parity checker Error Status not..,1: TSO data path Parity checker Error Status.."
            newline
            bitfld.long 0x00 0. "ATPES,Application Transmit Interface Parity checker Error Status This bit when set indicates that a parity error is detected on the AXI/AHB Master read data parity checker" "0: Application Transmit Interface Parity checker..,1: Application Transmit Interface Parity checker.."
    group.long 0x148++0x03
        line.long 0x00 "MAC_FSM_Control,This register is used to control the FSM State parity and timeout error injection in Debug mode"
            rbitfld.long 0x00 31. "Reserved_RVCLGRNML,Reserved" "0,1"
            newline
            bitfld.long 0x00 30. "R125LGRNML,Rx125 Large/Normal Mode Select This field when set indicates that large mode tic generation is used for Rx125 domain else normal mode tic generation is used" "0: normal mode tic generation is used for Rx125..,1: large mode tic generation is used for Rx125.."
            newline
            bitfld.long 0x00 29. "T125LGRNML,Tx125 Large/Normal Mode Select This field when set indicates that large mode tic generation is used for Tx125 domain else normal mode tic generation is used" "0: normal mode tic generation is used for Tx125..,1: large mode tic generation is used for Tx125.."
            newline
            bitfld.long 0x00 28. "PLGRNML,PTP Large/Normal Mode Select This field when set indicates that large mode tic generation is used for PTP domain else normal mode tic generation is used" "0: normal mode tic generation is used for PTP..,1: large mode tic generation is used for PTP.."
            newline
            bitfld.long 0x00 27. "ALGRNML,APP Large or Normal Mode Select" "0: normal mode tic generation is used for APP..,1: large mode tic generation is used for APP.."
            newline
            bitfld.long 0x00 26. "CLGRNML,CSR Large/Normal Mode Select This field when set indicates that large mode tic generation is used for CSR domain else normal mode tic generation is used" "0: normal mode tic generation is used for CSR..,1: large mode tic generation is used for CSR.."
            newline
            bitfld.long 0x00 25. "RLGRNML,Rx Large/Normal Mode Select This field when set indicates that large mode tic generation is used for Rx domain else normal mode tic generation is used" "0: normal mode tic generation is used for Rx..,1: large mode tic generation is used for Rx domain"
            newline
            bitfld.long 0x00 24. "TLGRNML,Tx Large/Normal Mode Select This field when set indicates that large mode tic generation is used for Tx domain else normal mode tic generation is used" "0: normal mode tic generation is used for Tx..,1: large mode tic generation is used for Tx domain"
            newline
            rbitfld.long 0x00 23. "Reserved_RVCPEIN,Reserved" "0,1"
            newline
            bitfld.long 0x00 22. "R125PEIN,Rx125 FSM One Hot Protection Error Injection This field when set indicates that Error Injection for RX125 FSM One Hot Protection is enabled" "0: Rx125 FSM One Hot Protection Error Injection..,1: Rx125 FSM One Hot Protection Error Injection.."
            newline
            bitfld.long 0x00 21. "T125PEIN,Tx125 FSM One Hot Protection Error Injection This field when set indicates that Error Injection for TX125 FSM One Hot Protection is enabled" "0: Tx125 FSM One Hot Protection Error Injection..,1: Tx125 FSM One Hot Protection Error Injection.."
            newline
            bitfld.long 0x00 20. "PPEIN,PTP FSM One Hot Protection Error Injection This field when set indicates that Error Injection for PTP FSM One Hot Protection is enabled" "0: PTP FSM One Hot Protection Error Injection is..,1: PTP FSM One Hot Protection Error Injection is.."
            newline
            bitfld.long 0x00 19. "APEIN,APP FSM One Hot Protection Error Injection This field when set indicates that Error Injection for APP FSM One Hot Protection is enabled" "0: APP FSM One Hot Protection Error Injection is..,1: APP FSM One Hot Protection Error Injection is.."
            newline
            bitfld.long 0x00 18. "CPEIN,CSR FSM One Hot Protection Error Injection This field when set indicates that Error Injection for CSR Parity is enabled" "0: CSR FSM One Hot Protection Error Injection is..,1: CSR FSM One Hot Protection Error Injection is.."
            newline
            bitfld.long 0x00 17. "RPEIN,Rx FSM One Hot Protection Error Injection This field when set indicates that Error Injection for RX FSM One Hot Protection is enabled" "0: Rx FSM One Hot Protection Error Injection is..,1: Rx FSM One Hot Protection Error Injection is.."
            newline
            bitfld.long 0x00 16. "TPEIN,Tx FSM One Hot Protection Error Injection This field when set indicates that Error Injection for TX FSM One Hot Protection is enabled" "0: Tx FSM One Hot Protection Error Injection is..,1: Tx FSM One Hot Protection Error Injection is.."
            newline
            rbitfld.long 0x00 15. "Reserved_RVCTEIN,Reserved" "0,1"
            newline
            bitfld.long 0x00 14. "R125TEIN,Rx125 FSM Timeout Error Injection This field when set indicates that Error Injection for RX125 FSM timeout is enabled" "0: Rx125 FSM Timeout Error Injection is disabled,1: Rx125 FSM Timeout Error Injection is enabled"
            newline
            bitfld.long 0x00 13. "T125TEIN,Tx125 FSM Timeout Error Injection This field when set indicates that Error Injection for TX125 FSM timeout is enabled" "0: Tx125 FSM Timeout Error Injection is disabled,1: Tx125 FSM Timeout Error Injection is enabled"
            newline
            bitfld.long 0x00 12. "PTEIN,PTP FSM Timeout Error Injection This field when set indicates that Error Injection for PTP FSM timeout is enabled" "0: PTP FSM Timeout Error Injection is disabled,1: PTP FSM Timeout Error Injection is enabled"
            newline
            bitfld.long 0x00 11. "ATEIN,APP FSM Timeout Error Injection This field when set indicates that Error Injection for APP FSM timeout is enabled" "0: APP FSM Timeout Error Injection is disabled,1: APP FSM Timeout Error Injection is enabled"
            newline
            bitfld.long 0x00 10. "CTEIN,CSR FSM Timeout Error Injection This field when set indicates that Error Injection for CSR timeout is enabled" "0: CSR FSM Timeout Error Injection is disabled,1: CSR FSM Timeout Error Injection is enabled"
            newline
            bitfld.long 0x00 9. "RTEIN,Rx FSM Timeout Error Injection This field when set indicates that Error Injection for RX FSM timeout is enabled" "0: Rx FSM Timeout Error Injection is disabled,1: Rx FSM Timeout Error Injection is enabled"
            newline
            bitfld.long 0x00 8. "TTEIN,Tx FSM Timeout Error Injection This field when set indicates that Error Injection for TX FSM timeout is enabled" "0: Tx FSM Timeout Error Injection is disabled,1: Tx FSM Timeout Error Injection is enabled"
            newline
            rbitfld.long 0x00 2.--7. "Reserved_7_2,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 1. "PRTYEN,This bit when set indicates that the FSM One Hot Protection feature is enabled" "0: FSM One Hot Protection feature is disabled,1: FSM One Hot Protection feature is enabled"
            newline
            bitfld.long 0x00 0. "TMOUTEN,This bit when set indicates that the FSM timeout feature is enabled" "0: FSM timeout feature is disabled,1: FSM timeout feature is enabled"
    group.long 0x14C++0x03
        line.long 0x00 "MAC_FSM_ACT_Timer,This register is used to select the FSM and Interface Timeout values"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_31_24,Reserved"
            newline
            bitfld.long 0x00 20.--23. "LTMRMD,Large Mode Timeout Value This field provides the mode value to be used for large mode FSM and other interface time outs" "0: Timer disabled,1: M_1MICRO_SEC,2: 1.024ms (~4ms),3: 16.384ms (~16ms),4: 65.536ms (~64ms),5: 262.144ms (~256ms),6: 1.048sec (~1sec),7: 4.194sec (~4sec),8: 16.777sec (~16sec),9: 33.554sec (~32sec),10: 67.108sec (~64sec),?..."
            newline
            bitfld.long 0x00 16.--19. "NTMRMD,Normal Mode Timeout Value This field provides the value to be used for normal mode FSM and other interface time outs" "0: Timer disabled,1: M_1MICRO_SEC,2: 1.024ms (~4ms),3: 16.384ms (~16ms),4: 65.536ms (~64ms),5: 262.144ms (~256ms),6: 1.048sec (~1sec),7: 4.194sec (~4sec),8: 16.777sec (~16sec),9: 33.554sec (~32sec),10: 67.108sec (~64sec),?..."
            newline
            rbitfld.long 0x00 10.--15. "Reserved_15_10,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            hexmask.long.word 0x00 0.--9. 1. "TMR,CSR Clocks for 1us Tic This field indicates the number of CSR clocks required to generate 1us tic"
    group.long 0x150++0x03
        line.long 0x00 "SNPS_SCS_REG1,Synopsys Reserved Register"
            hexmask.long 0x00 0.--31. 1. "MAC_SCS1,Synopsys Reserved All the bits must be set to 0"
    group.long 0x200++0x03
        line.long 0x00 "MAC_MDIO_Address,The MDIO Address register controls the management cycles to external PHY through a management interface"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 28. "Reserved_RAT,Reserved" "0,1"
            newline
            bitfld.long 0x00 27. "PSE,Preamble Suppression Enable" "0: Preamble Suppression disabled,1: Preamble Suppression enabled"
            newline
            bitfld.long 0x00 26. "BTB,Back-to-Back Transactions" "0: Back to Back transactions disabled,1: Back to Back transactions enabled"
            newline
            bitfld.long 0x00 21.--25. "PA,Physical Layer Address Specifies the address of the PHY device out of the 32 possible PHY devices" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 16.--20. "RDA,Register or Device Address - For clause 22 PHY: Specifies the PHY register address of the selected PHY device" "0: B10T1S PLCA control,1: B10T1S PLCA node control,2: B10T1S PLCA status,3: B10T1S PLCA timer - 5'b00100-5'b01010: Reserved,?,?,?,?,?,?,?,11: B10T1S PCS control,12: B10T1S PCS status,13: B10T1S PCS diagnostic,14: B10T1S PCS diagnostic,15: B10T1S PCS Jab Timer - 5'b10000-5'b10011:..,?,?,?,?,20: B10T1S PMA/PMD extended ability,21: B10T1S PMA/PMD control,22: B10T1S PMA control,23: B10T1S PMA status,24: B10T1S test mode control,25: B10T1S Debug_mode - 5'b11010-5'b11111:..,?..."
            newline
            rbitfld.long 0x00 15. "Reserved_15,Reserved" "0,1"
            newline
            bitfld.long 0x00 12.--14. "NTC,Number of Trailing Clocks This field controls the number of trailing clock cycles generated on the gmii_mdc_o (MDC) signal after the end of MDIO frame transfer" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 8.--11. "CR,CSR Clock Range The CSR Clock Range selection determines the frequency of the MDC clock according to the CSR clock frequency used in your design" "0: CSR clock = 60-100 MHz MDC clock = CSR clock/42,1: CSR clock = 100-150 MHz MDC clock = CSR..,2: CSR clock = 20-35 MHz MDC clock = CSR clock/16,3: 0) ensures that the MDC clock is approximately,4: CSR clock = 150-250 MHz MDC clock = CSR..,5: CSR clock = 250-300 MHz MDC clock = CSR..,6: CSR clock = 300-500 MHz MDC clock = CSR..,7: CSR clock = 500-800 MHz MDC clock = CSR,8: CSR clock/4,9: CSR clock/6,10: CSR clock/8,11: CSR clock/10,12: CSR clock/12,13: CSR clock/14,14: CSR clock/16,15: CSR clock/18"
            newline
            rbitfld.long 0x00 5.--7. "Reserved_7_5,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 4. "SKAP,Skip Address Packet" "0: Skip Address Packet is disabled,1: Skip Address Packet is enabled"
            newline
            bitfld.long 0x00 3. "GOC_1,GMII Operation Command 1 This bit is higher bit of the operation command to the PHY or RevMII GOC_1 and GOC_O is encoded as follows" "0: GMII Operation Command 1 is disabled,1: GMII Operation Command 1 is enabled"
            newline
            bitfld.long 0x00 2. "GOC_0,GMII Operation Command 0 This is the lower bit of the operation command to the PHY or RevMII" "0: GMII Operation Command 0 is disabled,1: GMII Operation Command 0 is enabled"
            newline
            bitfld.long 0x00 1. "C45E,Clause 45 PHY Enable" "0: Clause 45 PHY is disabled,1: Clause 45 PHY is enabled"
            newline
            bitfld.long 0x00 0. "GB,GMII Busy The application writes 1 to this bit to instruct the SMA to initiate a read or write access to the MDIO slave" "0: GMII Busy is disabled,1: GMII Busy is enabled"
    group.long 0x204++0x03
        line.long 0x00 "MAC_MDIO_Data,The MDIO Data register stores the Write data to be written to the PHY register located at the address specified in MAC_MDIO_Address"
            hexmask.long.word 0x00 16.--31. 1. "RA,Register Address This field is valid only when C45E is set"
            newline
            hexmask.long.word 0x00 0.--15. 1. "GD,GMII Data This field contains the 16-bit data value read from the PHY after a Management Read operation or the 16-bit data value to be written to the PHY before a Management Write operation"
    group.long 0x210++0x03
        line.long 0x00 "MAC_ARP_Address,The ARP Address register contains the IPv4 Destination Address of the MAC"
            hexmask.long 0x00 0.--31. 1. "ARPPA,ARP Protocol Address This field contains the IPv4 Destination Address of the MAC"
    group.long 0x230++0x03
        line.long 0x00 "MAC_CSR_SW_Ctrl,This register contains software programmable controls for changing the CSR access response and status bits clearing"
            hexmask.long.tbyte 0x00 10.--31. 1. "Reserved_31_10,Reserved"
            newline
            rbitfld.long 0x00 9. "Reserved_ASPSSE,Reserved" "0,1"
            newline
            bitfld.long 0x00 8. "SEEN,Slave Error Response Enable When this bit is set the MAC responds with Slave Error for accesses to reserved registers in CSR space" "0: Slave Error Response is disabled,1: Slave Error Response is enabled"
            newline
            hexmask.long.byte 0x00 1.--7. 1. "Reserved_7_1,Reserved"
            newline
            bitfld.long 0x00 0. "RCWE,Register Clear on Write 1 Enable When this bit is set the access mode of some register fields changes to Clear on Write 1 the application needs to set that respective bit to 1 to clear it" "0: Register Clear on Write 1 is disabled,1: Register Clear on Write 1 is enabled"
    group.long 0x238++0x03
        line.long 0x00 "MAC_Ext_Cfg1,This register contains Split mode control field and offset field for Split Header feature"
            hexmask.long.byte 0x00 25.--31. 1. "Reserved_31_25,Reserved"
            newline
            bitfld.long 0x00 24. "SAVE,Split AV Enable - When this bit is set to 1 and the received packet is an AV Type packet the header is split at SAVO bytes from the beginning of Length/Type field of the packet for L2 Split" "0,1"
            newline
            rbitfld.long 0x00 23. "Reserved_23,Reserved" "0,1"
            newline
            hexmask.long.byte 0x00 16.--22. 1. "SAVO,Split AV Offset When SAVE bit is set to 1 and the received packet is an AV Type packet these bits indicate the value of the offset from the beginning of Length/Type field at which header should be split when appropriate SPLM is selected"
            newline
            rbitfld.long 0x00 10.--15. "Reserved_15_10,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 8.--9. "SPLM,Split Mode These bits indicate the mode of splitting the incoming Rx packets" "0: Split at L3-L4 header,1: Split at L2 header with an offset,2: Combination mode,?..."
            newline
            rbitfld.long 0x00 7. "Reserved_7,Reserved" "0,1"
            newline
            hexmask.long.byte 0x00 0.--6. 1. "SPLOFST,Split Offset These bits indicate the value of offset from the beginning of Length/Type field at which header split should take place when the appropriate SPLM is selected"

    rgroup.long 0x240++0x03
        line.long 0x00 "MAC_Presn_Time_ns,This register contains the 32-bit binary rollover equivalent time of the PTP System Time in ns"
            hexmask.long 0x00 0.--31. 1. "MPTN,MAC 1722 Presentation Time in ns These bits indicate the value of the 32-bit binary rollover equivalent time of the PTP System Time in ns"

    group.long 0x244++0x03
        line.long 0x00 "MAC_Presn_Time_Updt,This field holds the 32-bit value of MAC 1722 Presentation Time in ns that should be added to the Current Presentation Time Counter value"
            abitfld.long 0x00 0.--31. "MPTU,MAC 1722 Presentation Time Update This field contains the initial value or the update value for the presentation time" "0x00000000=0: Add this 32-bit value in ns to the..,0x00000001=1: Subtract this 32-bit value in ns.."
    group.long 0x300++0x03
        line.long 0x00 "MAC_Address0_High,The MAC Address0 High register holds the upper 16 bits of the 1st 6-byte MAC address of the station"
            rbitfld.long 0x00 31. "AE,Address Enable This bit is always set to 1" "0: INVALID,1: This bit is always set to 1"
            newline
            hexmask.long.word 0x00 18.--30. 1. "Reserved_30_y,Reserved"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select This field indicates the Rx DMA channel number or DMA channel numbers to which the MAC routes the received packet" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address0[47:32] This field contains the upper 16 bits [47:32] of the 1st 6-byte MAC address"
    group.long 0x304++0x03
        line.long 0x00 "MAC_Address0_Low,The MAC Address0 Low register holds the lower 32 bits of the 1st 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address0[31:0] This field contains the lower 32 bits of the 1st 6-byte MAC address"
    group.long 0x308++0x03
        line.long 0x00 "MAC_Address1_High,The MAC Address1 High register holds the upper 16 bits of the 2nd 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 2nd MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address1[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address1_Low[7:0] You can filter a group..,?,?,27: MAC_Address1_Low[31:24],28: MAC_Address1_High[7:0] - Bit,29: MAC_Address1_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address1 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address1 [47:32] This field contains the upper 16 bits[47:32] of the 2nd 6-byte MAC address"
    group.long 0x30C++0x03
        line.long 0x00 "MAC_Address1_Low,The MAC Address1 Low register holds the lower 32 bits of the 2nd 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address1 [31:0] This field contains the lower 32 bits of 2nd 6-byte MAC address"
    group.long 0x310++0x03
        line.long 0x00 "MAC_Address2_High,The MAC Address2 High register holds the upper 16 bits of the 3rd 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 3rd MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address2[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address2_Low[7:0] You can filter a group..,?,?,27: MAC_Address2_Low[31:24],28: MAC_Address2_High[7:0] - Bit,29: MAC_Address2_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address2 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address2 [47:32] This field contains the upper 16 bits[47:32] of the 3rd 6-byte MAC address"
    group.long 0x314++0x03
        line.long 0x00 "MAC_Address2_Low,The MAC Address2 Low register holds the lower 32 bits of the 3rd 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address2 [31:0] This field contains the lower 32 bits of 3rd 6-byte MAC address"
    group.long 0x318++0x03
        line.long 0x00 "MAC_Address3_High,The MAC Address3 High register holds the upper 16 bits of the 4th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 4th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address3[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address3_Low[7:0] You can filter a group..,?,?,27: MAC_Address3_Low[31:24],28: MAC_Address3_High[7:0] - Bit,29: MAC_Address3_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address3 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address3 [47:32] This field contains the upper 16 bits[47:32] of the 4th 6-byte MAC address"
    group.long 0x31C++0x03
        line.long 0x00 "MAC_Address3_Low,The MAC Address3 Low register holds the lower 32 bits of the 4th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address3 [31:0] This field contains the lower 32 bits of 4th 6-byte MAC address"
    group.long 0x320++0x03
        line.long 0x00 "MAC_Address4_High,The MAC Address4 High register holds the upper 16 bits of the 5th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 5th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address4[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address4_Low[7:0] You can filter a group..,?,?,27: MAC_Address4_Low[31:24],28: MAC_Address4_High[7:0] - Bit,29: MAC_Address4_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address4 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address4 [47:32] This field contains the upper 16 bits[47:32] of the 5th 6-byte MAC address"
    group.long 0x324++0x03
        line.long 0x00 "MAC_Address4_Low,The MAC Address4 Low register holds the lower 32 bits of the 5th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address4 [31:0] This field contains the lower 32 bits of 5th 6-byte MAC address"
    group.long 0x328++0x03
        line.long 0x00 "MAC_Address5_High,The MAC Address5 High register holds the upper 16 bits of the 6th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 6th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address5[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address5_Low[7:0] You can filter a group..,?,?,27: MAC_Address5_Low[31:24],28: MAC_Address5_High[7:0] - Bit,29: MAC_Address5_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address5 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address5 [47:32] This field contains the upper 16 bits[47:32] of the 6th 6-byte MAC address"
    group.long 0x32C++0x03
        line.long 0x00 "MAC_Address5_Low,The MAC Address5 Low register holds the lower 32 bits of the 6th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address5 [31:0] This field contains the lower 32 bits of 6th 6-byte MAC address"
    group.long 0x330++0x03
        line.long 0x00 "MAC_Address6_High,The MAC Address6 High register holds the upper 16 bits of the 7th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 7th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address6[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address6_Low[7:0] You can filter a group..,?,?,27: MAC_Address6_Low[31:24],28: MAC_Address6_High[7:0] - Bit,29: MAC_Address6_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address6 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address6 [47:32] This field contains the upper 16 bits[47:32] of the 7th 6-byte MAC address"
    group.long 0x334++0x03
        line.long 0x00 "MAC_Address6_Low,The MAC Address6 Low register holds the lower 32 bits of the 7th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address6 [31:0] This field contains the lower 32 bits of 7th 6-byte MAC address"
    group.long 0x338++0x03
        line.long 0x00 "MAC_Address7_High,The MAC Address7 High register holds the upper 16 bits of the 8th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 8th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address7[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address7_Low[7:0] You can filter a group..,?,?,27: MAC_Address7_Low[31:24],28: MAC_Address7_High[7:0] - Bit,29: MAC_Address7_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address7 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address7 [47:32] This field contains the upper 16 bits[47:32] of the 8th 6-byte MAC address"
    group.long 0x33C++0x03
        line.long 0x00 "MAC_Address7_Low,The MAC Address7 Low register holds the lower 32 bits of the 8th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address7 [31:0] This field contains the lower 32 bits of 8th 6-byte MAC address"
    group.long 0x340++0x03
        line.long 0x00 "MAC_Address8_High,The MAC Address8 High register holds the upper 16 bits of the 9th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 9th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address8[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address8_Low[7:0] You can filter a group..,?,?,27: MAC_Address8_Low[31:24],28: MAC_Address8_High[7:0] - Bit,29: MAC_Address8_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address8 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address8 [47:32] This field contains the upper 16 bits[47:32] of the 9th 6-byte MAC address"
    group.long 0x344++0x03
        line.long 0x00 "MAC_Address8_Low,The MAC Address8 Low register holds the lower 32 bits of the 9th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address8 [31:0] This field contains the lower 32 bits of 9th 6-byte MAC address"
    group.long 0x348++0x03
        line.long 0x00 "MAC_Address9_High,The MAC Address9 High register holds the upper 16 bits of the 10th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 10th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address9[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address9_Low[7:0] You can filter a group..,?,?,27: MAC_Address9_Low[31:24],28: MAC_Address9_High[7:0] - Bit,29: MAC_Address9_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address9 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address9 [47:32] This field contains the upper 16 bits[47:32] of the 10th 6-byte MAC address"
    group.long 0x34C++0x03
        line.long 0x00 "MAC_Address9_Low,The MAC Address9 Low register holds the lower 32 bits of the 10th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address9 [31:0] This field contains the lower 32 bits of 10th 6-byte MAC address"
    group.long 0x350++0x03
        line.long 0x00 "MAC_Address10_High,The MAC Address10 High register holds the upper 16 bits of the 11th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 11th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address10[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address10_Low[7:0] You can filter a..,?,?,27: MAC_Address10_Low[31:24],28: MAC_Address10_High[7:0] - Bit,29: MAC_Address10_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address10 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address10 [47:32] This field contains the upper 16 bits[47:32] of the 11th 6-byte MAC address"
    group.long 0x354++0x03
        line.long 0x00 "MAC_Address10_Low,The MAC Address10 Low register holds the lower 32 bits of the 11th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address10 [31:0] This field contains the lower 32 bits of 11th 6-byte MAC address"
    group.long 0x358++0x03
        line.long 0x00 "MAC_Address11_High,The MAC Address11 High register holds the upper 16 bits of the 12th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 12th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address11[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address11_Low[7:0] You can filter a..,?,?,27: MAC_Address11_Low[31:24],28: MAC_Address11_High[7:0] - Bit,29: MAC_Address11_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address11 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address11 [47:32] This field contains the upper 16 bits[47:32] of the 12th 6-byte MAC address"
    group.long 0x35C++0x03
        line.long 0x00 "MAC_Address11_Low,The MAC Address11 Low register holds the lower 32 bits of the 12th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address11 [31:0] This field contains the lower 32 bits of 12th 6-byte MAC address"
    group.long 0x360++0x03
        line.long 0x00 "MAC_Address12_High,The MAC Address12 High register holds the upper 16 bits of the 13th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 13th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address12[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address12_Low[7:0] You can filter a..,?,?,27: MAC_Address12_Low[31:24],28: MAC_Address12_High[7:0] - Bit,29: MAC_Address12_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address12 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address12 [47:32] This field contains the upper 16 bits[47:32] of the 13th 6-byte MAC address"
    group.long 0x364++0x03
        line.long 0x00 "MAC_Address12_Low,The MAC Address12 Low register holds the lower 32 bits of the 13th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address12 [31:0] This field contains the lower 32 bits of 13th 6-byte MAC address"
    group.long 0x368++0x03
        line.long 0x00 "MAC_Address13_High,The MAC Address13 High register holds the upper 16 bits of the 14th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 14th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address13[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address13_Low[7:0] You can filter a..,?,?,27: MAC_Address13_Low[31:24],28: MAC_Address13_High[7:0] - Bit,29: MAC_Address13_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address13 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address13 [47:32] This field contains the upper 16 bits[47:32] of the 14th 6-byte MAC address"
    group.long 0x36C++0x03
        line.long 0x00 "MAC_Address13_Low,The MAC Address13 Low register holds the lower 32 bits of the 14th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address13 [31:0] This field contains the lower 32 bits of 14th 6-byte MAC address"
    group.long 0x370++0x03
        line.long 0x00 "MAC_Address14_High,The MAC Address14 High register holds the upper 16 bits of the 15th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 15th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address14[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address14_Low[7:0] You can filter a..,?,?,27: MAC_Address14_Low[31:24],28: MAC_Address14_High[7:0] - Bit,29: MAC_Address14_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address14 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address14 [47:32] This field contains the upper 16 bits[47:32] of the 15th 6-byte MAC address"
    group.long 0x374++0x03
        line.long 0x00 "MAC_Address14_Low,The MAC Address14 Low register holds the lower 32 bits of the 15th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address14 [31:0] This field contains the lower 32 bits of 15th 6-byte MAC address"
    group.long 0x378++0x03
        line.long 0x00 "MAC_Address15_High,The MAC Address15 High register holds the upper 16 bits of the 16th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 16th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address15[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address15_Low[7:0] You can filter a..,?,?,27: MAC_Address15_Low[31:24],28: MAC_Address15_High[7:0] - Bit,29: MAC_Address15_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address15 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address15 [47:32] This field contains the upper 16 bits[47:32] of the 16th 6-byte MAC address"
    group.long 0x37C++0x03
        line.long 0x00 "MAC_Address15_Low,The MAC Address15 Low register holds the lower 32 bits of the 16th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address15 [31:0] This field contains the lower 32 bits of 16th 6-byte MAC address"
    group.long 0x380++0x03
        line.long 0x00 "MAC_Address16_High,The MAC Address16 High register holds the upper 16 bits of the 17th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 17th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address16[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address16_Low[7:0] You can filter a..,?,?,27: MAC_Address16_Low[31:24],28: MAC_Address16_High[7:0] - Bit,29: MAC_Address16_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address16 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address16 [47:32] This field contains the upper 16 bits[47:32] of the 17th 6-byte MAC address"
    group.long 0x384++0x03
        line.long 0x00 "MAC_Address16_Low,The MAC Address16 Low register holds the lower 32 bits of the 17th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address16 [31:0] This field contains the lower 32 bits of 17th 6-byte MAC address"
    group.long 0x388++0x03
        line.long 0x00 "MAC_Address17_High,The MAC Address17 High register holds the upper 16 bits of the 18th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 18th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address17[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address17_Low[7:0] You can filter a..,?,?,27: MAC_Address17_Low[31:24],28: MAC_Address17_High[7:0] - Bit,29: MAC_Address17_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address17 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address17 [47:32] This field contains the upper 16 bits[47:32] of the 18th 6-byte MAC address"
    group.long 0x38C++0x03
        line.long 0x00 "MAC_Address17_Low,The MAC Address17 Low register holds the lower 32 bits of the 18th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address17 [31:0] This field contains the lower 32 bits of 18th 6-byte MAC address"
    group.long 0x390++0x03
        line.long 0x00 "MAC_Address18_High,The MAC Address18 High register holds the upper 16 bits of the 19th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 19th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address18[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address18_Low[7:0] You can filter a..,?,?,27: MAC_Address18_Low[31:24],28: MAC_Address18_High[7:0] - Bit,29: MAC_Address18_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address18 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address18 [47:32] This field contains the upper 16 bits[47:32] of the 19th 6-byte MAC address"
    group.long 0x394++0x03
        line.long 0x00 "MAC_Address18_Low,The MAC Address18 Low register holds the lower 32 bits of the 19th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address18 [31:0] This field contains the lower 32 bits of 19th 6-byte MAC address"
    group.long 0x398++0x03
        line.long 0x00 "MAC_Address19_High,The MAC Address19 High register holds the upper 16 bits of the 20th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 20th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address19[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address19_Low[7:0] You can filter a..,?,?,27: MAC_Address19_Low[31:24],28: MAC_Address19_High[7:0] - Bit,29: MAC_Address19_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address19 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address19 [47:32] This field contains the upper 16 bits[47:32] of the 20th 6-byte MAC address"
    group.long 0x39C++0x03
        line.long 0x00 "MAC_Address19_Low,The MAC Address19 Low register holds the lower 32 bits of the 20th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address19 [31:0] This field contains the lower 32 bits of 20th 6-byte MAC address"
    group.long 0x3A0++0x03
        line.long 0x00 "MAC_Address20_High,The MAC Address20 High register holds the upper 16 bits of the 21st 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 21st MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address20[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address20_Low[7:0] You can filter a..,?,?,27: MAC_Address20_Low[31:24],28: MAC_Address20_High[7:0] - Bit,29: MAC_Address20_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address20 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address20 [47:32] This field contains the upper 16 bits[47:32] of the 21st 6-byte MAC address"
    group.long 0x3A4++0x03
        line.long 0x00 "MAC_Address20_Low,The MAC Address20 Low register holds the lower 32 bits of the 21st 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address20 [31:0] This field contains the lower 32 bits of 21st 6-byte MAC address"
    group.long 0x3A8++0x03
        line.long 0x00 "MAC_Address21_High,The MAC Address21 High register holds the upper 16 bits of the 22nd 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 22nd MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address21[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address21_Low[7:0] You can filter a..,?,?,27: MAC_Address21_Low[31:24],28: MAC_Address21_High[7:0] - Bit,29: MAC_Address21_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address21 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address21 [47:32] This field contains the upper 16 bits[47:32] of the 22nd 6-byte MAC address"
    group.long 0x3AC++0x03
        line.long 0x00 "MAC_Address21_Low,The MAC Address21 Low register holds the lower 32 bits of the 22nd 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address21 [31:0] This field contains the lower 32 bits of 22nd 6-byte MAC address"
    group.long 0x3B0++0x03
        line.long 0x00 "MAC_Address22_High,The MAC Address22 High register holds the upper 16 bits of the 23rd 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 23rd MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address22[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address22_Low[7:0] You can filter a..,?,?,27: MAC_Address22_Low[31:24],28: MAC_Address22_High[7:0] - Bit,29: MAC_Address22_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address22 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address22 [47:32] This field contains the upper 16 bits[47:32] of the 23rd 6-byte MAC address"
    group.long 0x3B4++0x03
        line.long 0x00 "MAC_Address22_Low,The MAC Address22 Low register holds the lower 32 bits of the 23rd 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address22 [31:0] This field contains the lower 32 bits of 23rd 6-byte MAC address"
    group.long 0x3B8++0x03
        line.long 0x00 "MAC_Address23_High,The MAC Address23 High register holds the upper 16 bits of the 24th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 24th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address23[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address23_Low[7:0] You can filter a..,?,?,27: MAC_Address23_Low[31:24],28: MAC_Address23_High[7:0] - Bit,29: MAC_Address23_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address23 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address23 [47:32] This field contains the upper 16 bits[47:32] of the 24th 6-byte MAC address"
    group.long 0x3BC++0x03
        line.long 0x00 "MAC_Address23_Low,The MAC Address23 Low register holds the lower 32 bits of the 24th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address23 [31:0] This field contains the lower 32 bits of 24th 6-byte MAC address"
    group.long 0x3C0++0x03
        line.long 0x00 "MAC_Address24_High,The MAC Address24 High register holds the upper 16 bits of the 25th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 25th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address24[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address24_Low[7:0] You can filter a..,?,?,27: MAC_Address24_Low[31:24],28: MAC_Address24_High[7:0] - Bit,29: MAC_Address24_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address24 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address24 [47:32] This field contains the upper 16 bits[47:32] of the 25th 6-byte MAC address"
    group.long 0x3C4++0x03
        line.long 0x00 "MAC_Address24_Low,The MAC Address24 Low register holds the lower 32 bits of the 25th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address24 [31:0] This field contains the lower 32 bits of 25th 6-byte MAC address"
    group.long 0x3C8++0x03
        line.long 0x00 "MAC_Address25_High,The MAC Address25 High register holds the upper 16 bits of the 26th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 26th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address25[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address25_Low[7:0] You can filter a..,?,?,27: MAC_Address25_Low[31:24],28: MAC_Address25_High[7:0] - Bit,29: MAC_Address25_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address25 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address25 [47:32] This field contains the upper 16 bits[47:32] of the 26th 6-byte MAC address"
    group.long 0x3CC++0x03
        line.long 0x00 "MAC_Address25_Low,The MAC Address25 Low register holds the lower 32 bits of the 26th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address25 [31:0] This field contains the lower 32 bits of 26th 6-byte MAC address"
    group.long 0x3D0++0x03
        line.long 0x00 "MAC_Address26_High,The MAC Address26 High register holds the upper 16 bits of the 27th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 27th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address26[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address26_Low[7:0] You can filter a..,?,?,27: MAC_Address26_Low[31:24],28: MAC_Address26_High[7:0] - Bit,29: MAC_Address26_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address26 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address26 [47:32] This field contains the upper 16 bits[47:32] of the 27th 6-byte MAC address"
    group.long 0x3D4++0x03
        line.long 0x00 "MAC_Address26_Low,The MAC Address26 Low register holds the lower 32 bits of the 27th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address26 [31:0] This field contains the lower 32 bits of 27th 6-byte MAC address"
    group.long 0x3D8++0x03
        line.long 0x00 "MAC_Address27_High,The MAC Address27 High register holds the upper 16 bits of the 28th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 28th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address27[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address27_Low[7:0] You can filter a..,?,?,27: MAC_Address27_Low[31:24],28: MAC_Address27_High[7:0] - Bit,29: MAC_Address27_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address27 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address27 [47:32] This field contains the upper 16 bits[47:32] of the 28th 6-byte MAC address"
    group.long 0x3DC++0x03
        line.long 0x00 "MAC_Address27_Low,The MAC Address27 Low register holds the lower 32 bits of the 28th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address27 [31:0] This field contains the lower 32 bits of 28th 6-byte MAC address"
    group.long 0x3E0++0x03
        line.long 0x00 "MAC_Address28_High,The MAC Address28 High register holds the upper 16 bits of the 29th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 29th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address28[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address28_Low[7:0] You can filter a..,?,?,27: MAC_Address28_Low[31:24],28: MAC_Address28_High[7:0] - Bit,29: MAC_Address28_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address28 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address28 [47:32] This field contains the upper 16 bits[47:32] of the 29th 6-byte MAC address"
    group.long 0x3E4++0x03
        line.long 0x00 "MAC_Address28_Low,The MAC Address28 Low register holds the lower 32 bits of the 29th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address28 [31:0] This field contains the lower 32 bits of 29th 6-byte MAC address"
    group.long 0x3E8++0x03
        line.long 0x00 "MAC_Address29_High,The MAC Address29 High register holds the upper 16 bits of the 30th 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 30th MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address29[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address29_Low[7:0] You can filter a..,?,?,27: MAC_Address29_Low[31:24],28: MAC_Address29_High[7:0] - Bit,29: MAC_Address29_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address29 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address29 [47:32] This field contains the upper 16 bits[47:32] of the 30th 6-byte MAC address"
    group.long 0x3EC++0x03
        line.long 0x00 "MAC_Address29_Low,The MAC Address29 Low register holds the lower 32 bits of the 30th 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address29 [31:0] This field contains the lower 32 bits of 30th 6-byte MAC address"
    group.long 0x3F0++0x03
        line.long 0x00 "MAC_Address30_High,The MAC Address30 High register holds the upper 16 bits of the 31st 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 31st MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address30[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address30_Low[7:0] You can filter a..,?,?,27: MAC_Address30_Low[31:24],28: MAC_Address30_High[7:0] - Bit,29: MAC_Address30_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address30 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address30 [47:32] This field contains the upper 16 bits[47:32] of the 31st 6-byte MAC address"
    group.long 0x3F4++0x03
        line.long 0x00 "MAC_Address30_Low,The MAC Address30 Low register holds the lower 32 bits of the 31st 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address30 [31:0] This field contains the lower 32 bits of 31st 6-byte MAC address"
    group.long 0x3F8++0x03
        line.long 0x00 "MAC_Address31_High,The MAC Address31 High register holds the upper 16 bits of the 32nd 6-byte MAC address of the station"
            bitfld.long 0x00 31. "AE,Address Enable When this bit is set the address filter module uses the 32nd MAC address for perfect filtering" "0: Address is ignored,1: Address is enabled"
            newline
            bitfld.long 0x00 30. "SA,Source Address When this bit is set the MAC Address31[47:0] is used to compare with the SA fields of the received packet" "0: Compare with Destination Address,1: Compare with Source Address"
            newline
            bitfld.long 0x00 24.--29. "MBC,Mask Byte Control These bits are mask control bits for comparing each of the MAC Address bytes" "?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,24: MAC_Address31_Low[7:0] You can filter a..,?,?,27: MAC_Address31_Low[31:24],28: MAC_Address31_High[7:0] - Bit,29: MAC_Address31_High[15:8] - Bit,?..."
            newline
            rbitfld.long 0x00 18.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 16.--17. "DCS,DMA Channel Select If the PDC bit of MAC_Ext_Configuration register is not set: This field contains the binary representation of the DMA Channel number to which an Rx packet whose DA matches the MAC Address31 content is routed" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--15. 1. "ADDRHI,MAC Address31 [47:32] This field contains the upper 16 bits[47:32] of the 32nd 6-byte MAC address"
    group.long 0x3FC++0x03
        line.long 0x00 "MAC_Address31_Low,The MAC Address31 Low register holds the lower 32 bits of the 32nd 6-byte MAC address of the station"
            hexmask.long 0x00 0.--31. 1. "ADDRLO,MAC Address31 [31:0] This field contains the lower 32 bits of 32nd 6-byte MAC address"
    group.long 0x700++0x03
        line.long 0x00 "MMC_Control,This register establishes the operating mode of MMC"
            hexmask.long.tbyte 0x00 9.--31. 1. "Reserved_31_9,Reserved"
            newline
            bitfld.long 0x00 8. "UCDBC,Update MMC Counters for Dropped Broadcast Packets Note: The CNTRST bit has a higher priority than the CNTPRST bit" "0: Update MMC Counters for Dropped Broadcast..,1: Update MMC Counters for Dropped Broadcast.."
            newline
            rbitfld.long 0x00 6.--7. "Reserved_7_6,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 5. "CNTPRSTLVL,Full-Half Preset When this bit is low and the CNTPRST bit is set all MMC counters get preset to almost-half value" "0: Full-Half Preset is disabled,1: Full-Half Preset is enabled"
            newline
            bitfld.long 0x00 4. "CNTPRST,Counters Preset When this bit is set all counters are initialized or preset to almost full or almost half according to the CNTPRSTLVL bit" "0: Counters Preset is disabled,1: Counters Preset is enabled"
            newline
            bitfld.long 0x00 3. "CNTFREEZ,MMC Counter Freeze When this bit is set it freezes all MMC counters to their current value" "0: MMC Counter Freeze is disabled,1: MMC Counter Freeze is enabled"
            newline
            bitfld.long 0x00 2. "RSTONRD,Reset on Read When this bit is set the MMC counters are reset to zero after Read (self-clearing after reset)" "0: Reset on Read is disabled,1: Reset on Read is enabled"
            newline
            bitfld.long 0x00 1. "CNTSTOPRO,Counter Stop Rollover When this bit is set the counter does not roll over to zero after reaching the maximum value" "0: Counter Stop Rollover is disabled,1: Counter Stop Rollover is enabled"
            newline
            bitfld.long 0x00 0. "CNTRST,Counters Reset When this bit is set all counters are reset" "0: Counters are not reset,1: All counters are reset"

    rgroup.long 0x704++0x03
        line.long 0x00 "MMC_Rx_Interrupt,This register maintains the interrupts generated from all Receive statistics counters"
            bitfld.long 0x00 28.--31. "Reserved_31_28,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 27. "Reserved_RXLPITRCIS,Reserved" "0,1"
            newline
            bitfld.long 0x00 26. "Reserved_RXLPIUSCIS,Reserved" "0,1"
            newline
            bitfld.long 0x00 25. "RXCTRLPIS,MMC Receive Control Packet Counter Interrupt Status This bit is set when the Rx_Control_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Control Packet Counter Interrupt..,1: MMC Receive Control Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 24. "RXRCVERRPIS,MMC Receive Error Packet Counter Interrupt Status This bit is set when the Rx_Receive_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Error Packet Counter Interrupt..,1: MMC Receive Error Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 23. "RXWDOGPIS,MMC Receive Watchdog Error Packet Counter Interrupt Status This bit is set when the Rx_Watchdog_Error_Packets error counter reaches half of the maximum value or the maximum value" "0: MMC Receive Watchdog Error Packet Counter..,1: MMC Receive Watchdog Error Packet Counter.."
            newline
            bitfld.long 0x00 22. "RXVLANGBPIS,MMC Receive VLAN Good Bad Packet Counter Interrupt Status This bit is set when the Rx_VLAN_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive VLAN Good Bad Packet Counter..,1: MMC Receive VLAN Good Bad Packet Counter.."
            newline
            bitfld.long 0x00 21. "RXFOVPIS,MMC Receive FIFO Overflow Packet Counter Interrupt Status This bit is set when the Rx_FIFO_Overflow_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive FIFO Overflow Packet Counter..,1: MMC Receive FIFO Overflow Packet Counter.."
            newline
            bitfld.long 0x00 20. "RXPAUSPIS,MMC Receive Pause Packet Counter Interrupt Status This bit is set when the Rx_Pause_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Pause Packet Counter Interrupt..,1: MMC Receive Pause Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 19. "RXORANGEPIS,MMC Receive Out Of Range Error Packet Counter Interrupt Status" "0: MMC Receive Out Of Range Error Packet Counter..,1: MMC Receive Out Of Range Error Packet Counter.."
            newline
            bitfld.long 0x00 18. "RXLENERPIS,MMC Receive Length Error Packet Counter Interrupt Status This bit is set when the Rx_Length_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Length Error Packet Counter..,1: MMC Receive Length Error Packet Counter.."
            newline
            bitfld.long 0x00 17. "RXUCGPIS,MMC Receive Unicast Good Packet Counter Interrupt Status This bit is set when the Rx_Unicast_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Unicast Good Packet Counter..,1: MMC Receive Unicast Good Packet Counter.."
            newline
            bitfld.long 0x00 16. "RX1024TMAXOCTGBPIS,MMC Receive 1024 to Maximum Octet Good Bad Packet Counter Interrupt Status This bit is set when the Rx_1024ToMaxOctets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive 1024 to Maximum Octet Good Bad..,1: MMC Receive 1024 to Maximum Octet Good Bad.."
            newline
            bitfld.long 0x00 15. "RX512T1023OCTGBPIS,MMC Receive 512 to 1023 Octet Good Bad Packet Counter Interrupt Status This bit is set when the Rx_512To1023Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive 512 to 1023 Octet Good Bad Packet..,1: MMC Receive 512 to 1023 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 14. "RX256T511OCTGBPIS,MMC Receive 256 to 511 Octet Good Bad Packet Counter Interrupt Status This bit is set when the Rx_256To511Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive 256 to 511 Octet Good Bad Packet..,1: MMC Receive 256 to 511 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 13. "RX128T255OCTGBPIS,MMC Receive 128 to 255 Octet Good Bad Packet Counter Interrupt Status This bit is set when the Rx_128To255Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive 128 to 255 Octet Good Bad Packet..,1: MMC Receive 128 to 255 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 12. "RX65T127OCTGBPIS,MMC Receive 65 to 127 Octet Good Bad Packet Counter Interrupt Status This bit is set when the Rx_65To127Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive 65 to 127 Octet Good Bad Packet..,1: MMC Receive 65 to 127 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 11. "RX64OCTGBPIS,MMC Receive 64 Octet Good Bad Packet Counter Interrupt Status This bit is set when the Rx_64Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive 64 Octet Good Bad Packet Counter..,1: MMC Receive 64 Octet Good Bad Packet Counter.."
            newline
            bitfld.long 0x00 10. "RXOSIZEGPIS,MMC Receive Oversize Good Packet Counter Interrupt Status This bit is set when the Rx_Oversize_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Oversize Good Packet Counter..,1: MMC Receive Oversize Good Packet Counter.."
            newline
            bitfld.long 0x00 9. "RXUSIZEGPIS,MMC Receive Undersize Good Packet Counter Interrupt Status This bit is set when the Rx_Undersize_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Undersize Good Packet Counter..,1: MMC Receive Undersize Good Packet Counter.."
            newline
            bitfld.long 0x00 8. "RXJABERPIS,MMC Receive Jabber Error Packet Counter Interrupt Status This bit is set when the Rx_Jabber_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Jabber Error Packet Counter..,1: MMC Receive Jabber Error Packet Counter.."
            newline
            bitfld.long 0x00 7. "RXRUNTPIS,MMC Receive Runt Packet Counter Interrupt Status This bit is set when the Rx_Runt_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Runt Packet Counter Interrupt..,1: MMC Receive Runt Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 6. "RXALGNERPIS,MMC Receive Alignment Error Packet Counter Interrupt Status This bit is set when the Rx_Alignment_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Alignment Error Packet Counter..,1: MMC Receive Alignment Error Packet Counter.."
            newline
            bitfld.long 0x00 5. "RXCRCERPIS,MMC Receive CRC Error Packet Counter Interrupt Status This bit is set when the Rx_CRC_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive CRC Error Packet Counter..,1: MMC Receive CRC Error Packet Counter.."
            newline
            bitfld.long 0x00 4. "RXMCGPIS,MMC Receive Multicast Good Packet Counter Interrupt Status This bit is set when the Rx_Multicast_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Multicast Good Packet Counter..,1: MMC Receive Multicast Good Packet Counter.."
            newline
            bitfld.long 0x00 3. "RXBCGPIS,MMC Receive Broadcast Good Packet Counter Interrupt Status This bit is set when the Rx_Broadcast_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Broadcast Good Packet Counter..,1: MMC Receive Broadcast Good Packet Counter.."
            newline
            bitfld.long 0x00 2. "RXGOCTIS,MMC Receive Good Octet Counter Interrupt Status This bit is set when the Rx_Octet_Count_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Good Octet Counter Interrupt..,1: MMC Receive Good Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 1. "RXGBOCTIS,MMC Receive Good Bad Octet Counter Interrupt Status This bit is set when the Rx_Octet_Count_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive Good Bad Octet Counter Interrupt..,1: MMC Receive Good Bad Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 0. "RXGBPKTIS,MMC Receive Good Bad Packet Counter Interrupt Status This bit is set when the Rx_Packets_Count_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive Good Bad Packet Counter Interrupt..,1: MMC Receive Good Bad Packet Counter Interrupt.."
    rgroup.long 0x708++0x03
        line.long 0x00 "MMC_Tx_Interrupt,This register maintains the interrupts generated from all Transmit statistics counters"
            bitfld.long 0x00 28.--31. "Reserved_31_28,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 27. "Reserved_TXLPITRCIS,Reserved" "0,1"
            newline
            bitfld.long 0x00 26. "Reserved_TXLPIUSCIS,Reserved" "0,1"
            newline
            bitfld.long 0x00 25. "TXOSIZEGPIS,MMC Transmit Oversize Good Packet Counter Interrupt Status This bit is set when the Tx_OSize_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Oversize Good Packet Counter..,1: MMC Transmit Oversize Good Packet Counter.."
            newline
            bitfld.long 0x00 24. "TXVLANGPIS,MMC Transmit VLAN Good Packet Counter Interrupt Status This bit is set when the Tx_VLAN_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Transmit VLAN Good Packet Counter..,1: MMC Transmit VLAN Good Packet Counter.."
            newline
            bitfld.long 0x00 23. "TXPAUSPIS,MMC Transmit Pause Packet Counter Interrupt Status This bit is set when the Tx_Pause_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Pause Packet Counter Interrupt..,1: MMC Transmit Pause Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 22. "TXEXDEFPIS,MMC Transmit Excessive Deferral Packet Counter Interrupt Status This bit is set when the Tx_Excessive_Deferral_Error counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Excessive Deferral Packet..,1: MMC Transmit Excessive Deferral Packet.."
            newline
            bitfld.long 0x00 21. "TXGPKTIS,MMC Transmit Good Packet Counter Interrupt Status This bit is set when the Tx_Packet_Count_Good counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Good Packet Counter Interrupt..,1: MMC Transmit Good Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 20. "TXGOCTIS,MMC Transmit Good Octet Counter Interrupt Status This bit is set when the Tx_Octet_Count_Good counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Good Octet Counter Interrupt..,1: MMC Transmit Good Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 19. "TXCARERPIS,MMC Transmit Carrier Error Packet Counter Interrupt Status This bit is set when the Tx_Carrier_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Carrier Error Packet Counter..,1: MMC Transmit Carrier Error Packet Counter.."
            newline
            bitfld.long 0x00 18. "TXEXCOLPIS,MMC Transmit Excessive Collision Packet Counter Interrupt Status This bit is set when the Tx_Excessive_Collision_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Excessive Collision Packet..,1: MMC Transmit Excessive Collision Packet.."
            newline
            bitfld.long 0x00 17. "TXLATCOLPIS,MMC Transmit Late Collision Packet Counter Interrupt Status This bit is set when the Tx_Late_Collision_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Late Collision Packet Counter..,1: MMC Transmit Late Collision Packet Counter.."
            newline
            bitfld.long 0x00 16. "TXDEFPIS,MMC Transmit Deferred Packet Counter Interrupt Status This bit is set when the Tx_Deferred_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Deferred Packet Counter..,1: MMC Transmit Deferred Packet Counter.."
            newline
            bitfld.long 0x00 15. "TXMCOLGPIS,MMC Transmit Multiple Collision Good Packet Counter Interrupt Status This bit is set when the Tx_Multiple_Collision_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Multiple Collision Good Packet..,1: MMC Transmit Multiple Collision Good Packet.."
            newline
            bitfld.long 0x00 14. "TXSCOLGPIS,MMC Transmit Single Collision Good Packet Counter Interrupt Status This bit is set when the Tx_Single_Collision_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Single Collision Good Packet..,1: MMC Transmit Single Collision Good Packet.."
            newline
            bitfld.long 0x00 13. "TXUFLOWERPIS,MMC Transmit Underflow Error Packet Counter Interrupt Status This bit is set when the Tx_Underflow_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Underflow Error Packet Counter..,1: MMC Transmit Underflow Error Packet Counter.."
            newline
            bitfld.long 0x00 12. "TXBCGBPIS,MMC Transmit Broadcast Good Bad Packet Counter Interrupt Status This bit is set when the Tx_Broadcast_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Broadcast Good Bad Packet..,1: MMC Transmit Broadcast Good Bad Packet.."
            newline
            bitfld.long 0x00 11. "TXMCGBPIS,MMC Transmit Multicast Good Bad Packet Counter Interrupt Status The bit is set when the Tx_Multicast_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Multicast Good Bad Packet..,1: MMC Transmit Multicast Good Bad Packet.."
            newline
            bitfld.long 0x00 10. "TXUCGBPIS,MMC Transmit Unicast Good Bad Packet Counter Interrupt Status This bit is set when the Tx_Unicast_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Unicast Good Bad Packet Counter..,1: MMC Transmit Unicast Good Bad Packet Counter.."
            newline
            bitfld.long 0x00 9. "TX1024TMAXOCTGBPIS,MMC Transmit 1024 to Maximum Octet Good Bad Packet Counter Interrupt Status This bit is set when the Tx_1024ToMaxOctets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit 1024 to Maximum Octet Good Bad..,1: MMC Transmit 1024 to Maximum Octet Good Bad.."
            newline
            bitfld.long 0x00 8. "TX512T1023OCTGBPIS,MMC Transmit 512 to 1023 Octet Good Bad Packet Counter Interrupt Status This bit is set when the Tx_512To1023Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit 512 to 1023 Octet Good Bad..,1: MMC Transmit 512 to 1023 Octet Good Bad.."
            newline
            bitfld.long 0x00 7. "TX256T511OCTGBPIS,MMC Transmit 256 to 511 Octet Good Bad Packet Counter Interrupt Status This bit is set when the Tx_512To1023Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit 256 to 511 Octet Good Bad Packet..,1: MMC Transmit 256 to 511 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 6. "TX128T255OCTGBPIS,MMC Transmit 128 to 255 Octet Good Bad Packet Counter Interrupt Status This bit is set when the Tx_128To255Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit 128 to 255 Octet Good Bad Packet..,1: MMC Transmit 128 to 255 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 5. "TX65T127OCTGBPIS,MMC Transmit 65 to 127 Octet Good Bad Packet Counter Interrupt Status This bit is set when the Tx_65To127Octets_Packets_Good_Bad counter reaches half the maximum value and also when it reaches the maximum value" "0: MMC Transmit 65 to 127 Octet Good Bad Packet..,1: MMC Transmit 65 to 127 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 4. "TX64OCTGBPIS,MMC Transmit 64 Octet Good Bad Packet Counter Interrupt Status This bit is set when the Tx_64Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit 64 Octet Good Bad Packet Counter..,1: MMC Transmit 64 Octet Good Bad Packet Counter.."
            newline
            bitfld.long 0x00 3. "TXMCGPIS,MMC Transmit Multicast Good Packet Counter Interrupt Status This bit is set when the Tx_Multicast_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Multicast Good Packet Counter..,1: MMC Transmit Multicast Good Packet Counter.."
            newline
            bitfld.long 0x00 2. "TXBCGPIS,MMC Transmit Broadcast Good Packet Counter Interrupt Status This bit is set when the Tx_Broadcast_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Broadcast Good Packet Counter..,1: MMC Transmit Broadcast Good Packet Counter.."
            newline
            bitfld.long 0x00 1. "TXGBPKTIS,MMC Transmit Good Bad Packet Counter Interrupt Status This bit is set when the Tx_Packet_Count_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Good Bad Packet Counter..,1: MMC Transmit Good Bad Packet Counter.."
            newline
            bitfld.long 0x00 0. "TXGBOCTIS,MMC Transmit Good Bad Octet Counter Interrupt Status This bit is set when the Tx_Octet_Count_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Good Bad Octet Counter Interrupt..,1: MMC Transmit Good Bad Octet Counter Interrupt.."

    group.long 0x70C++0x03
        line.long 0x00 "MMC_Rx_Interrupt_Mask,This register maintains the masks for interrupts generated from all Receive statistics counters"
            rbitfld.long 0x00 28.--31. "Reserved_31_28,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 27. "Reserved_RXLPITRCIM,Reserved" "0,1"
            newline
            rbitfld.long 0x00 26. "Reserved_RXLPIUSCIM,Reserved" "0,1"
            newline
            bitfld.long 0x00 25. "RXCTRLPIM,MMC Receive Control Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Control_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Control Packet Counter Interrupt..,1: MMC Receive Control Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 24. "RXRCVERRPIM,MMC Receive Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Receive_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Error Packet Counter Interrupt..,1: MMC Receive Error Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 23. "RXWDOGPIM,MMC Receive Watchdog Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Watchdog_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Watchdog Error Packet Counter..,1: MMC Receive Watchdog Error Packet Counter.."
            newline
            bitfld.long 0x00 22. "RXVLANGBPIM,MMC Receive VLAN Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_VLAN_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive VLAN Good Bad Packet Counter..,1: MMC Receive VLAN Good Bad Packet Counter.."
            newline
            bitfld.long 0x00 21. "RXFOVPIM,MMC Receive FIFO Overflow Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_FIFO_Overflow_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive FIFO Overflow Packet Counter..,1: MMC Receive FIFO Overflow Packet Counter.."
            newline
            bitfld.long 0x00 20. "RXPAUSPIM,MMC Receive Pause Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Pause_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Pause Packet Counter Interrupt..,1: MMC Receive Pause Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 19. "RXORANGEPIM,MMC Receive Out Of Range Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Out_Of_Range_Type_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Out Of Range Error Packet Counter..,1: MMC Receive Out Of Range Error Packet Counter.."
            newline
            bitfld.long 0x00 18. "RXLENERPIM,MMC Receive Length Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Length_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Length Error Packet Counter..,1: MMC Receive Length Error Packet Counter.."
            newline
            bitfld.long 0x00 17. "RXUCGPIM,MMC Receive Unicast Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Unicast_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Unicast Good Packet Counter..,1: MMC Receive Unicast Good Packet Counter.."
            newline
            bitfld.long 0x00 16. "RX1024TMAXOCTGBPIM,MMC Receive 1024 to Maximum Octet Good Bad Packet Counter Interrupt Mask" "0: MMC Receive 1024 to Maximum Octet Good Bad..,1: MMC Receive 1024 to Maximum Octet Good Bad.."
            newline
            bitfld.long 0x00 15. "RX512T1023OCTGBPIM,MMC Receive 512 to 1023 Octet Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_512To1023Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive 512 to 1023 Octet Good Bad Packet..,1: MMC Receive 512 to 1023 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 14. "RX256T511OCTGBPIM,MMC Receive 256 to 511 Octet Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_256To511Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive 256 to 511 Octet Good Bad Packet..,1: MMC Receive 256 to 511 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 13. "RX128T255OCTGBPIM,MMC Receive 128 to 255 Octet Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_128To255Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive 128 to 255 Octet Good Bad Packet..,1: MMC Receive 128 to 255 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 12. "RX65T127OCTGBPIM,MMC Receive 65 to 127 Octet Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_65To127Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive 65 to 127 Octet Good Bad Packet..,1: MMC Receive 65 to 127 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 11. "RX64OCTGBPIM,MMC Receive 64 Octet Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_64Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive 64 Octet Good Bad Packet Counter..,1: MMC Receive 64 Octet Good Bad Packet Counter.."
            newline
            bitfld.long 0x00 10. "RXOSIZEGPIM,MMC Receive Oversize Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Oversize_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Oversize Good Packet Counter..,1: MMC Receive Oversize Good Packet Counter.."
            newline
            bitfld.long 0x00 9. "RXUSIZEGPIM,MMC Receive Undersize Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Undersize_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Undersize Good Packet Counter..,1: MMC Receive Undersize Good Packet Counter.."
            newline
            bitfld.long 0x00 8. "RXJABERPIM,MMC Receive Jabber Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Jabber_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Jabber Error Packet Counter..,1: MMC Receive Jabber Error Packet Counter.."
            newline
            bitfld.long 0x00 7. "RXRUNTPIM,MMC Receive Runt Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Runt_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Runt Packet Counter Interrupt..,1: MMC Receive Runt Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 6. "RXALGNERPIM,MMC Receive Alignment Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Alignment_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive Alignment Error Packet Counter..,1: MMC Receive Alignment Error Packet Counter.."
            newline
            bitfld.long 0x00 5. "RXCRCERPIM,MMC Receive CRC Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_CRC_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive CRC Error Packet Counter..,1: MMC Receive CRC Error Packet Counter.."
            newline
            bitfld.long 0x00 4. "RXMCGPIM,MMC Receive Multicast Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Multicast_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Multicast Good Packet Counter..,1: MMC Receive Multicast Good Packet Counter.."
            newline
            bitfld.long 0x00 3. "RXBCGPIM,MMC Receive Broadcast Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Broadcast_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Broadcast Good Packet Counter..,1: MMC Receive Broadcast Good Packet Counter.."
            newline
            bitfld.long 0x00 2. "RXGOCTIM,MMC Receive Good Octet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Octet_Count_Good counter reaches half of the maximum value or the maximum value" "0: MMC Receive Good Octet Counter Interrupt Mask..,1: MMC Receive Good Octet Counter Interrupt Mask.."
            newline
            bitfld.long 0x00 1. "RXGBOCTIM,MMC Receive Good Bad Octet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Octet_Count_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive Good Bad Octet Counter Interrupt..,1: MMC Receive Good Bad Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 0. "RXGBPKTIM,MMC Receive Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Rx_Packets_Count_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Receive Good Bad Packet Counter Interrupt..,1: MMC Receive Good Bad Packet Counter Interrupt.."
    group.long 0x710++0x03
        line.long 0x00 "MMC_Tx_Interrupt_Mask,This register maintains the masks for interrupts generated from all Transmit statistics counters"
            rbitfld.long 0x00 28.--31. "Reserved_31_28,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 27. "Reserved_TXLPITRCIM,Reserved" "0,1"
            newline
            rbitfld.long 0x00 26. "Reserved_TXLPIUSCIM,Reserved" "0,1"
            newline
            bitfld.long 0x00 25. "TXOSIZEGPIM,MMC Transmit Oversize Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_OSize_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Oversize Good Packet Counter..,1: MMC Transmit Oversize Good Packet Counter.."
            newline
            bitfld.long 0x00 24. "TXVLANGPIM,MMC Transmit VLAN Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_VLAN_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Transmit VLAN Good Packet Counter..,1: MMC Transmit VLAN Good Packet Counter.."
            newline
            bitfld.long 0x00 23. "TXPAUSPIM,MMC Transmit Pause Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Pause_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Pause Packet Counter Interrupt..,1: MMC Transmit Pause Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 22. "TXEXDEFPIM,MMC Transmit Excessive Deferral Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Excessive_Deferral_Error counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Excessive Deferral Packet..,1: MMC Transmit Excessive Deferral Packet.."
            newline
            bitfld.long 0x00 21. "TXGPKTIM,MMC Transmit Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Packet_Count_Good counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Good Packet Counter Interrupt..,1: MMC Transmit Good Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 20. "TXGOCTIM,MMC Transmit Good Octet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Octet_Count_Good counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Good Octet Counter Interrupt..,1: MMC Transmit Good Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 19. "TXCARERPIM,MMC Transmit Carrier Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Carrier_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Carrier Error Packet Counter..,1: MMC Transmit Carrier Error Packet Counter.."
            newline
            bitfld.long 0x00 18. "TXEXCOLPIM,MMC Transmit Excessive Collision Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Excessive_Collision_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Excessive Collision Packet..,1: MMC Transmit Excessive Collision Packet.."
            newline
            bitfld.long 0x00 17. "TXLATCOLPIM,MMC Transmit Late Collision Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Late_Collision_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Late Collision Packet Counter..,1: MMC Transmit Late Collision Packet Counter.."
            newline
            bitfld.long 0x00 16. "TXDEFPIM,MMC Transmit Deferred Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Deferred_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Deferred Packet Counter..,1: MMC Transmit Deferred Packet Counter.."
            newline
            bitfld.long 0x00 15. "TXMCOLGPIM,MMC Transmit Multiple Collision Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Multiple_Collision_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Multiple Collision Good Packet..,1: MMC Transmit Multiple Collision Good Packet.."
            newline
            bitfld.long 0x00 14. "TXSCOLGPIM,MMC Transmit Single Collision Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Single_Collision_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Single Collision Good Packet..,1: MMC Transmit Single Collision Good Packet.."
            newline
            bitfld.long 0x00 13. "TXUFLOWERPIM,MMC Transmit Underflow Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Underflow_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Underflow Error Packet Counter..,1: MMC Transmit Underflow Error Packet Counter.."
            newline
            bitfld.long 0x00 12. "TXBCGBPIM,MMC Transmit Broadcast Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Broadcast_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Broadcast Good Bad Packet..,1: MMC Transmit Broadcast Good Bad Packet.."
            newline
            bitfld.long 0x00 11. "TXMCGBPIM,MMC Transmit Multicast Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Multicast_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Multicast Good Bad Packet..,1: MMC Transmit Multicast Good Bad Packet.."
            newline
            bitfld.long 0x00 10. "TXUCGBPIM,MMC Transmit Unicast Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Unicast_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Unicast Good Bad Packet Counter..,1: MMC Transmit Unicast Good Bad Packet Counter.."
            newline
            bitfld.long 0x00 9. "TX1024TMAXOCTGBPIM,MMC Transmit 1024 to Maximum Octet Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_1024ToMaxOctets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit 1024 to Maximum Octet Good Bad..,1: MMC Transmit 1024 to Maximum Octet Good Bad.."
            newline
            bitfld.long 0x00 8. "TX512T1023OCTGBPIM,MMC Transmit 512 to 1023 Octet Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_512To1023Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit 512 to 1023 Octet Good Bad..,1: MMC Transmit 512 to 1023 Octet Good Bad.."
            newline
            bitfld.long 0x00 7. "TX256T511OCTGBPIM,MMC Transmit 256 to 511 Octet Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_512To1023Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit 256 to 511 Octet Good Bad Packet..,1: MMC Transmit 256 to 511 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 6. "TX128T255OCTGBPIM,MMC Transmit 128 to 255 Octet Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_128To255Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit 128 to 255 Octet Good Bad Packet..,1: MMC Transmit 128 to 255 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 5. "TX65T127OCTGBPIM,MMC Transmit 65 to 127 Octet Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_65To127Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit 65 to 127 Octet Good Bad Packet..,1: MMC Transmit 65 to 127 Octet Good Bad Packet.."
            newline
            bitfld.long 0x00 4. "TX64OCTGBPIM,MMC Transmit 64 Octet Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_64Octets_Packets_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit 64 Octet Good Bad Packet Counter..,1: MMC Transmit 64 Octet Good Bad Packet Counter.."
            newline
            bitfld.long 0x00 3. "TXMCGPIM,MMC Transmit Multicast Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Multicast_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Multicast Good Packet Counter..,1: MMC Transmit Multicast Good Packet Counter.."
            newline
            bitfld.long 0x00 2. "TXBCGPIM,MMC Transmit Broadcast Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Broadcast_Packets_Good counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Broadcast Good Packet Counter..,1: MMC Transmit Broadcast Good Packet Counter.."
            newline
            bitfld.long 0x00 1. "TXGBPKTIM,MMC Transmit Good Bad Packet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Packet_Count_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Good Bad Packet Counter..,1: MMC Transmit Good Bad Packet Counter.."
            newline
            bitfld.long 0x00 0. "TXGBOCTIM,MMC Transmit Good Bad Octet Counter Interrupt Mask Setting this bit masks the interrupt when the Tx_Octet_Count_Good_Bad counter reaches half of the maximum value or the maximum value" "0: MMC Transmit Good Bad Octet Counter Interrupt..,1: MMC Transmit Good Bad Octet Counter Interrupt.."

    rgroup.long 0x714++0x03
        line.long 0x00 "Tx_Octet_Count_Good_Bad,This register provides the number of bytes transmitted by the DWC_ether_qos exclusive of preamble and retried bytes in good and bad packets"
            hexmask.long 0x00 0.--31. 1. "TXOCTGB,Tx Octet Count Good Bad This field indicates the number of bytes transmitted exclusive of preamble and retried bytes in good and bad packets"
    rgroup.long 0x718++0x03
        line.long 0x00 "Tx_Packet_Count_Good_Bad,This register provides the number of good and bad packets transmitted by DWC_ether_qos exclusive of retried packets"
            hexmask.long 0x00 0.--31. 1. "TXPKTGB,Tx Packet Count Good Bad This field indicates the number of good and bad packets transmitted exclusive of retried packets"
    rgroup.long 0x71C++0x03
        line.long 0x00 "Tx_Broadcast_Packets_Good,This register provides the number of good broadcast packets transmitted by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "TXBCASTG,Tx Broadcast Packets Good This field indicates the number of good broadcast packets transmitted"
    rgroup.long 0x720++0x03
        line.long 0x00 "Tx_Multicast_Packets_Good,This register provides the number of good multicast packets transmitted by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "TXMCASTG,Tx Multicast Packets Good This field indicates the number of good multicast packets transmitted"
    rgroup.long 0x724++0x03
        line.long 0x00 "Tx_64Octets_Packets_Good_Bad,This register provides the number of good and bad packets transmitted by DWC_ether_qos with length 64 bytes exclusive of preamble and retried packets"
            hexmask.long 0x00 0.--31. 1. "TX64OCTGB,Tx 64Octets Packets Good_Bad This field indicates the number of good and bad packets transmitted with length 64 bytes exclusive of preamble and retried packets"
    rgroup.long 0x728++0x03
        line.long 0x00 "Tx_65To127Octets_Packets_Good_Bad,This register provides the number of good and bad packets transmitted by DWC_ether_qos with length between 65 and 127 (inclusive) bytes exclusive of preamble and retried packets"
            hexmask.long 0x00 0.--31. 1. "TX65_127OCTGB,Tx 65To127Octets Packets Good Bad This field indicates the number of good and bad packets transmitted with length between 65 and 127 (inclusive) bytes exclusive of preamble and retried packets"
    rgroup.long 0x72C++0x03
        line.long 0x00 "Tx_128To255Octets_Packets_Good_Bad,This register provides the number of good and bad packets transmitted by DWC_ether_qos with length between 128 to 255 (inclusive) bytes exclusive of preamble and retried packets"
            hexmask.long 0x00 0.--31. 1. "TX128_255OCTGB,Tx 128To255Octets Packets Good Bad This field indicates the number of good and bad packets transmitted with length between 128 and 255 (inclusive) bytes exclusive of preamble and retried packets"
    rgroup.long 0x730++0x03
        line.long 0x00 "Tx_256To511Octets_Packets_Good_Bad,This register provides the number of good and bad packets transmitted by DWC_ether_qos with length between 256 to 511 (inclusive) bytes exclusive of preamble and retried packets"
            hexmask.long 0x00 0.--31. 1. "TX256_511OCTGB,Tx 256To511Octets Packets Good Bad This field indicates the number of good and bad packets transmitted with length between 256 and 511 (inclusive) bytes exclusive of preamble and retried packets"
    rgroup.long 0x734++0x03
        line.long 0x00 "Tx_512To1023Octets_Packets_Good_Bad,This register provides the number of good and bad packets transmitted by DWC_ether_qos with length 512 to 1023 (inclusive) bytes exclusive of preamble and retried packets"
            hexmask.long 0x00 0.--31. 1. "TX512_1023OCTGB,Tx 512To1023Octets Packets Good Bad This field indicates the number of good and bad packets transmitted with length between 512 and 1023 (inclusive) bytes exclusive of preamble and retried packets"
    rgroup.long 0x738++0x03
        line.long 0x00 "Tx_1024ToMaxOctets_Packets_Good_Bad,This register provides the number of good and bad packets transmitted by DWC_ether_qos with length 1024 to maxsize (inclusive) bytes exclusive of preamble and retried packets"
            hexmask.long 0x00 0.--31. 1. "TX1024_MAXOCTGB,Tx 1024ToMaxOctets Packets Good Bad This field indicates the number of good and bad packets transmitted with length between 1024 and maxsize (inclusive) bytes exclusive of preamble and retried packets"
    rgroup.long 0x73C++0x03
        line.long 0x00 "Tx_Unicast_Packets_Good_Bad,This register provides the number of good and bad unicast packets transmitted by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "TXUCASTGB,Tx Unicast Packets Good Bad This field indicates the number of good and bad unicast packets transmitted"
    rgroup.long 0x740++0x03
        line.long 0x00 "Tx_Multicast_Packets_Good_Bad,This register provides the number of good and bad multicast packets transmitted by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "TXMCASTGB,Tx Multicast Packets Good Bad This field indicates the number of good and bad multicast packets transmitted"
    rgroup.long 0x744++0x03
        line.long 0x00 "Tx_Broadcast_Packets_Good_Bad,This register provides the number of good and bad broadcast packets transmitted by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "TXBCASTGB,Tx Broadcast Packets Good Bad This field indicates the number of good and bad broadcast packets transmitted"
    rgroup.long 0x748++0x03
        line.long 0x00 "Tx_Underflow_Error_Packets,This register provides the number of packets aborted by DWC_ether_qos because of packets underflow error"
            hexmask.long 0x00 0.--31. 1. "TXUNDRFLW,Tx Underflow Error Packets This field indicates the number of packets aborted because of packets underflow error"
    rgroup.long 0x74C++0x03
        line.long 0x00 "Tx_Single_Collision_Good_Packets,This register provides the number of successfully transmitted packets by DWC_ether_qos after a single collision in the half-duplex mode"
            hexmask.long 0x00 0.--31. 1. "TXSNGLCOLG,Tx Single Collision Good Packets This field indicates the number of successfully transmitted packets after a single collision in the half-duplex mode"
    rgroup.long 0x750++0x03
        line.long 0x00 "Tx_Multiple_Collision_Good_Packets,This register provides the number of successfully transmitted packets by DWC_ether_qos after multiple collisions in the half-duplex mode"
            hexmask.long 0x00 0.--31. 1. "TXMULTCOLG,Tx Multiple Collision Good Packets This field indicates the number of successfully transmitted packets after multiple collisions in the half-duplex mode"
    rgroup.long 0x754++0x03
        line.long 0x00 "Tx_Deferred_Packets,This register provides the number of successfully transmitted by DWC_ether_qos after a deferral in the half-duplex mode"
            hexmask.long 0x00 0.--31. 1. "TXDEFRD,Tx Deferred Packets This field indicates the number of successfully transmitted after a deferral in the half-duplex mode"
    rgroup.long 0x758++0x03
        line.long 0x00 "Tx_Late_Collision_Packets,This register provides the number of packets aborted by DWC_ether_qos because of late collision error"
            hexmask.long 0x00 0.--31. 1. "TXLATECOL,Tx Late Collision Packets This field indicates the number of packets aborted because of late collision error"
    rgroup.long 0x75C++0x03
        line.long 0x00 "Tx_Excessive_Collision_Packets,This register provides the number of packets aborted by DWC_ether_qos because of excessive (16) collision errors"
            hexmask.long 0x00 0.--31. 1. "TXEXSCOL,Tx Excessive Collision Packets This field indicates the number of packets aborted because of excessive (16) collision errors"
    rgroup.long 0x760++0x03
        line.long 0x00 "Tx_Carrier_Error_Packets,This register provides the number of packets aborted by DWC_ether_qos because of carrier sense error (no carrier or loss of carrier)"
            hexmask.long 0x00 0.--31. 1. "TXCARR,Tx Carrier Error Packets This field indicates the number of packets aborted because of carrier sense error (no carrier or loss of carrier)"
    rgroup.long 0x764++0x03
        line.long 0x00 "Tx_Octet_Count_Good,This register provides the number of bytes transmitted by DWC_ether_qos exclusive of preamble only in good packets"
            hexmask.long 0x00 0.--31. 1. "TXOCTG,Tx Octet Count Good This field indicates the number of bytes transmitted exclusive of preamble only in good packets"
    rgroup.long 0x768++0x03
        line.long 0x00 "Tx_Packet_Count_Good,This register provides the number of good packets transmitted by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "TXPKTG,Tx Packet Count Good This field indicates the number of good packets transmitted"
    rgroup.long 0x76C++0x03
        line.long 0x00 "Tx_Excessive_Deferral_Error,This register provides the number of packets aborted by DWC_ether_qos because of excessive deferral error (deferred for more than two max-sized packet times)"
            hexmask.long 0x00 0.--31. 1. "TXEXSDEF,Tx Excessive Deferral Error This field indicates the number of packets aborted because of excessive deferral error (deferred for more than two max-sized packet times)"
    rgroup.long 0x770++0x03
        line.long 0x00 "Tx_Pause_Packets,This register provides the number of good Pause packets transmitted by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "TXPAUSE,Tx Pause Packets This field indicates the number of good Pause packets transmitted"
    rgroup.long 0x774++0x03
        line.long 0x00 "Tx_VLAN_Packets_Good,This register provides the number of good VLAN packets transmitted by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "TXVLANG,Tx VLAN Packets Good This field provides the number of good VLAN packets transmitted"
    rgroup.long 0x778++0x03
        line.long 0x00 "Tx_OSize_Packets_Good,This register provides the number of packets transmitted by DWC_ether_qos without errors and with length greater than the maxsize (1 518 or 1 522 bytes for VLAN tagged packets 2000 bytes if enabled in S2KP bit of the.."
            hexmask.long 0x00 0.--31. 1. "TXOSIZG,Tx OSize Packets Good This field indicates the number of packets transmitted without errors and with length greater than the maxsize (1 518 or 1 522 bytes for VLAN tagged packets 2000 bytes if enabled in S2KP bit of the MAC_Configuration register)"
    rgroup.long 0x780++0x03
        line.long 0x00 "Rx_Packets_Count_Good_Bad,This register provides the number of good and bad packets received by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "RXPKTGB,Rx Packets Count Good Bad This field indicates the number of good and bad packets received"
    rgroup.long 0x784++0x03
        line.long 0x00 "Rx_Octet_Count_Good_Bad,This register provides the number of bytes received by DWC_ther_qos exclusive of preamble in good and bad packets"
            hexmask.long 0x00 0.--31. 1. "RXOCTGB,Rx Octet Count Good Bad This field indicates the number of bytes received exclusive of preamble in good and bad packets"
    rgroup.long 0x788++0x03
        line.long 0x00 "Rx_Octet_Count_Good,This register provides the number of bytes received by DWC_ether_qos exclusive of preamble only in good packets"
            hexmask.long 0x00 0.--31. 1. "RXOCTG,Rx Octet Count Good This field indicates the number of bytes received exclusive of preamble only in good packets"
    rgroup.long 0x78C++0x03
        line.long 0x00 "Rx_Broadcast_Packets_Good,This register provides the number of good broadcast packets received by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "RXBCASTG,Rx Broadcast Packets Good This field indicates the number of good broadcast packets received"
    rgroup.long 0x790++0x03
        line.long 0x00 "Rx_Multicast_Packets_Good,This register provides the number of good multicast packets received by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "RXMCASTG,Rx Multicast Packets Good This field indicates the number of good multicast packets received"
    rgroup.long 0x794++0x03
        line.long 0x00 "Rx_CRC_Error_Packets,This register provides the number of packets received by DWC_ether_qos with CRC error"
            hexmask.long 0x00 0.--31. 1. "RXCRCERR,Rx CRC Error Packets This field indicates the number of packets received with CRC error"
    rgroup.long 0x798++0x03
        line.long 0x00 "Rx_Alignment_Error_Packets,This register provides the number of packets received by DWC_ether_qos with alignment (dribble) error"
            hexmask.long 0x00 0.--31. 1. "RXALGNERR,Rx Alignment Error Packets This field indicates the number of packets received with alignment (dribble) error"
    rgroup.long 0x79C++0x03
        line.long 0x00 "Rx_Runt_Error_Packets,This register provides the number of packets received by DWC_ether_qos with runt (length less than 64 bytes and CRC error) error"
            hexmask.long 0x00 0.--31. 1. "RXRUNTERR,Rx Runt Error Packets This field indicates the number of packets received with runt (length less than 64 bytes and CRC error) error"
    rgroup.long 0x7A0++0x03
        line.long 0x00 "Rx_Jabber_Error_Packets,This register provides the number of giant packets received by DWC_ether_qos with length (including CRC) greater than 1 518 bytes (1 522 bytes for VLAN tagged) and with CRC error"
            hexmask.long 0x00 0.--31. 1. "RXJABERR,Rx Jabber Error Packets This field indicates the number of giant packets received with length (including CRC) greater than 1 518 bytes (1 522 bytes for VLAN tagged) and with CRC error"
    rgroup.long 0x7A4++0x03
        line.long 0x00 "Rx_Undersize_Packets_Good,This register provides the number of packets received by DWC_ether_qos with length less than 64 bytes without any errors"
            hexmask.long 0x00 0.--31. 1. "RXUNDERSZG,Rx Undersize Packets Good This field indicates the number of packets received with length less than 64 bytes without any errors"
    rgroup.long 0x7A8++0x03
        line.long 0x00 "Rx_Oversize_Packets_Good,This register provides the number of packets received by DWC_ether_qos without errors with length greater than the maxsize (1 518 bytes or 1 522 bytes for VLAN tagged packets 2000 bytes if enabled in the S2KP bit of the.."
            hexmask.long 0x00 0.--31. 1. "RXOVERSZG,Rx Oversize Packets Good This field indicates the number of packets received without errors with length greater than the maxsize (1 518 bytes or 1 522 bytes for VLAN tagged packets 2000 bytes if enabled in the S2KP bit of the MAC_Configuration.."
    rgroup.long 0x7AC++0x03
        line.long 0x00 "Rx_64Octets_Packets_Good_Bad,This register provides the number of good and bad packets received by DWC_ether_qos with length 64 bytes exclusive of the preamble"
            hexmask.long 0x00 0.--31. 1. "RX64OCTGB,Rx 64 Octets Packets Good Bad This field indicates the number of good and bad packets received with length 64 bytes exclusive of the preamble"
    rgroup.long 0x7B0++0x03
        line.long 0x00 "Rx_65To127Octets_Packets_Good_Bad,This register provides the number of good and bad packets received by DWC_ether_qos with length between 65 and 127 (inclusive) bytes exclusive of the preamble"
            hexmask.long 0x00 0.--31. 1. "RX65_127OCTGB,Rx 65-127 Octets Packets Good Bad This field indicates the number of good and bad packets received with length between 65 and 127 (inclusive) bytes exclusive of the preamble"
    rgroup.long 0x7B4++0x03
        line.long 0x00 "Rx_128To255Octets_Packets_Good_Bad,This register provides the number of good and bad packets received by DWC_ether_qos with length between 128 and 255 (inclusive) bytes exclusive of the preamble"
            hexmask.long 0x00 0.--31. 1. "RX128_255OCTGB,Rx 128-255 Octets Packets Good Bad This field indicates the number of good and bad packets received with length between 128 and 255 (inclusive) bytes exclusive of the preamble"
    rgroup.long 0x7B8++0x03
        line.long 0x00 "Rx_256To511Octets_Packets_Good_Bad,This register provides the number of good and bad packets received by DWC_ether_qos with length between 256 and 511 (inclusive) bytes exclusive of the preamble"
            hexmask.long 0x00 0.--31. 1. "RX256_511OCTGB,Rx 256-511 Octets Packets Good Bad This field indicates the number of good and bad packets received with length between 256 and 511 (inclusive) bytes exclusive of the preamble"
    rgroup.long 0x7BC++0x03
        line.long 0x00 "Rx_512To1023Octets_Packets_Good_Bad,This register provides the number of good and bad packets received by DWC_ether_qos with length between 512 and 1023 (inclusive) bytes exclusive of the preamble"
            hexmask.long 0x00 0.--31. 1. "RX512_1023OCTGB,RX 512-1023 Octets Packets Good Bad This field indicates the number of good and bad packets received with length between 512 and 1023 (inclusive) bytes exclusive of the preamble"
    rgroup.long 0x7C0++0x03
        line.long 0x00 "Rx_1024ToMaxOctets_Packets_Good_Bad,This register provides the number of good and bad packets received by DWC_ether_qos with length between 1024 and maxsize (inclusive) bytes exclusive of the preamble"
            hexmask.long 0x00 0.--31. 1. "RX1024_MAXOCTGB,Rx 1024-Max Octets Good Bad This field indicates the number of good and bad packets received with length between 1024 and maxsize (inclusive) bytes exclusive of the preamble"
    rgroup.long 0x7C4++0x03
        line.long 0x00 "Rx_Unicast_Packets_Good,This register provides the number of good unicast packets received by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "RXUCASTG,Rx Unicast Packets Good This field indicates the number of good unicast packets received"
    rgroup.long 0x7C8++0x03
        line.long 0x00 "Rx_Length_Error_Packets,This register provides the number of packets received by DWC_ether_qos with length error (Length Type field not equal to packet size) for all packets with valid length field"
            hexmask.long 0x00 0.--31. 1. "RXLENERR,Rx Length Error Packets This field indicates the number of packets received with length error (Length Type field not equal to packet size) for all packets with valid length field"
    rgroup.long 0x7CC++0x03
        line.long 0x00 "Rx_Out_Of_Range_Type_Packets,This register provides the number of packets received by DWC_ether_qos with length field not equal to the valid packet size (greater than 1 500 but less than 1 536)"
            hexmask.long 0x00 0.--31. 1. "RXOUTOFRNG,Rx Out of Range Type Packet This field indicates the number of packets received with length field not equal to the valid packet size (greater than 1 500 but less than 1 536)"
    rgroup.long 0x7D0++0x03
        line.long 0x00 "Rx_Pause_Packets,This register provides the number of good and valid Pause packets received by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "RXPAUSEPKT,Rx Pause Packets This field indicates the number of good and valid Pause packets received"
    rgroup.long 0x7D4++0x03
        line.long 0x00 "Rx_FIFO_Overflow_Packets,This register provides the number of missed received packets because of FIFO overflow in DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "RXFIFOOVFL,Rx FIFO Overflow Packets This field indicates the number of missed received packets because of FIFO overflow"
    rgroup.long 0x7D8++0x03
        line.long 0x00 "Rx_VLAN_Packets_Good_Bad,This register provides the number of good and bad VLAN packets received by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "RXVLANPKTGB,Rx VLAN Packets Good Bad This field indicates the number of good and bad VLAN packets received"
    rgroup.long 0x7DC++0x03
        line.long 0x00 "Rx_Watchdog_Error_Packets,This register provides the number of packets received by DWC_ether_qos with error because of watchdog timeout error (packets with a data load larger than 2 048 bytes (when JE and WD bits are reset in MAC_Configuration register).."
            hexmask.long 0x00 0.--31. 1. "RXWDGERR,Rx Watchdog Error Packets This field indicates the number of packets received with error because of watchdog timeout error (packets with a data load larger than 2 048 bytes (when JE and WD bits are reset in MAC_Configuration register) 10 240.."
    rgroup.long 0x7E0++0x03
        line.long 0x00 "Rx_Receive_Error_Packets,This register provides the number of packets received by DWC_ether_qos with Receive error or Packet Extension error on the GMII or MII interface"
            hexmask.long 0x00 0.--31. 1. "RXRCVERR,Rx Receive Error Packets This field indicates the number of packets received with Receive error or Packet Extension error on the GMII or MII interface"
    rgroup.long 0x7E4++0x03
        line.long 0x00 "Rx_Control_Packets_Good,This register provides the number of good control packets received by DWC_ether_qos"
            hexmask.long 0x00 0.--31. 1. "RXCTRLG,Rx Control Packets Good This field indicates the number of good control packets received"

    group.long 0x800++0x03
        line.long 0x00 "MMC_IPC_Rx_Interrupt_Mask,This register maintains the mask for the interrupt generated from the receive IPC statistic counters"
            rbitfld.long 0x00 30.--31. "Reserved_31_30,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 29. "RXICMPEROIM,MMC Receive ICMP Error Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxICMP_Error_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive ICMP Error Octet Counter..,1: MMC Receive ICMP Error Octet Counter.."
            newline
            bitfld.long 0x00 28. "RXICMPGOIM,MMC Receive ICMP Good Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxICMP_Good_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive ICMP Good Octet Counter Interrupt..,1: MMC Receive ICMP Good Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 27. "RXTCPEROIM,MMC Receive TCP Error Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxTCP_Error_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive TCP Error Octet Counter Interrupt..,1: MMC Receive TCP Error Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 26. "RXTCPGOIM,MMC Receive TCP Good Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxTCP_Good_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive TCP Good Octet Counter Interrupt..,1: MMC Receive TCP Good Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 25. "RXUDPEROIM,MMC Receive UDP Good Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxUDP_Error_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive UDP Good Octet Counter Interrupt..,1: MMC Receive UDP Good Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 24. "RXUDPGOIM,MMC Receive IPV6 No Payload Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxUDP_Good_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV6 No Payload Octet Counter..,1: MMC Receive IPV6 No Payload Octet Counter.."
            newline
            bitfld.long 0x00 23. "RXIPV6NOPAYOIM,MMC Receive IPV6 Header Error Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv6_No_Payload_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV6 Header Error Octet Counter..,1: MMC Receive IPV6 Header Error Octet Counter.."
            newline
            bitfld.long 0x00 22. "RXIPV6HEROIM,MMC Receive IPV6 Good Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv6_Header_Error_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV6 Good Octet Counter Interrupt..,1: MMC Receive IPV6 Good Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 21. "RXIPV6GOIM,MMC Receive IPV6 Good Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv6_Good_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV6 Good Octet Counter Interrupt..,1: MMC Receive IPV6 Good Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 20. "RXIPV4UDSBLOIM,MMC Receive IPV4 UDP Checksum Disabled Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv4_UDP_Checksum_Disable_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 UDP Checksum Disabled Octet..,1: MMC Receive IPV4 UDP Checksum Disabled Octet.."
            newline
            bitfld.long 0x00 19. "RXIPV4FRAGOIM,MMC Receive IPV4 Fragmented Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv4_Fragmented_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 Fragmented Octet Counter..,1: MMC Receive IPV4 Fragmented Octet Counter.."
            newline
            bitfld.long 0x00 18. "RXIPV4NOPAYOIM,MMC Receive IPV4 No Payload Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv4_No_Payload_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 No Payload Octet Counter..,1: MMC Receive IPV4 No Payload Octet Counter.."
            newline
            bitfld.long 0x00 17. "RXIPV4HEROIM,MMC Receive IPV4 Header Error Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv4_Header_Error_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 Header Error Octet Counter..,1: MMC Receive IPV4 Header Error Octet Counter.."
            newline
            bitfld.long 0x00 16. "RXIPV4GOIM,MMC Receive IPV4 Good Octet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv4_Good_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 Good Octet Counter Interrupt..,1: MMC Receive IPV4 Good Octet Counter Interrupt.."
            newline
            rbitfld.long 0x00 14.--15. "Reserved_15_14,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 13. "RXICMPERPIM,MMC Receive ICMP Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxICMP_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive ICMP Error Packet Counter..,1: MMC Receive ICMP Error Packet Counter.."
            newline
            bitfld.long 0x00 12. "RXICMPGPIM,MMC Receive ICMP Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxICMP_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive ICMP Good Packet Counter..,1: MMC Receive ICMP Good Packet Counter.."
            newline
            bitfld.long 0x00 11. "RXTCPERPIM,MMC Receive TCP Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxTCP_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive TCP Error Packet Counter..,1: MMC Receive TCP Error Packet Counter.."
            newline
            bitfld.long 0x00 10. "RXTCPGPIM,MMC Receive TCP Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxTCP_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive TCP Good Packet Counter Interrupt..,1: MMC Receive TCP Good Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 9. "RXUDPERPIM,MMC Receive UDP Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxUDP_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive UDP Error Packet Counter..,1: MMC Receive UDP Error Packet Counter.."
            newline
            bitfld.long 0x00 8. "RXUDPGPIM,MMC Receive UDP Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxUDP_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive UDP Good Packet Counter Interrupt..,1: MMC Receive UDP Good Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 7. "RXIPV6NOPAYPIM,MMC Receive IPV6 No Payload Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv6_No_Payload_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV6 No Payload Packet Counter..,1: MMC Receive IPV6 No Payload Packet Counter.."
            newline
            bitfld.long 0x00 6. "RXIPV6HERPIM,MMC Receive IPV6 Header Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv6_Header_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV6 Header Error Packet Counter..,1: MMC Receive IPV6 Header Error Packet Counter.."
            newline
            bitfld.long 0x00 5. "RXIPV6GPIM,MMC Receive IPV6 Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv6_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV6 Good Packet Counter..,1: MMC Receive IPV6 Good Packet Counter.."
            newline
            bitfld.long 0x00 4. "RXIPV4UDSBLPIM,MMC Receive IPV4 UDP Checksum Disabled Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv4_UDP_Checksum_Disabled_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 UDP Checksum Disabled Packet..,1: MMC Receive IPV4 UDP Checksum Disabled Packet.."
            newline
            bitfld.long 0x00 3. "RXIPV4FRAGPIM,MMC Receive IPV4 Fragmented Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv4_Fragmented_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 Fragmented Packet Counter..,1: MMC Receive IPV4 Fragmented Packet Counter.."
            newline
            bitfld.long 0x00 2. "RXIPV4NOPAYPIM,MMC Receive IPV4 No Payload Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv4_No_Payload_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 No Payload Packet Counter..,1: MMC Receive IPV4 No Payload Packet Counter.."
            newline
            bitfld.long 0x00 1. "RXIPV4HERPIM,MMC Receive IPV4 Header Error Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv4_Header_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 Header Error Packet Counter..,1: MMC Receive IPV4 Header Error Packet Counter.."
            newline
            bitfld.long 0x00 0. "RXIPV4GPIM,MMC Receive IPV4 Good Packet Counter Interrupt Mask Setting this bit masks the interrupt when the RxIPv4_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 Good Packet Counter..,1: MMC Receive IPV4 Good Packet Counter.."

    rgroup.long 0x808++0x03
        line.long 0x00 "MMC_IPC_Rx_Interrupt,This register maintains the interrupt that the receive IPC statistic counters generate"
            bitfld.long 0x00 30.--31. "Reserved_31_30,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 29. "RXICMPEROIS,MMC Receive ICMP Error Octet Counter Interrupt Status This bit is set when the RxICMP_Error_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive ICMP Error Octet Counter..,1: MMC Receive ICMP Error Octet Counter.."
            newline
            bitfld.long 0x00 28. "RXICMPGOIS,MMC Receive ICMP Good Octet Counter Interrupt Status This bit is set when the RxICMP_Good_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive ICMP Good Octet Counter Interrupt..,1: MMC Receive ICMP Good Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 27. "RXTCPEROIS,MMC Receive TCP Error Octet Counter Interrupt Status This bit is set when the RxTCP_Error_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive TCP Error Octet Counter Interrupt..,1: MMC Receive TCP Error Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 26. "RXTCPGOIS,MMC Receive TCP Good Octet Counter Interrupt Status This bit is set when the RxTCP_Good_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive TCP Good Octet Counter Interrupt..,1: MMC Receive TCP Good Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 25. "RXUDPEROIS,MMC Receive UDP Error Octet Counter Interrupt Status This bit is set when the RxUDP_Error_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive UDP Error Octet Counter Interrupt..,1: MMC Receive UDP Error Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 24. "RXUDPGOIS,MMC Receive UDP Good Octet Counter Interrupt Status This bit is set when the RxUDP_Good_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive UDP Good Octet Counter Interrupt..,1: MMC Receive UDP Good Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 23. "RXIPV6NOPAYOIS,MMC Receive IPV6 No Payload Octet Counter Interrupt Status This bit is set when the RxIPv6_No_Payload_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV6 No Payload Octet Counter..,1: MMC Receive IPV6 No Payload Octet Counter.."
            newline
            bitfld.long 0x00 22. "RXIPV6HEROIS,MMC Receive IPV6 Header Error Octet Counter Interrupt Status This bit is set when the RxIPv6_Header_Error_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV6 Header Error Octet Counter..,1: MMC Receive IPV6 Header Error Octet Counter.."
            newline
            bitfld.long 0x00 21. "RXIPV6GOIS,MMC Receive IPV6 Good Octet Counter Interrupt Status This bit is set when the RxIPv6_Good_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV6 Good Octet Counter Interrupt..,1: MMC Receive IPV6 Good Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 20. "RXIPV4UDSBLOIS,MMC Receive IPV4 UDP Checksum Disabled Octet Counter Interrupt Status This bit is set when the RxIPv4_UDP_Checksum_Disable_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 UDP Checksum Disabled Octet..,1: MMC Receive IPV4 UDP Checksum Disabled Octet.."
            newline
            bitfld.long 0x00 19. "RXIPV4FRAGOIS,MMC Receive IPV4 Fragmented Octet Counter Interrupt Status This bit is set when the RxIPv4_Fragmented_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 Fragmented Octet Counter..,1: MMC Receive IPV4 Fragmented Octet Counter.."
            newline
            bitfld.long 0x00 18. "RXIPV4NOPAYOIS,MMC Receive IPV4 No Payload Octet Counter Interrupt Status This bit is set when the RxIPv4_No_Payload_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 No Payload Octet Counter..,1: MMC Receive IPV4 No Payload Octet Counter.."
            newline
            bitfld.long 0x00 17. "RXIPV4HEROIS,MMC Receive IPV4 Header Error Octet Counter Interrupt Status This bit is set when the RxIPv4_Header_Error_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 Header Error Octet Counter..,1: MMC Receive IPV4 Header Error Octet Counter.."
            newline
            bitfld.long 0x00 16. "RXIPV4GOIS,MMC Receive IPV4 Good Octet Counter Interrupt Status This bit is set when the RxIPv4_Good_Octets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 Good Octet Counter Interrupt..,1: MMC Receive IPV4 Good Octet Counter Interrupt.."
            newline
            bitfld.long 0x00 14.--15. "Reserved_15_14,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 13. "RXICMPERPIS,MMC Receive ICMP Error Packet Counter Interrupt Status This bit is set when the RxICMP_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive ICMP Error Packet Counter..,1: MMC Receive ICMP Error Packet Counter.."
            newline
            bitfld.long 0x00 12. "RXICMPGPIS,MMC Receive ICMP Good Packet Counter Interrupt Status This bit is set when the RxICMP_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive ICMP Good Packet Counter..,1: MMC Receive ICMP Good Packet Counter.."
            newline
            bitfld.long 0x00 11. "RXTCPERPIS,MMC Receive TCP Error Packet Counter Interrupt Status This bit is set when the RxTCP_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive TCP Error Packet Counter..,1: MMC Receive TCP Error Packet Counter.."
            newline
            bitfld.long 0x00 10. "RXTCPGPIS,MMC Receive TCP Good Packet Counter Interrupt Status This bit is set when the RxTCP_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive TCP Good Packet Counter Interrupt..,1: MMC Receive TCP Good Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 9. "RXUDPERPIS,MMC Receive UDP Error Packet Counter Interrupt Status This bit is set when the RxUDP_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive UDP Error Packet Counter..,1: MMC Receive UDP Error Packet Counter.."
            newline
            bitfld.long 0x00 8. "RXUDPGPIS,MC Receive UDP Good Packet Counter Interrupt Status This bit is set when the RxUDP_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive UDP Good Packet Counter Interrupt..,1: MMC Receive UDP Good Packet Counter Interrupt.."
            newline
            bitfld.long 0x00 7. "RXIPV6NOPAYPIS,MMC Receive IPV6 No Payload Packet Counter Interrupt Status This bit is set when the RxIPv6_No_Payload_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV6 No Payload Packet Counter..,1: MMC Receive IPV6 No Payload Packet Counter.."
            newline
            bitfld.long 0x00 6. "RXIPV6HERPIS,MMC Receive IPV6 Header Error Packet Counter Interrupt Status This bit is set when the RxIPv6_Header_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV6 Header Error Packet Counter..,1: MMC Receive IPV6 Header Error Packet Counter.."
            newline
            bitfld.long 0x00 5. "RXIPV6GPIS,MMC Receive IPV6 Good Packet Counter Interrupt Status This bit is set when the RxIPv6_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV6 Good Packet Counter..,1: MMC Receive IPV6 Good Packet Counter.."
            newline
            bitfld.long 0x00 4. "RXIPV4UDSBLPIS,MMC Receive IPV4 UDP Checksum Disabled Packet Counter Interrupt Status This bit is set when the RxIPv4_UDP_Checksum_Disabled_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 UDP Checksum Disabled Packet..,1: MMC Receive IPV4 UDP Checksum Disabled Packet.."
            newline
            bitfld.long 0x00 3. "RXIPV4FRAGPIS,MMC Receive IPV4 Fragmented Packet Counter Interrupt Status This bit is set when the RxIPv4_Fragmented_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 Fragmented Packet Counter..,1: MMC Receive IPV4 Fragmented Packet Counter.."
            newline
            bitfld.long 0x00 2. "RXIPV4NOPAYPIS,MMC Receive IPV4 No Payload Packet Counter Interrupt Status This bit is set when the RxIPv4_No_Payload_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 No Payload Packet Counter..,1: MMC Receive IPV4 No Payload Packet Counter.."
            newline
            bitfld.long 0x00 1. "RXIPV4HERPIS,MMC Receive IPV4 Header Error Packet Counter Interrupt Status This bit is set when the RxIPv4_Header_Error_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 Header Error Packet Counter..,1: MMC Receive IPV4 Header Error Packet Counter.."
            newline
            bitfld.long 0x00 0. "RXIPV4GPIS,MMC Receive IPV4 Good Packet Counter Interrupt Status This bit is set when the RxIPv4_Good_Packets counter reaches half of the maximum value or the maximum value" "0: MMC Receive IPV4 Good Packet Counter..,1: MMC Receive IPV4 Good Packet Counter.."
    rgroup.long 0x810++0x03
        line.long 0x00 "RxIPv4_Good_Packets,This register provides the number of good IPv4 datagrams received by DWC_ether_qos with the TCP UDP or ICMP payload"
            hexmask.long 0x00 0.--31. 1. "RXIPV4GDPKT,RxIPv4 Good Packets This field indicates the number of good IPv4 datagrams received with the TCP UDP or ICMP payload"
    rgroup.long 0x814++0x03
        line.long 0x00 "RxIPv4_Header_Error_Packets,RxIPv4 Header Error Packets This register provides the number of IPv4 datagrams received by DWC_ether_qos with header (checksum length or version mismatch) errors"
            hexmask.long 0x00 0.--31. 1. "RXIPV4HDRERRPKT,RxIPv4 Header Error Packets This field indicates the number of IPv4 datagrams received with header (checksum length or version mismatch) errors"
    rgroup.long 0x818++0x03
        line.long 0x00 "RxIPv4_No_Payload_Packets,This register provides the number of IPv4 datagram packets received by DWC_ether_qos that did not have a TCP UDP or ICMP payload"
            hexmask.long 0x00 0.--31. 1. "RXIPV4NOPAYPKT,RxIPv4 Payload Packets This field indicates the number of IPv4 datagram packets received that did not have a TCP UDP or ICMP payload"
    rgroup.long 0x81C++0x03
        line.long 0x00 "RxIPv4_Fragmented_Packets,This register provides the number of good IPv4 datagrams received by DWC_ether_qos with fragmentation"
            hexmask.long 0x00 0.--31. 1. "RXIPV4FRAGPKT,RxIPv4 Fragmented Packets This field indicates the number of good IPv4 datagrams received with fragmentation"
    rgroup.long 0x820++0x03
        line.long 0x00 "RxIPv4_UDP_Checksum_Disabled_Packets,This register provides the number of good IPv4 datagrams received by DWC_ether_qos that had a UDP payload with checksum disabled"
            hexmask.long 0x00 0.--31. 1. "RXIPV4UDSBLPKT,RxIPv4 UDP Checksum Disabled Packets This field indicates the number of good IPv4 datagrams received that had a UDP payload with checksum disabled"
    rgroup.long 0x824++0x03
        line.long 0x00 "RxIPv6_Good_Packets,This register provides the number of good IPv6 datagrams received by DWC_ether_qos with the TCP UDP or ICMP payload"
            hexmask.long 0x00 0.--31. 1. "RXIPV6GDPKT,RxIPv6 Good Packets This field indicates the number of good IPv6 datagrams received with the TCP UDP or ICMP payload"
    rgroup.long 0x828++0x03
        line.long 0x00 "RxIPv6_Header_Error_Packets,This register provides the number of IPv6 datagrams received by DWC_ether_qos with header (length or version mismatch) errors"
            hexmask.long 0x00 0.--31. 1. "RXIPV6HDRERRPKT,RxIPv6 Header Error Packets This field indicates the number of IPv6 datagrams received with header (length or version mismatch) errors"
    rgroup.long 0x82C++0x03
        line.long 0x00 "RxIPv6_No_Payload_Packets,This register provides the number of IPv6 datagram packets received by DWC_ether_qos that did not have a TCP UDP or ICMP payload"
            hexmask.long 0x00 0.--31. 1. "RXIPV6NOPAYPKT,RxIPv6 Payload Packets This field indicates the number of IPv6 datagram packets received that did not have a TCP UDP or ICMP payload"
    rgroup.long 0x830++0x03
        line.long 0x00 "RxUDP_Good_Packets,This register provides the number of good IP datagrams received by DWC_ether_qos with a good UDP payload"
            hexmask.long 0x00 0.--31. 1. "RXUDPGDPKT,RxUDP Good Packets This field indicates the number of good IP datagrams received with a good UDP payload"
    rgroup.long 0x834++0x03
        line.long 0x00 "RxUDP_Error_Packets,This register provides the number of good IP datagrams received by DWC_ether_qos whose UDP payload has a checksum error"
            hexmask.long 0x00 0.--31. 1. "RXUDPERRPKT,RxUDP Error Packets This field indicates the number of good IP datagrams received whose UDP payload has a checksum error"
    rgroup.long 0x838++0x03
        line.long 0x00 "RxTCP_Good_Packets,This register provides the number of good IP datagrams received by DWC_ether_qos with a good TCP payload"
            hexmask.long 0x00 0.--31. 1. "RXTCPGDPKT,RxTCP Good Packets This field indicates the number of good IP datagrams received with a good TCP payload"
    rgroup.long 0x83C++0x03
        line.long 0x00 "RxTCP_Error_Packets,This register provides the number of good IP datagrams received by DWC_ether_qos whose TCP payload has a checksum error"
            hexmask.long 0x00 0.--31. 1. "RXTCPERRPKT,RxTCP Error Packets This field indicates the number of good IP datagrams received whose TCP payload has a checksum error"
    rgroup.long 0x840++0x03
        line.long 0x00 "RxICMP_Good_Packets,This register provides the number of good IP datagrams received by DWC_ether_qos with a good ICMP payload"
            hexmask.long 0x00 0.--31. 1. "RXICMPGDPKT,RxICMP Good Packets This field indicates the number of good IP datagrams received with a good ICMP payload"
    rgroup.long 0x844++0x03
        line.long 0x00 "RxICMP_Error_Packets,This register provides the number of good IP datagrams received by DWC_ether_qos whose ICMP payload has a checksum error"
            hexmask.long 0x00 0.--31. 1. "RXICMPERRPKT,RxICMP Error Packets This field indicates the number of good IP datagrams received whose ICMP payload has a checksum error"
    rgroup.long 0x850++0x03
        line.long 0x00 "RxIPv4_Good_Octets,This register provides the number of bytes received by DWC_ether_qos in good IPv4 datagrams encapsulating TCP UDP or ICMP data"
            hexmask.long 0x00 0.--31. 1. "RXIPV4GDOCT,RxIPv4 Good Octets This field indicates the number of bytes received in good IPv4 datagrams encapsulating TCP UDP or ICMP data"
    rgroup.long 0x854++0x03
        line.long 0x00 "RxIPv4_Header_Error_Octets,This register provides the number of bytes received by DWC_ether_qos in IPv4 datagrams with header errors (checksum length version mismatch)"
            hexmask.long 0x00 0.--31. 1. "RXIPV4HDRERROCT,RxIPv4 Header Error Octets This field indicates the number of bytes received in IPv4 datagrams with header errors (checksum length version mismatch)"
    rgroup.long 0x858++0x03
        line.long 0x00 "RxIPv4_No_Payload_Octets,This register provides the number of bytes received by DWC_ether_qos in IPv4 datagrams that did not have a TCP UDP or ICMP payload"
            hexmask.long 0x00 0.--31. 1. "RXIPV4NOPAYOCT,RxIPv4 Payload Octets This field indicates the number of bytes received in IPv4 datagrams that did not have a TCP UDP or ICMP payload"
    rgroup.long 0x85C++0x03
        line.long 0x00 "RxIPv4_Fragmented_Octets,This register provides the number of bytes received by DWC_ether_qos in fragmented IPv4 datagrams"
            hexmask.long 0x00 0.--31. 1. "RXIPV4FRAGOCT,RxIPv4 Fragmented Octets This field indicates the number of bytes received in fragmented IPv4 datagrams"
    rgroup.long 0x860++0x03
        line.long 0x00 "RxIPv4_UDP_Checksum_Disable_Octets,This register provides the number of bytes received by DWC_ether_qos in a UDP segment that had the UDP checksum disabled"
            hexmask.long 0x00 0.--31. 1. "RXIPV4UDSBLOCT,RxIPv4 UDP Checksum Disable Octets This field indicates the number of bytes received in a UDP segment that had the UDP checksum disabled"
    rgroup.long 0x864++0x03
        line.long 0x00 "RxIPv6_Good_Octets,This register provides the number of bytes received by DWC_ether_qos in good IPv6 datagrams encapsulating TCP UDP or ICMP data"
            hexmask.long 0x00 0.--31. 1. "RXIPV6GDOCT,RxIPv6 Good Octets This field indicates the number of bytes received in good IPv6 datagrams encapsulating TCP UDP or ICMP data"
    rgroup.long 0x868++0x03
        line.long 0x00 "RxIPv6_Header_Error_Octets,This register provides the number of bytes received by DWC_ether_qos in IPv6 datagrams with header errors (length version mismatch)"
            hexmask.long 0x00 0.--31. 1. "RXIPV6HDRERROCT,RxIPv6 Header Error Octets This field indicates the number of bytes received in IPv6 datagrams with header errors (length version mismatch)"
    rgroup.long 0x86C++0x03
        line.long 0x00 "RxIPv6_No_Payload_Octets,This register provides the number of bytes received by DWC_ether_qos in IPv6 datagrams that did not have a TCP UDP or ICMP payload"
            hexmask.long 0x00 0.--31. 1. "RXIPV6NOPAYOCT,RxIPv6 Payload Octets This field indicates the number of bytes received in IPv6 datagrams that did not have a TCP UDP or ICMP payload"
    rgroup.long 0x870++0x03
        line.long 0x00 "RxUDP_Good_Octets,This register provides the number of bytes received by DWC_ether_qos in a good UDP segment"
            hexmask.long 0x00 0.--31. 1. "RXUDPGDOCT,RxUDP Good Octets This field indicates the number of bytes received in a good UDP segment"
    rgroup.long 0x874++0x03
        line.long 0x00 "RxUDP_Error_Octets,This register provides the number of bytes received by DWC_ether_qos in a UDP segment that had checksum errors"
            hexmask.long 0x00 0.--31. 1. "RXUDPERROCT,RxUDP Error Octets This field indicates the number of bytes received in a UDP segment that had checksum errors"
    rgroup.long 0x878++0x03
        line.long 0x00 "RxTCP_Good_Octets,This register provides the number of bytes received by DWC_ether_qos in a good TCP segment"
            hexmask.long 0x00 0.--31. 1. "RXTCPGDOCT,RxTCP Good Octets This field indicates the number of bytes received in a good TCP segment"
    rgroup.long 0x87C++0x03
        line.long 0x00 "RxTCP_Error_Octets,This register provides the number of bytes received by DWC_ether_qos in a TCP segment that had checksum errors"
            hexmask.long 0x00 0.--31. 1. "RXTCPERROCT,RxTCP Error Octets This field indicates the number of bytes received in a TCP segment that had checksum errors"
    rgroup.long 0x880++0x03
        line.long 0x00 "RxICMP_Good_Octets,This register provides the number of bytes received by DWC_ether_qos in a good ICMP segment"
            hexmask.long 0x00 0.--31. 1. "RXICMPGDOCT,RxICMP Good Octets This field indicates the number of bytes received in a good ICMP segment"
    rgroup.long 0x884++0x03
        line.long 0x00 "RxICMP_Error_Octets,This register provides the number of bytes received by DWC_ether_qos in a ICMP segment that had checksum errors"
            hexmask.long 0x00 0.--31. 1. "RXICMPERROCT,RxICMP Error Octets This field indicates the number of bytes received in a ICMP segment that had checksum errors"

    group.long 0x900++0x03
        line.long 0x00 "MAC_L3_L4_Control0,The Layer 3 and Layer 4 Control register controls the operations of filter 0 of Layer 3 and Layer 4"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 28. "DMCHEN0,DMA Channel Select Enable When set this bit enables the selection of the DMA channel number for the packet that is passed by this L3_L4 filter" "0: DMA Channel Select is disabled,1: DMA Channel Select is enabled"
            newline
            rbitfld.long 0x00 25.--27. "Reserved_27_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 24. "DMCHN0,DMA Channel Number When DMCHEN is set high this field selects the DMA Channel number to which the packet passed by this filter is routed" "0,1"
            newline
            rbitfld.long 0x00 22.--23. "Reserved_23_22,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 21. "L4DPIM0,Layer 4 Destination Port Inverse Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for inverse matching" "0: Layer 4 Destination Port Inverse Match is..,1: Layer 4 Destination Port Inverse Match is.."
            newline
            bitfld.long 0x00 20. "L4DPM0,Layer 4 Destination Port Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for matching" "0: Layer 4 Destination Port Match is disabled,1: Layer 4 Destination Port Match is enabled"
            newline
            bitfld.long 0x00 19. "L4SPIM0,Layer 4 Source Port Inverse Match Enable When this bit is set the Layer 4 Source Port number field is enabled for inverse matching" "0: Layer 4 Source Port Inverse Match is disabled,1: Layer 4 Source Port Inverse Match is enabled"
            newline
            bitfld.long 0x00 18. "L4SPM0,Layer 4 Source Port Match Enable When this bit is set the Layer 4 Source Port number field is enabled for matching" "0: Layer 4 Source Port Match is disabled,1: Layer 4 Source Port Match is enabled"
            newline
            rbitfld.long 0x00 17. "Reserved_17,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "L4PEN0,Layer 4 Protocol Enable When this bit is set the Source and Destination Port number fields of UDP packets are used for matching" "0: Layer 4 Protocol is disabled,1: Layer 4 Protocol is enabled"
            newline
            bitfld.long 0x00 11.--15. "L3HDBM0,Layer 3 IP DA Higher Bits Match IPv4 Packets: This field contains the number of higher bits of IP Destination Address that are matched in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 6.--10. "L3HSBM0,Layer 3 IP SA Higher Bits Match IPv4 Packets: This field contains the number of lower bits of IP Source Address that are masked for matching in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 5. "L3DAIM0,Layer 3 IP DA Inverse Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for inverse matching" "0: Layer 3 IP DA Inverse Match is disabled,1: Layer 3 IP DA Inverse Match is enabled"
            newline
            bitfld.long 0x00 4. "L3DAM0,Layer 3 IP DA Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for matching" "0: Layer 3 IP DA Match is disabled,1: Layer 3 IP DA Match is enabled"
            newline
            bitfld.long 0x00 3. "L3SAIM0,Layer 3 IP SA Inverse Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for inverse matching" "0: Layer 3 IP SA Inverse Match is disabled,1: Layer 3 IP SA Inverse Match is enabled"
            newline
            bitfld.long 0x00 2. "L3SAM0,Layer 3 IP SA Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for matching" "0: Layer 3 IP SA Match is disabled,1: Layer 3 IP SA Match is enabled"
            newline
            rbitfld.long 0x00 1. "Reserved_1,Reserved" "0,1"
            newline
            bitfld.long 0x00 0. "L3PEN0,Layer 3 Protocol Enable When this bit is set the Layer 3 IP Source or Destination Address matching is enabled for IPv6 packets" "0: Layer 3 Protocol is disabled,1: Layer 3 Protocol is enabled"
    group.long 0x904++0x03
        line.long 0x00 "MAC_Layer4_Address0,The MAC_Layer4_Address0 MAC_L3_L4_Control0 MAC_Layer3_Addr0_Reg0 MAC_Layer3_Addr1_Reg0 MAC_Layer3_Addr2_Reg0 and MAC_Layer3_Addr3_Reg0 registers are reserved (RO with default value) if Enable Layer 3 and Layer 4 Packet Filter option.."
            hexmask.long.word 0x00 16.--31. 1. "L4DP0,Layer 4 Destination Port Number Field When the L4PEN0 bit is reset and the L4DPM0 bit is set in the MAC_L3_L4_Control0 register this field contains the value to be matched with the TCP Destination Port Number field in the IPv4 or IPv6 packets"
            newline
            hexmask.long.word 0x00 0.--15. 1. "L4SP0,Layer 4 Source Port Number Field When the L4PEN0 bit is reset and the L4SPM0 bit is set in the MAC_L3_L4_Control0 register this field contains the value to be matched with the TCP Source Port Number field in the IPv4 or IPv6 packets"
    group.long 0x910++0x03
        line.long 0x00 "MAC_Layer3_Addr0_Reg0,For IPv4 packets the Layer 3 Address 0 Register 0 register contains the 32-bit IP Source Address field"
            hexmask.long 0x00 0.--31. 1. "L3A00,Layer 3 Address 0 Field When the L3PEN0 and L3SAM0 bits are set in the MAC_L3_L4_Control0 register this field contains the value to be matched with Bits[31:0] of the IP Source Address field in the IPv6 packets"
    group.long 0x914++0x03
        line.long 0x00 "MAC_Layer3_Addr1_Reg0,For IPv4 packets the Layer 3 Address 1 Register 0 register contains the 32-bit IP Destination Address field"
            hexmask.long 0x00 0.--31. 1. "L3A10,Layer 3 Address 1 Field When the L3PEN0 and L3SAM0 bits are set in the MAC_L3_L4_Control0 register this field contains the value to be matched with Bits[63:32] of the IP Source Address field in the IPv6 packets"
    group.long 0x918++0x03
        line.long 0x00 "MAC_Layer3_Addr2_Reg0,The Layer 3 Address 2 Register 0 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A20,Layer 3 Address 2 Field When the L3PEN0 and L3SAM0 bits are set in the MAC_L3_L4_Control0 register this field contains the value to be matched with Bits[95:64] of the IP Source Address field in the IPv6 packets"
    group.long 0x91C++0x03
        line.long 0x00 "MAC_Layer3_Addr3_Reg0,The Layer 3 Address 3 Register 0 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A30,Layer 3 Address 3 Field When the L3PEN0 and L3SAM0 bits are set in the MAC_L3_L4_Control0 register this field contains the value to be matched with Bits[127:96] of the IP Source Address field in the IPv6 packets"
    group.long 0x930++0x03
        line.long 0x00 "MAC_L3_L4_Control1,The Layer 3 and Layer 4 Control register controls the operations of filter 1 of Layer 3 and Layer 4"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 28. "DMCHEN1,DMA Channel Select Enable When set this bit enables the selection of the DMA channel number for the packet that is passed by this L3_L4 filter" "0: DMA Channel Select is disabled,1: DMA Channel Select is enabled"
            newline
            rbitfld.long 0x00 25.--27. "Reserved_27_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 24. "DMCHN1,DMA Channel Number When DMCHEN is set high this field selects the DMA Channel number to which the packet passed by this filter is routed" "0,1"
            newline
            rbitfld.long 0x00 22.--23. "Reserved_23_22,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 21. "L4DPIM1,Layer 4 Destination Port Inverse Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for inverse matching" "0: Layer 4 Destination Port Inverse Match is..,1: Layer 4 Destination Port Inverse Match is.."
            newline
            bitfld.long 0x00 20. "L4DPM1,Layer 4 Destination Port Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for matching" "0: Layer 4 Destination Port Match is disabled,1: Layer 4 Destination Port Match is enabled"
            newline
            bitfld.long 0x00 19. "L4SPIM1,Layer 4 Source Port Inverse Match Enable When this bit is set the Layer 4 Source Port number field is enabled for inverse matching" "0: Layer 4 Source Port Inverse Match is disabled,1: Layer 4 Source Port Inverse Match is enabled"
            newline
            bitfld.long 0x00 18. "L4SPM1,Layer 4 Source Port Match Enable When this bit is set the Layer 4 Source Port number field is enabled for matching" "0: Layer 4 Source Port Match is disabled,1: Layer 4 Source Port Match is enabled"
            newline
            rbitfld.long 0x00 17. "Reserved_17,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "L4PEN1,Layer 4 Protocol Enable When this bit is set the Source and Destination Port number fields of UDP packets are used for matching" "0: Layer 4 Protocol is disabled,1: Layer 4 Protocol is enabled"
            newline
            bitfld.long 0x00 11.--15. "L3HDBM1,Layer 3 IP DA Higher Bits Match IPv4 Packets: This field contains the number of higher bits of IP Destination Address that are matched in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 6.--10. "L3HSBM1,Layer 3 IP SA Higher Bits Match IPv4 Packets: This field contains the number of lower bits of IP Source Address that are masked for matching in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 5. "L3DAIM1,Layer 3 IP DA Inverse Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for inverse matching" "0: Layer 3 IP DA Inverse Match is disabled,1: Layer 3 IP DA Inverse Match is enabled"
            newline
            bitfld.long 0x00 4. "L3DAM1,Layer 3 IP DA Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for matching" "0: Layer 3 IP DA Match is disabled,1: Layer 3 IP DA Match is enabled"
            newline
            bitfld.long 0x00 3. "L3SAIM1,Layer 3 IP SA Inverse Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for inverse matching" "0: Layer 3 IP SA Inverse Match is disabled,1: Layer 3 IP SA Inverse Match is enabled"
            newline
            bitfld.long 0x00 2. "L3SAM1,Layer 3 IP SA Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for matching" "0: Layer 3 IP SA Match is disabled,1: Layer 3 IP SA Match is enabled"
            newline
            rbitfld.long 0x00 1. "Reserved_1,Reserved" "0,1"
            newline
            bitfld.long 0x00 0. "L3PEN1,Layer 3 Protocol Enable When this bit is set the Layer 3 IP Source or Destination Address matching is enabled for IPv6 packets" "0: Layer 3 Protocol is disabled,1: Layer 3 Protocol is enabled"
    group.long 0x934++0x03
        line.long 0x00 "MAC_Layer4_Address1,The MAC_Layer4_Address1 MAC_L3_L4_Control1 MAC_Layer3_Addr0_Reg1 MAC_Layer3_Addr1_Reg1 MAC_Layer3_Addr2_Reg1 and MAC_Layer3_Addr3_Reg1 registers are reserved (RO with default value) if Enable Layer 3 and Layer 4 Packet Filter option.."
            hexmask.long.word 0x00 16.--31. 1. "L4DP1,Layer 4 Destination Port Number Field When the L4PEN1 bit is reset and the L4DPM1 bit is set in the MAC_L3_L4_Control1 register this field contains the value to be matched with the TCP Destination Port Number field in the IPv4 or IPv6 packets"
            newline
            hexmask.long.word 0x00 0.--15. 1. "L4SP1,Layer 4 Source Port Number Field When the L4PEN1 bit is reset and the L4SPM1 bit is set in the MAC_L3_L4_Control1 register this field contains the value to be matched with the TCP Source Port Number field in the IPv4 or IPv6 packets"
    group.long 0x940++0x03
        line.long 0x00 "MAC_Layer3_Addr0_Reg1,For IPv4 packets the Layer 3 Address 0 Register 1 register contains the 32-bit IP Source Address field"
            hexmask.long 0x00 0.--31. 1. "L3A01,Layer 3 Address 0 Field When the L3PEN1 and L3SAM1 bits are set in the MAC_L3_L4_Control1 register this field contains the value to be matched with Bits[31:0] of the IP Source Address field in the IPv6 packets"
    group.long 0x944++0x03
        line.long 0x00 "MAC_Layer3_Addr1_Reg1,For IPv4 packets the Layer 3 Address 1 Register 1 register contains the 32-bit IP Destination Address field"
            hexmask.long 0x00 0.--31. 1. "L3A11,Layer 3 Address 1 Field When the L3PEN1 and L3SAM1 bits are set in the MAC_L3_L4_Control1 register this field contains the value to be matched with Bits[63:32] of the IP Source Address field in the IPv6 packets"
    group.long 0x948++0x03
        line.long 0x00 "MAC_Layer3_Addr2_Reg1,The Layer 3 Address 2 Register 1 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A21,Layer 3 Address 2 Field When the L3PEN1 and L3SAM1 bits are set in the MAC_L3_L4_Control1 register this field contains the value to be matched with Bits[95:64] of the IP Source Address field in the IPv6 packets"
    group.long 0x94C++0x03
        line.long 0x00 "MAC_Layer3_Addr3_Reg1,The Layer 3 Address 3 Register 1 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A31,Layer 3 Address 3 Field When the L3PEN1 and L3SAM1 bits are set in the MAC_L3_L4_Control1 register this field contains the value to be matched with Bits[127:96] of the IP Source Address field in the IPv6 packets"
    group.long 0x960++0x03
        line.long 0x00 "MAC_L3_L4_Control2,The Layer 3 and Layer 4 Control register controls the operations of filter 2 of Layer 3 and Layer 4"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 28. "DMCHEN2,DMA Channel Select Enable When set this bit enables the selection of the DMA channel number for the packet that is passed by this L3_L4 filter" "0: DMA Channel Select is disabled,1: DMA Channel Select is enabled"
            newline
            rbitfld.long 0x00 25.--27. "Reserved_27_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 24. "DMCHN2,DMA Channel Number When DMCHEN is set high this field selects the DMA Channel number to which the packet passed by this filter is routed" "0,1"
            newline
            rbitfld.long 0x00 22.--23. "Reserved_23_22,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 21. "L4DPIM2,Layer 4 Destination Port Inverse Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for inverse matching" "0: Layer 4 Destination Port Inverse Match is..,1: Layer 4 Destination Port Inverse Match is.."
            newline
            bitfld.long 0x00 20. "L4DPM2,Layer 4 Destination Port Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for matching" "0: Layer 4 Destination Port Match is disabled,1: Layer 4 Destination Port Match is enabled"
            newline
            bitfld.long 0x00 19. "L4SPIM2,Layer 4 Source Port Inverse Match Enable When this bit is set the Layer 4 Source Port number field is enabled for inverse matching" "0: Layer 4 Source Port Inverse Match is disabled,1: Layer 4 Source Port Inverse Match is enabled"
            newline
            bitfld.long 0x00 18. "L4SPM2,Layer 4 Source Port Match Enable When this bit is set the Layer 4 Source Port number field is enabled for matching" "0: Layer 4 Source Port Match is disabled,1: Layer 4 Source Port Match is enabled"
            newline
            rbitfld.long 0x00 17. "Reserved_17,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "L4PEN2,Layer 4 Protocol Enable When this bit is set the Source and Destination Port number fields of UDP packets are used for matching" "0: Layer 4 Protocol is disabled,1: Layer 4 Protocol is enabled"
            newline
            bitfld.long 0x00 11.--15. "L3HDBM2,Layer 3 IP DA Higher Bits Match IPv4 Packets: This field contains the number of higher bits of IP Destination Address that are matched in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 6.--10. "L3HSBM2,Layer 3 IP SA Higher Bits Match IPv4 Packets: This field contains the number of lower bits of IP Source Address that are masked for matching in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 5. "L3DAIM2,Layer 3 IP DA Inverse Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for inverse matching" "0: Layer 3 IP DA Inverse Match is disabled,1: Layer 3 IP DA Inverse Match is enabled"
            newline
            bitfld.long 0x00 4. "L3DAM2,Layer 3 IP DA Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for matching" "0: Layer 3 IP DA Match is disabled,1: Layer 3 IP DA Match is enabled"
            newline
            bitfld.long 0x00 3. "L3SAIM2,Layer 3 IP SA Inverse Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for inverse matching" "0: Layer 3 IP SA Inverse Match is disabled,1: Layer 3 IP SA Inverse Match is enabled"
            newline
            bitfld.long 0x00 2. "L3SAM2,Layer 3 IP SA Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for matching" "0: Layer 3 IP SA Match is disabled,1: Layer 3 IP SA Match is enabled"
            newline
            rbitfld.long 0x00 1. "Reserved_1,Reserved" "0,1"
            newline
            bitfld.long 0x00 0. "L3PEN2,Layer 3 Protocol Enable When this bit is set the Layer 3 IP Source or Destination Address matching is enabled for IPv6 packets" "0: Layer 3 Protocol is disabled,1: Layer 3 Protocol is enabled"
    group.long 0x964++0x03
        line.long 0x00 "MAC_Layer4_Address2,The MAC_Layer4_Address2 MAC_L3_L4_Control2 MAC_Layer3_Addr0_Reg2 MAC_Layer3_Addr1_Reg2 MAC_Layer3_Addr2_Reg2 and MAC_Layer3_Addr3_Reg2 registers are reserved (RO with default value) if Enable Layer 3 and Layer 4 Packet Filter option.."
            hexmask.long.word 0x00 16.--31. 1. "L4DP2,Layer 4 Destination Port Number Field When the L4PEN2 bit is reset and the L4DPM2 bit is set in the MAC_L3_L4_Control2 register this field contains the value to be matched with the TCP Destination Port Number field in the IPv4 or IPv6 packets"
            newline
            hexmask.long.word 0x00 0.--15. 1. "L4SP2,Layer 4 Source Port Number Field When the L4PEN2 bit is reset and the L4SPM2 bit is set in the MAC_L3_L4_Control2 register this field contains the value to be matched with the TCP Source Port Number field in the IPv4 or IPv6 packets"
    group.long 0x970++0x03
        line.long 0x00 "MAC_Layer3_Addr0_Reg2,For IPv4 packets the Layer 3 Address 0 Register 2 register contains the 32-bit IP Source Address field"
            hexmask.long 0x00 0.--31. 1. "L3A02,Layer 3 Address 0 Field When the L3PEN2 and L3SAM2 bits are set in the MAC_L3_L4_Control2 register this field contains the value to be matched with Bits[31:0] of the IP Source Address field in the IPv6 packets"
    group.long 0x974++0x03
        line.long 0x00 "MAC_Layer3_Addr1_Reg2,For IPv4 packets the Layer 3 Address 1 Register 2 register contains the 32-bit IP Destination Address field"
            hexmask.long 0x00 0.--31. 1. "L3A12,Layer 3 Address 1 Field When the L3PEN2 and L3SAM2 bits are set in the MAC_L3_L4_Control2 register this field contains the value to be matched with Bits[63:32] of the IP Source Address field in the IPv6 packets"
    group.long 0x978++0x03
        line.long 0x00 "MAC_Layer3_Addr2_Reg2,The Layer 3 Address 2 Register 2 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A22,Layer 3 Address 2 Field When the L3PEN2 and L3SAM2 bits are set in the MAC_L3_L4_Control2 register this field contains the value to be matched with Bits[95:64] of the IP Source Address field in the IPv6 packets"
    group.long 0x97C++0x03
        line.long 0x00 "MAC_Layer3_Addr3_Reg2,The Layer 3 Address 3 Register 2 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A32,Layer 3 Address 3 Field When the L3PEN2 and L3SAM2 bits are set in the MAC_L3_L4_Control2 register this field contains the value to be matched with Bits[127:96] of the IP Source Address field in the IPv6 packets"
    group.long 0x990++0x03
        line.long 0x00 "MAC_L3_L4_Control3,The Layer 3 and Layer 4 Control register controls the operations of filter 3 of Layer 3 and Layer 4"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 28. "DMCHEN3,DMA Channel Select Enable When set this bit enables the selection of the DMA channel number for the packet that is passed by this L3_L4 filter" "0: DMA Channel Select is disabled,1: DMA Channel Select is enabled"
            newline
            rbitfld.long 0x00 25.--27. "Reserved_27_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 24. "DMCHN3,DMA Channel Number When DMCHEN is set high this field selects the DMA Channel number to which the packet passed by this filter is routed" "0,1"
            newline
            rbitfld.long 0x00 22.--23. "Reserved_23_22,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 21. "L4DPIM3,Layer 4 Destination Port Inverse Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for inverse matching" "0: Layer 4 Destination Port Inverse Match is..,1: Layer 4 Destination Port Inverse Match is.."
            newline
            bitfld.long 0x00 20. "L4DPM3,Layer 4 Destination Port Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for matching" "0: Layer 4 Destination Port Match is disabled,1: Layer 4 Destination Port Match is enabled"
            newline
            bitfld.long 0x00 19. "L4SPIM3,Layer 4 Source Port Inverse Match Enable When this bit is set the Layer 4 Source Port number field is enabled for inverse matching" "0: Layer 4 Source Port Inverse Match is disabled,1: Layer 4 Source Port Inverse Match is enabled"
            newline
            bitfld.long 0x00 18. "L4SPM3,Layer 4 Source Port Match Enable When this bit is set the Layer 4 Source Port number field is enabled for matching" "0: Layer 4 Source Port Match is disabled,1: Layer 4 Source Port Match is enabled"
            newline
            rbitfld.long 0x00 17. "Reserved_17,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "L4PEN3,Layer 4 Protocol Enable When this bit is set the Source and Destination Port number fields of UDP packets are used for matching" "0: Layer 4 Protocol is disabled,1: Layer 4 Protocol is enabled"
            newline
            bitfld.long 0x00 11.--15. "L3HDBM3,Layer 3 IP DA Higher Bits Match IPv4 Packets: This field contains the number of higher bits of IP Destination Address that are matched in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 6.--10. "L3HSBM3,Layer 3 IP SA Higher Bits Match IPv4 Packets: This field contains the number of lower bits of IP Source Address that are masked for matching in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 5. "L3DAIM3,Layer 3 IP DA Inverse Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for inverse matching" "0: Layer 3 IP DA Inverse Match is disabled,1: Layer 3 IP DA Inverse Match is enabled"
            newline
            bitfld.long 0x00 4. "L3DAM3,Layer 3 IP DA Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for matching" "0: Layer 3 IP DA Match is disabled,1: Layer 3 IP DA Match is enabled"
            newline
            bitfld.long 0x00 3. "L3SAIM3,Layer 3 IP SA Inverse Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for inverse matching" "0: Layer 3 IP SA Inverse Match is disabled,1: Layer 3 IP SA Inverse Match is enabled"
            newline
            bitfld.long 0x00 2. "L3SAM3,Layer 3 IP SA Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for matching" "0: Layer 3 IP SA Match is disabled,1: Layer 3 IP SA Match is enabled"
            newline
            rbitfld.long 0x00 1. "Reserved_1,Reserved" "0,1"
            newline
            bitfld.long 0x00 0. "L3PEN3,Layer 3 Protocol Enable When this bit is set the Layer 3 IP Source or Destination Address matching is enabled for IPv6 packets" "0: Layer 3 Protocol is disabled,1: Layer 3 Protocol is enabled"
    group.long 0x994++0x03
        line.long 0x00 "MAC_Layer4_Address3,The MAC_Layer4_Address3 MAC_L3_L4_Control3 MAC_Layer3_Addr0_Reg3 MAC_Layer3_Addr1_Reg3 MAC_Layer3_Addr2_Reg3 and MAC_Layer3_Addr3_Reg3 registers are reserved (RO with default value) if Enable Layer 3 and Layer 4 Packet Filter option.."
            hexmask.long.word 0x00 16.--31. 1. "L4DP3,Layer 4 Destination Port Number Field When the L4PEN3 bit is reset and the L4DPM3 bit is set in the MAC_L3_L4_Control3 register this field contains the value to be matched with the TCP Destination Port Number field in the IPv4 or IPv6 packets"
            newline
            hexmask.long.word 0x00 0.--15. 1. "L4SP3,Layer 4 Source Port Number Field When the L4PEN3 bit is reset and the L4SPM3 bit is set in the MAC_L3_L4_Control3 register this field contains the value to be matched with the TCP Source Port Number field in the IPv4 or IPv6 packets"
    group.long 0x9A0++0x03
        line.long 0x00 "MAC_Layer3_Addr0_Reg3,For IPv4 packets the Layer 3 Address 0 Register 3 register contains the 32-bit IP Source Address field"
            hexmask.long 0x00 0.--31. 1. "L3A03,Layer 3 Address 0 Field When the L3PEN3 and L3SAM3 bits are set in the MAC_L3_L4_Control3 register this field contains the value to be matched with Bits[31:0] of the IP Source Address field in the IPv6 packets"
    group.long 0x9A4++0x03
        line.long 0x00 "MAC_Layer3_Addr1_Reg3,For IPv4 packets the Layer 3 Address 1 Register 3 register contains the 32-bit IP Destination Address field"
            hexmask.long 0x00 0.--31. 1. "L3A13,Layer 3 Address 1 Field When the L3PEN3 and L3SAM3 bits are set in the MAC_L3_L4_Control3 register this field contains the value to be matched with Bits[63:32] of the IP Source Address field in the IPv6 packets"
    group.long 0x9A8++0x03
        line.long 0x00 "MAC_Layer3_Addr2_Reg3,The Layer 3 Address 2 Register 3 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A23,Layer 3 Address 2 Field When the L3PEN3 and L3SAM3 bits are set in the MAC_L3_L4_Control3 register this field contains the value to be matched with Bits[95:64] of the IP Source Address field in the IPv6 packets"
    group.long 0x9AC++0x03
        line.long 0x00 "MAC_Layer3_Addr3_Reg3,The Layer 3 Address 3 Register 3 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A33,Layer 3 Address 3 Field When the L3PEN3 and L3SAM3 bits are set in the MAC_L3_L4_Control3 register this field contains the value to be matched with Bits[127:96] of the IP Source Address field in the IPv6 packets"
    group.long 0x9C0++0x03
        line.long 0x00 "MAC_L3_L4_Control4,The Layer 3 and Layer 4 Control register controls the operations of filter 4 of Layer 3 and Layer 4"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 28. "DMCHEN4,DMA Channel Select Enable When set this bit enables the selection of the DMA channel number for the packet that is passed by this L3_L4 filter" "0: DMA Channel Select is disabled,1: DMA Channel Select is enabled"
            newline
            rbitfld.long 0x00 25.--27. "Reserved_27_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 24. "DMCHN4,DMA Channel Number When DMCHEN is set high this field selects the DMA Channel number to which the packet passed by this filter is routed" "0,1"
            newline
            rbitfld.long 0x00 22.--23. "Reserved_23_22,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 21. "L4DPIM4,Layer 4 Destination Port Inverse Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for inverse matching" "0: Layer 4 Destination Port Inverse Match is..,1: Layer 4 Destination Port Inverse Match is.."
            newline
            bitfld.long 0x00 20. "L4DPM4,Layer 4 Destination Port Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for matching" "0: Layer 4 Destination Port Match is disabled,1: Layer 4 Destination Port Match is enabled"
            newline
            bitfld.long 0x00 19. "L4SPIM4,Layer 4 Source Port Inverse Match Enable When this bit is set the Layer 4 Source Port number field is enabled for inverse matching" "0: Layer 4 Source Port Inverse Match is disabled,1: Layer 4 Source Port Inverse Match is enabled"
            newline
            bitfld.long 0x00 18. "L4SPM4,Layer 4 Source Port Match Enable When this bit is set the Layer 4 Source Port number field is enabled for matching" "0: Layer 4 Source Port Match is disabled,1: Layer 4 Source Port Match is enabled"
            newline
            rbitfld.long 0x00 17. "Reserved_17,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "L4PEN4,Layer 4 Protocol Enable When this bit is set the Source and Destination Port number fields of UDP packets are used for matching" "0: Layer 4 Protocol is disabled,1: Layer 4 Protocol is enabled"
            newline
            bitfld.long 0x00 11.--15. "L3HDBM4,Layer 3 IP DA Higher Bits Match IPv4 Packets: This field contains the number of higher bits of IP Destination Address that are matched in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 6.--10. "L3HSBM4,Layer 3 IP SA Higher Bits Match IPv4 Packets: This field contains the number of lower bits of IP Source Address that are masked for matching in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 5. "L3DAIM4,Layer 3 IP DA Inverse Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for inverse matching" "0: Layer 3 IP DA Inverse Match is disabled,1: Layer 3 IP DA Inverse Match is enabled"
            newline
            bitfld.long 0x00 4. "L3DAM4,Layer 3 IP DA Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for matching" "0: Layer 3 IP DA Match is disabled,1: Layer 3 IP DA Match is enabled"
            newline
            bitfld.long 0x00 3. "L3SAIM4,Layer 3 IP SA Inverse Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for inverse matching" "0: Layer 3 IP SA Inverse Match is disabled,1: Layer 3 IP SA Inverse Match is enabled"
            newline
            bitfld.long 0x00 2. "L3SAM4,Layer 3 IP SA Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for matching" "0: Layer 3 IP SA Match is disabled,1: Layer 3 IP SA Match is enabled"
            newline
            rbitfld.long 0x00 1. "Reserved_1,Reserved" "0,1"
            newline
            bitfld.long 0x00 0. "L3PEN4,Layer 3 Protocol Enable When this bit is set the Layer 3 IP Source or Destination Address matching is enabled for IPv6 packets" "0: Layer 3 Protocol is disabled,1: Layer 3 Protocol is enabled"
    group.long 0x9C4++0x03
        line.long 0x00 "MAC_Layer4_Address4,The MAC_Layer4_Address4 MAC_L3_L4_Control4 MAC_Layer3_Addr0_Reg4 MAC_Layer3_Addr1_Reg4 MAC_Layer3_Addr2_Reg4 and MAC_Layer3_Addr3_Reg4 registers are reserved (RO with default value) if Enable Layer 3 and Layer 4 Packet Filter option.."
            hexmask.long.word 0x00 16.--31. 1. "L4DP4,Layer 4 Destination Port Number Field When the L4PEN4 bit is reset and the L4DPM4 bit is set in the MAC_L3_L4_Control4 register this field contains the value to be matched with the TCP Destination Port Number field in the IPv4 or IPv6 packets"
            newline
            hexmask.long.word 0x00 0.--15. 1. "L4SP4,Layer 4 Source Port Number Field When the L4PEN4 bit is reset and the L4SPM4 bit is set in the MAC_L3_L4_Control4 register this field contains the value to be matched with the TCP Source Port Number field in the IPv4 or IPv6 packets"
    group.long 0x9D0++0x03
        line.long 0x00 "MAC_Layer3_Addr0_Reg4,For IPv4 packets the Layer 3 Address 0 Register 4 register contains the 32-bit IP Source Address field"
            hexmask.long 0x00 0.--31. 1. "L3A04,Layer 3 Address 0 Field When the L3PEN4 and L3SAM4 bits are set in the MAC_L3_L4_Control4 register this field contains the value to be matched with Bits[31:0] of the IP Source Address field in the IPv6 packets"
    group.long 0x9D4++0x03
        line.long 0x00 "MAC_Layer3_Addr1_Reg4,For IPv4 packets the Layer 3 Address 1 Register 4 register contains the 32-bit IP Destination Address field"
            hexmask.long 0x00 0.--31. 1. "L3A14,Layer 3 Address 1 Field When the L3PEN4 and L3SAM4 bits are set in the MAC_L3_L4_Control4 register this field contains the value to be matched with Bits[63:32] of the IP Source Address field in the IPv6 packets"
    group.long 0x9D8++0x03
        line.long 0x00 "MAC_Layer3_Addr2_Reg4,The Layer 3 Address 2 Register 4 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A24,Layer 3 Address 2 Field When the L3PEN4 and L3SAM4 bits are set in the MAC_L3_L4_Control4 register this field contains the value to be matched with Bits[95:64] of the IP Source Address field in the IPv6 packets"
    group.long 0x9DC++0x03
        line.long 0x00 "MAC_Layer3_Addr3_Reg4,The Layer 3 Address 3 Register 4 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A34,Layer 3 Address 3 Field When the L3PEN4 and L3SAM4 bits are set in the MAC_L3_L4_Control4 register this field contains the value to be matched with Bits[127:96] of the IP Source Address field in the IPv6 packets"
    group.long 0x9F0++0x03
        line.long 0x00 "MAC_L3_L4_Control5,The Layer 3 and Layer 4 Control register controls the operations of filter 5 of Layer 3 and Layer 4"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 28. "DMCHEN5,DMA Channel Select Enable When set this bit enables the selection of the DMA channel number for the packet that is passed by this L3_L4 filter" "0: DMA Channel Select is disabled,1: DMA Channel Select is enabled"
            newline
            rbitfld.long 0x00 25.--27. "Reserved_27_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 24. "DMCHN5,DMA Channel Number When DMCHEN is set high this field selects the DMA Channel number to which the packet passed by this filter is routed" "0,1"
            newline
            rbitfld.long 0x00 22.--23. "Reserved_23_22,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 21. "L4DPIM5,Layer 4 Destination Port Inverse Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for inverse matching" "0: Layer 4 Destination Port Inverse Match is..,1: Layer 4 Destination Port Inverse Match is.."
            newline
            bitfld.long 0x00 20. "L4DPM5,Layer 4 Destination Port Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for matching" "0: Layer 4 Destination Port Match is disabled,1: Layer 4 Destination Port Match is enabled"
            newline
            bitfld.long 0x00 19. "L4SPIM5,Layer 4 Source Port Inverse Match Enable When this bit is set the Layer 4 Source Port number field is enabled for inverse matching" "0: Layer 4 Source Port Inverse Match is disabled,1: Layer 4 Source Port Inverse Match is enabled"
            newline
            bitfld.long 0x00 18. "L4SPM5,Layer 4 Source Port Match Enable When this bit is set the Layer 4 Source Port number field is enabled for matching" "0: Layer 4 Source Port Match is disabled,1: Layer 4 Source Port Match is enabled"
            newline
            rbitfld.long 0x00 17. "Reserved_17,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "L4PEN5,Layer 4 Protocol Enable When this bit is set the Source and Destination Port number fields of UDP packets are used for matching" "0: Layer 4 Protocol is disabled,1: Layer 4 Protocol is enabled"
            newline
            bitfld.long 0x00 11.--15. "L3HDBM5,Layer 3 IP DA Higher Bits Match IPv4 Packets: This field contains the number of higher bits of IP Destination Address that are matched in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 6.--10. "L3HSBM5,Layer 3 IP SA Higher Bits Match IPv4 Packets: This field contains the number of lower bits of IP Source Address that are masked for matching in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 5. "L3DAIM5,Layer 3 IP DA Inverse Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for inverse matching" "0: Layer 3 IP DA Inverse Match is disabled,1: Layer 3 IP DA Inverse Match is enabled"
            newline
            bitfld.long 0x00 4. "L3DAM5,Layer 3 IP DA Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for matching" "0: Layer 3 IP DA Match is disabled,1: Layer 3 IP DA Match is enabled"
            newline
            bitfld.long 0x00 3. "L3SAIM5,Layer 3 IP SA Inverse Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for inverse matching" "0: Layer 3 IP SA Inverse Match is disabled,1: Layer 3 IP SA Inverse Match is enabled"
            newline
            bitfld.long 0x00 2. "L3SAM5,Layer 3 IP SA Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for matching" "0: Layer 3 IP SA Match is disabled,1: Layer 3 IP SA Match is enabled"
            newline
            rbitfld.long 0x00 1. "Reserved_1,Reserved" "0,1"
            newline
            bitfld.long 0x00 0. "L3PEN5,Layer 3 Protocol Enable When this bit is set the Layer 3 IP Source or Destination Address matching is enabled for IPv6 packets" "0: Layer 3 Protocol is disabled,1: Layer 3 Protocol is enabled"
    group.long 0x9F4++0x03
        line.long 0x00 "MAC_Layer4_Address5,The MAC_Layer4_Address5 MAC_L3_L4_Control5 MAC_Layer3_Addr0_Reg5 MAC_Layer3_Addr1_Reg5 MAC_Layer3_Addr2_Reg5 and MAC_Layer3_Addr3_Reg5 registers are reserved (RO with default value) if Enable Layer 3 and Layer 4 Packet Filter option.."
            hexmask.long.word 0x00 16.--31. 1. "L4DP5,Layer 4 Destination Port Number Field When the L4PEN5 bit is reset and the L4DPM5 bit is set in the MAC_L3_L4_Control5 register this field contains the value to be matched with the TCP Destination Port Number field in the IPv4 or IPv6 packets"
            newline
            hexmask.long.word 0x00 0.--15. 1. "L4SP5,Layer 4 Source Port Number Field When the L4PEN5 bit is reset and the L4SPM5 bit is set in the MAC_L3_L4_Control5 register this field contains the value to be matched with the TCP Source Port Number field in the IPv4 or IPv6 packets"
    group.long 0xA00++0x03
        line.long 0x00 "MAC_Layer3_Addr0_Reg5,For IPv4 packets the Layer 3 Address 0 Register 5 register contains the 32-bit IP Source Address field"
            hexmask.long 0x00 0.--31. 1. "L3A05,Layer 3 Address 0 Field When the L3PEN5 and L3SAM5 bits are set in the MAC_L3_L4_Control5 register this field contains the value to be matched with Bits[31:0] of the IP Source Address field in the IPv6 packets"
    group.long 0xA04++0x03
        line.long 0x00 "MAC_Layer3_Addr1_Reg5,For IPv4 packets the Layer 3 Address 1 Register 5 register contains the 32-bit IP Destination Address field"
            hexmask.long 0x00 0.--31. 1. "L3A15,Layer 3 Address 1 Field When the L3PEN5 and L3SAM5 bits are set in the MAC_L3_L4_Control5 register this field contains the value to be matched with Bits[63:32] of the IP Source Address field in the IPv6 packets"
    group.long 0xA08++0x03
        line.long 0x00 "MAC_Layer3_Addr2_Reg5,The Layer 3 Address 2 Register 5 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A25,Layer 3 Address 2 Field When the L3PEN5 and L3SAM5 bits are set in the MAC_L3_L4_Control5 register this field contains the value to be matched with Bits[95:64] of the IP Source Address field in the IPv6 packets"
    group.long 0xA0C++0x03
        line.long 0x00 "MAC_Layer3_Addr3_Reg5,The Layer 3 Address 3 Register 5 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A35,Layer 3 Address 3 Field When the L3PEN5 and L3SAM5 bits are set in the MAC_L3_L4_Control5 register this field contains the value to be matched with Bits[127:96] of the IP Source Address field in the IPv6 packets"
    group.long 0xA20++0x03
        line.long 0x00 "MAC_L3_L4_Control6,The Layer 3 and Layer 4 Control register controls the operations of filter 6 of Layer 3 and Layer 4"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 28. "DMCHEN6,DMA Channel Select Enable When set this bit enables the selection of the DMA channel number for the packet that is passed by this L3_L4 filter" "0: DMA Channel Select is disabled,1: DMA Channel Select is enabled"
            newline
            rbitfld.long 0x00 25.--27. "Reserved_27_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 24. "DMCHN6,DMA Channel Number When DMCHEN is set high this field selects the DMA Channel number to which the packet passed by this filter is routed" "0,1"
            newline
            rbitfld.long 0x00 22.--23. "Reserved_23_22,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 21. "L4DPIM6,Layer 4 Destination Port Inverse Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for inverse matching" "0: Layer 4 Destination Port Inverse Match is..,1: Layer 4 Destination Port Inverse Match is.."
            newline
            bitfld.long 0x00 20. "L4DPM6,Layer 4 Destination Port Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for matching" "0: Layer 4 Destination Port Match is disabled,1: Layer 4 Destination Port Match is enabled"
            newline
            bitfld.long 0x00 19. "L4SPIM6,Layer 4 Source Port Inverse Match Enable When this bit is set the Layer 4 Source Port number field is enabled for inverse matching" "0: Layer 4 Source Port Inverse Match is disabled,1: Layer 4 Source Port Inverse Match is enabled"
            newline
            bitfld.long 0x00 18. "L4SPM6,Layer 4 Source Port Match Enable When this bit is set the Layer 4 Source Port number field is enabled for matching" "0: Layer 4 Source Port Match is disabled,1: Layer 4 Source Port Match is enabled"
            newline
            rbitfld.long 0x00 17. "Reserved_17,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "L4PEN6,Layer 4 Protocol Enable When this bit is set the Source and Destination Port number fields of UDP packets are used for matching" "0: Layer 4 Protocol is disabled,1: Layer 4 Protocol is enabled"
            newline
            bitfld.long 0x00 11.--15. "L3HDBM6,Layer 3 IP DA Higher Bits Match IPv4 Packets: This field contains the number of higher bits of IP Destination Address that are matched in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 6.--10. "L3HSBM6,Layer 3 IP SA Higher Bits Match IPv4 Packets: This field contains the number of lower bits of IP Source Address that are masked for matching in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 5. "L3DAIM6,Layer 3 IP DA Inverse Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for inverse matching" "0: Layer 3 IP DA Inverse Match is disabled,1: Layer 3 IP DA Inverse Match is enabled"
            newline
            bitfld.long 0x00 4. "L3DAM6,Layer 3 IP DA Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for matching" "0: Layer 3 IP DA Match is disabled,1: Layer 3 IP DA Match is enabled"
            newline
            bitfld.long 0x00 3. "L3SAIM6,Layer 3 IP SA Inverse Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for inverse matching" "0: Layer 3 IP SA Inverse Match is disabled,1: Layer 3 IP SA Inverse Match is enabled"
            newline
            bitfld.long 0x00 2. "L3SAM6,Layer 3 IP SA Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for matching" "0: Layer 3 IP SA Match is disabled,1: Layer 3 IP SA Match is enabled"
            newline
            rbitfld.long 0x00 1. "Reserved_1,Reserved" "0,1"
            newline
            bitfld.long 0x00 0. "L3PEN6,Layer 3 Protocol Enable When this bit is set the Layer 3 IP Source or Destination Address matching is enabled for IPv6 packets" "0: Layer 3 Protocol is disabled,1: Layer 3 Protocol is enabled"
    group.long 0xA24++0x03
        line.long 0x00 "MAC_Layer4_Address6,The MAC_Layer4_Address6 MAC_L3_L4_Control6 MAC_Layer3_Addr0_Reg6 MAC_Layer3_Addr1_Reg6 MAC_Layer3_Addr2_Reg6 and MAC_Layer3_Addr3_Reg6 registers are reserved (RO with default value) if Enable Layer 3 and Layer 4 Packet Filter option.."
            hexmask.long.word 0x00 16.--31. 1. "L4DP6,Layer 4 Destination Port Number Field When the L4PEN6 bit is reset and the L4DPM6 bit is set in the MAC_L3_L4_Control6 register this field contains the value to be matched with the TCP Destination Port Number field in the IPv4 or IPv6 packets"
            newline
            hexmask.long.word 0x00 0.--15. 1. "L4SP6,Layer 4 Source Port Number Field When the L4PEN6 bit is reset and the L4SPM6 bit is set in the MAC_L3_L4_Control6 register this field contains the value to be matched with the TCP Source Port Number field in the IPv4 or IPv6 packets"
    group.long 0xA30++0x03
        line.long 0x00 "MAC_Layer3_Addr0_Reg6,For IPv4 packets the Layer 3 Address 0 Register 6 register contains the 32-bit IP Source Address field"
            hexmask.long 0x00 0.--31. 1. "L3A06,Layer 3 Address 0 Field When the L3PEN6 and L3SAM6 bits are set in the MAC_L3_L4_Control6 register this field contains the value to be matched with Bits[31:0] of the IP Source Address field in the IPv6 packets"
    group.long 0xA34++0x03
        line.long 0x00 "MAC_Layer3_Addr1_Reg6,For IPv4 packets the Layer 3 Address 1 Register 6 register contains the 32-bit IP Destination Address field"
            hexmask.long 0x00 0.--31. 1. "L3A16,Layer 3 Address 1 Field When the L3PEN6 and L3SAM6 bits are set in the MAC_L3_L4_Control6 register this field contains the value to be matched with Bits[63:32] of the IP Source Address field in the IPv6 packets"
    group.long 0xA38++0x03
        line.long 0x00 "MAC_Layer3_Addr2_Reg6,The Layer 3 Address 2 Register 6 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A26,Layer 3 Address 2 Field When the L3PEN6 and L3SAM6 bits are set in the MAC_L3_L4_Control6 register this field contains the value to be matched with Bits[95:64] of the IP Source Address field in the IPv6 packets"
    group.long 0xA3C++0x03
        line.long 0x00 "MAC_Layer3_Addr3_Reg6,The Layer 3 Address 3 Register 6 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A36,Layer 3 Address 3 Field When the L3PEN6 and L3SAM6 bits are set in the MAC_L3_L4_Control6 register this field contains the value to be matched with Bits[127:96] of the IP Source Address field in the IPv6 packets"
    group.long 0xA50++0x03
        line.long 0x00 "MAC_L3_L4_Control7,The Layer 3 and Layer 4 Control register controls the operations of filter 7 of Layer 3 and Layer 4"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 28. "DMCHEN7,DMA Channel Select Enable When set this bit enables the selection of the DMA channel number for the packet that is passed by this L3_L4 filter" "0: DMA Channel Select is disabled,1: DMA Channel Select is enabled"
            newline
            rbitfld.long 0x00 25.--27. "Reserved_27_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 24. "DMCHN7,DMA Channel Number When DMCHEN is set high this field selects the DMA Channel number to which the packet passed by this filter is routed" "0,1"
            newline
            rbitfld.long 0x00 22.--23. "Reserved_23_22,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 21. "L4DPIM7,Layer 4 Destination Port Inverse Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for inverse matching" "0: Layer 4 Destination Port Inverse Match is..,1: Layer 4 Destination Port Inverse Match is.."
            newline
            bitfld.long 0x00 20. "L4DPM7,Layer 4 Destination Port Match Enable When this bit is set the Layer 4 Destination Port number field is enabled for matching" "0: Layer 4 Destination Port Match is disabled,1: Layer 4 Destination Port Match is enabled"
            newline
            bitfld.long 0x00 19. "L4SPIM7,Layer 4 Source Port Inverse Match Enable When this bit is set the Layer 4 Source Port number field is enabled for inverse matching" "0: Layer 4 Source Port Inverse Match is disabled,1: Layer 4 Source Port Inverse Match is enabled"
            newline
            bitfld.long 0x00 18. "L4SPM7,Layer 4 Source Port Match Enable When this bit is set the Layer 4 Source Port number field is enabled for matching" "0: Layer 4 Source Port Match is disabled,1: Layer 4 Source Port Match is enabled"
            newline
            rbitfld.long 0x00 17. "Reserved_17,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "L4PEN7,Layer 4 Protocol Enable When this bit is set the Source and Destination Port number fields of UDP packets are used for matching" "0: Layer 4 Protocol is disabled,1: Layer 4 Protocol is enabled"
            newline
            bitfld.long 0x00 11.--15. "L3HDBM7,Layer 3 IP DA Higher Bits Match IPv4 Packets: This field contains the number of higher bits of IP Destination Address that are matched in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 6.--10. "L3HSBM7,Layer 3 IP SA Higher Bits Match IPv4 Packets: This field contains the number of lower bits of IP Source Address that are masked for matching in the IPv4 packets" "0: No bits are masked,1: LSb[0] is masked,2: Two LSbs [1:0] are masked,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,?,31: All bits except MSb are masked"
            newline
            bitfld.long 0x00 5. "L3DAIM7,Layer 3 IP DA Inverse Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for inverse matching" "0: Layer 3 IP DA Inverse Match is disabled,1: Layer 3 IP DA Inverse Match is enabled"
            newline
            bitfld.long 0x00 4. "L3DAM7,Layer 3 IP DA Match Enable When this bit is set the Layer 3 IP Destination Address field is enabled for matching" "0: Layer 3 IP DA Match is disabled,1: Layer 3 IP DA Match is enabled"
            newline
            bitfld.long 0x00 3. "L3SAIM7,Layer 3 IP SA Inverse Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for inverse matching" "0: Layer 3 IP SA Inverse Match is disabled,1: Layer 3 IP SA Inverse Match is enabled"
            newline
            bitfld.long 0x00 2. "L3SAM7,Layer 3 IP SA Match Enable When this bit is set the Layer 3 IP Source Address field is enabled for matching" "0: Layer 3 IP SA Match is disabled,1: Layer 3 IP SA Match is enabled"
            newline
            rbitfld.long 0x00 1. "Reserved_1,Reserved" "0,1"
            newline
            bitfld.long 0x00 0. "L3PEN7,Layer 3 Protocol Enable When this bit is set the Layer 3 IP Source or Destination Address matching is enabled for IPv6 packets" "0: Layer 3 Protocol is disabled,1: Layer 3 Protocol is enabled"
    group.long 0xA54++0x03
        line.long 0x00 "MAC_Layer4_Address7,The MAC_Layer4_Address7 MAC_L3_L4_Control7 MAC_Layer3_Addr0_Reg7 MAC_Layer3_Addr1_Reg7 MAC_Layer3_Addr2_Reg7 and MAC_Layer3_Addr3_Reg7 registers are reserved (RO with default value) if Enable Layer 3 and Layer 4 Packet Filter option.."
            hexmask.long.word 0x00 16.--31. 1. "L4DP7,Layer 4 Destination Port Number Field When the L4PEN7 bit is reset and the L4DPM7 bit is set in the MAC_L3_L4_Control7 register this field contains the value to be matched with the TCP Destination Port Number field in the IPv4 or IPv6 packets"
            newline
            hexmask.long.word 0x00 0.--15. 1. "L4SP7,Layer 4 Source Port Number Field When the L4PEN7 bit is reset and the L4SPM7 bit is set in the MAC_L3_L4_Control7 register this field contains the value to be matched with the TCP Source Port Number field in the IPv4 or IPv6 packets"
    group.long 0xA60++0x03
        line.long 0x00 "MAC_Layer3_Addr0_Reg7,For IPv4 packets the Layer 3 Address 0 Register 7 register contains the 32-bit IP Source Address field"
            hexmask.long 0x00 0.--31. 1. "L3A07,Layer 3 Address 0 Field When the L3PEN7 and L3SAM7 bits are set in the MAC_L3_L4_Control7 register this field contains the value to be matched with Bits[31:0] of the IP Source Address field in the IPv6 packets"
    group.long 0xA64++0x03
        line.long 0x00 "MAC_Layer3_Addr1_Reg7,For IPv4 packets the Layer 3 Address 1 Register 7 register contains the 32-bit IP Destination Address field"
            hexmask.long 0x00 0.--31. 1. "L3A17,Layer 3 Address 1 Field When the L3PEN7 and L3SAM7 bits are set in the MAC_L3_L4_Control7 register this field contains the value to be matched with Bits[63:32] of the IP Source Address field in the IPv6 packets"
    group.long 0xA68++0x03
        line.long 0x00 "MAC_Layer3_Addr2_Reg7,The Layer 3 Address 2 Register 7 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A27,Layer 3 Address 2 Field When the L3PEN7 and L3SAM7 bits are set in the MAC_L3_L4_Control7 register this field contains the value to be matched with Bits[95:64] of the IP Source Address field in the IPv6 packets"
    group.long 0xA6C++0x03
        line.long 0x00 "MAC_Layer3_Addr3_Reg7,The Layer 3 Address 3 Register 7 register is reserved for IPv4 packets"
            hexmask.long 0x00 0.--31. 1. "L3A37,Layer 3 Address 3 Field When the L3PEN7 and L3SAM7 bits are set in the MAC_L3_L4_Control7 register this field contains the value to be matched with Bits[127:96] of the IP Source Address field in the IPv6 packets"
    group.long 0xA70++0x03
        line.long 0x00 "MAC_Indir_Access_Ctrl,This register provides the Indirect Access control and status for MAC_<MSEl>_<AOFF> registers"
            bitfld.long 0x00 31. "SNPS_R,snps_r" "0,1"
            newline
            hexmask.long.word 0x00 20.--30. 1. "Reserved_30_20,Reserved"
            newline
            bitfld.long 0x00 16.--19. "MSEL,Mode Select This field is used in indirect access of MAC_<MSEL>_<AOFF>" "0: MAC_TMRQ_Regs (Ethernet Type based RXQ mapping),1: MAC_PCCtrl_IndReg (Per Policing Counter Control,2: MAC_PCntr_IndReg (Per Policing Counter..,3: MAC_DPCSel_IndReg (Per DA Perfect Filter Event,4: MAC_VPCSel_IndReg (Per VLAN Filter Event,5: MAC_LPCSel_IndReg (Per L3-L4 Filter Event,6: MAC_FPCSel_IndReg0 (Filter Fail Event Register),7: MAC_PCStatus_IndReg0 (Policing Counter Status,?..."
            newline
            abitfld.long 0x00 8.--15. "AOFF,Address Offset This field is used in indirect access of MAC_<MSEL>_<AOFF>" "0x00=0: MAC_PCStatus_DA_IndReg0,0x01=1: MAC_PCStatus_VLAN_IndReg,0x07=7: MAC_TMRQ_Regs7 - 00001000-11111111,0x0A=10: MAC_PCStatus_L3L4_IndReg,0x0B=11: MAC_PCStatus_Filter_Event_IndReg,0x1F=31: MAC_VPCSel_IndReg31 - 00100000-11111111,0x6F=111: MAC_LPCSel_IndReg7 - 00001000-11111111"
            newline
            rbitfld.long 0x00 6.--7. "Reserved_7_6,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 5. "AUTO,Auto increment" "0: AOFF is not incremented automatically,1: AOFF is incremented by 1"
            newline
            rbitfld.long 0x00 2.--4. "Reserved_4_2,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 1. "COM,Command type This bit indicates the register access type" "0: Write operation,1: Read operation"
            newline
            bitfld.long 0x00 0. "OB,Operation Busy" "0,1"
    group.long 0xA74++0x03
        line.long 0x00 "MAC_Indir_Access_Data,This register holds the read/write data for Indirect Access of MAC_<MSEL_<AOFF> registers"
            hexmask.long 0x00 0.--31. 1. "DATA,This field contains data to read/write for Indirect address access associated with MAC_Indir_Access_Ctrl register"
    group.long 0xB00++0x03
        line.long 0x00 "MAC_Timestamp_Control,This register controls the operation of the System Time generator and processing of PTP packets for timestamping in the Receiver"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 28. "AV8021ASMEN,AV 802.1AS Mode Enable When this bit is set the MAC processes only untagged PTP over Ethernet packets for providing PTP status and capturing timestamp snapshots that is IEEE 802.1AS mode of operation" "0: AV 802.1AS Mode is disabled,1: AV 802.1AS Mode is enabled"
            newline
            rbitfld.long 0x00 27. "Reserved_TITA,Reserved" "0,1"
            newline
            rbitfld.long 0x00 26. "Reserved_26,Reserved" "0,1"
            newline
            rbitfld.long 0x00 25. "Reserved_EPCSL,Reserved" "0,1"
            newline
            bitfld.long 0x00 24. "TXTSSTSM,Transmit Timestamp Status Mode When this bit is set the MAC overwrites the earlier transmit timestamp status even if it is not read by the software" "0: Transmit Timestamp Status Mode is disabled,1: Transmit Timestamp Status Mode is enabled"
            newline
            rbitfld.long 0x00 21.--23. "Reserved_23_21,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 20. "ESTI,External System Time Input When this bit is set the MAC uses the external 64-bit reference System Time input for the following: - To take the timestamp provided as status - To insert the timestamp in transmit PTP packets when One-step Timestamp or.." "0: External System Time Input is disabled,1: External System Time Input is enabled"
            newline
            bitfld.long 0x00 19. "CSC,Enable checksum correction during OST for PTP over UDP/IPv4 packets When this bit is set the last two bytes of PTP message sent over UDP/IPv4 is updated to keep the UDP checksum correct for changes made to origin timestamp and/or correction field as.." "0: checksum correction during OST for PTP over..,1: checksum correction during OST for PTP over.."
            newline
            bitfld.long 0x00 18. "TSENMACADDR,Enable MAC Address for PTP Packet Filtering When this bit is set the DA MAC address (that matches any MAC Address register) is used to filter the PTP packets when PTP is directly sent over Ethernet" "0: MAC Address for PTP Packet Filtering is..,1: MAC Address for PTP Packet Filtering is enabled"
            newline
            bitfld.long 0x00 16.--17. "SNAPTYPSEL,Select PTP packets for Taking Snapshots These bits along with Bits 15 and 14 decide the set of PTP packet types for which snapshot needs to be taken" "0,1,2,3"
            newline
            bitfld.long 0x00 15. "TSMSTRENA,Enable Snapshot for Messages Relevant to Master When this bit is set the snapshot is taken only for the messages that are relevant to the master node" "0: Snapshot for Messages Relevant to Master is..,1: Snapshot for Messages Relevant to Master is.."
            newline
            bitfld.long 0x00 14. "TSEVNTENA,Enable Timestamp Snapshot for Event Messages When this bit is set the timestamp snapshot is taken only for event messages (SYNC Delay_Req Pdelay_Req or Pdelay_Resp)" "0: Timestamp Snapshot for Event Messages is..,1: Timestamp Snapshot for Event Messages is.."
            newline
            bitfld.long 0x00 13. "TSIPV4ENA,Enable Processing of PTP Packets Sent over IPv4-UDP When this bit is set the MAC receiver processes the PTP packets encapsulated in IPv4-UDP packets" "0: Processing of PTP Packets Sent over IPv4-UDP..,1: Processing of PTP Packets Sent over IPv4-UDP.."
            newline
            bitfld.long 0x00 12. "TSIPV6ENA,Enable Processing of PTP Packets Sent over IPv6-UDP When this bit is set the MAC receiver processes the PTP packets encapsulated in IPv6-UDP packets" "0: Processing of PTP Packets Sent over IPv6-UDP..,1: Processing of PTP Packets Sent over IPv6-UDP.."
            newline
            bitfld.long 0x00 11. "TSIPENA,Enable Processing of PTP over Ethernet Packets When this bit is set the MAC receiver processes the PTP packets encapsulated directly in the Ethernet packets" "0: Processing of PTP over Ethernet Packets is..,1: Processing of PTP over Ethernet Packets is.."
            newline
            bitfld.long 0x00 10. "TSVER2ENA,Enable PTP Packet Processing for Version 2 Format When this bit is set the IEEE 1588 version 2 format is used to process the PTP packets" "0: PTP Packet Processing for Version 2 Format is..,1: PTP Packet Processing for Version 2 Format is.."
            newline
            bitfld.long 0x00 9. "TSCTRLSSR,Timestamp Digital or Binary Rollover Control When this bit is set the Timestamp Low register rolls over after 0x3B9A_C9FF value (that is 1 nanosecond accuracy) and increments the timestamp (High) seconds" "0: Timestamp Digital or Binary Rollover Control..,1: Timestamp Digital or Binary Rollover Control.."
            newline
            bitfld.long 0x00 8. "TSENALL,Enable Timestamp for All Packets When this bit is set the timestamp snapshot is enabled for all packets received by the MAC" "0: Timestamp for All Packets disabled,1: Timestamp for All Packets enabled"
            newline
            rbitfld.long 0x00 7. "Reserved_7,Reserved" "0,1"
            newline
            bitfld.long 0x00 6. "PTGE,Presentation Time Generation Enable When this bit is set the Presentation Time generation is enabled" "0: Presentation Time Generation is disabled,1: Presentation Time Generation is enabled"
            newline
            bitfld.long 0x00 5. "TSADDREG,Update Addend Register When this bit is set the content of the Timestamp Addend register is updated in the PTP block for fine correction" "0: Addend Register is not updated,1: Addend Register is updated"
            newline
            rbitfld.long 0x00 4. "Reserved_TSTRIG,Reserved" "0,1"
            newline
            bitfld.long 0x00 3. "TSUPDT,Update Timestamp When this bit is set the system time is updated (added or subtracted) with the value specified in MAC_System_Time_Seconds_Update and MAC_System_Time_Nanoseconds_Update registers" "0: Timestamp is not updated,1: Timestamp is updated"
            newline
            bitfld.long 0x00 2. "TSINIT,Initialize Timestamp When this bit is set the system time is initialized (overwritten) with the value specified in the MAC_System_Time_Seconds_Update and MAC_System_Time_Nanoseconds_Update registers" "0: Timestamp is not initialized,1: Timestamp is initialized"
            newline
            bitfld.long 0x00 1. "TSCFUPDT,Fine or Coarse Timestamp Update When this bit is set the Fine method is used to update system timestamp" "0: Coarse method is used to update system..,1: Fine method is used to update system timestamp"
            newline
            bitfld.long 0x00 0. "TSENA,Enable Timestamp When this bit is set the timestamp is added for Transmit and Receive packets" "0: Timestamp is disabled,1: Timestamp is enabled"
    group.long 0xB04++0x03
        line.long 0x00 "MAC_Sub_Second_Increment,This register specifies the value to be added to the internal system time register every cycle of clk_ptp_ref_i clock"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_31_24,Reserved"
            newline
            hexmask.long.byte 0x00 16.--23. 1. "SSINC,Sub-second Increment Value The value programmed in this field is accumulated every clock cycle (of clk_ptp_i) with the contents of the sub-second register"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "Reserved_SNSINC,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "Reserved_7_0,Reserved"

    rgroup.long 0xB08++0x03
        line.long 0x00 "MAC_System_Time_Seconds,The System Time Seconds register along with System Time Nanoseconds register indicates the current value of the system time maintained by the MAC"
            hexmask.long 0x00 0.--31. 1. "TSS,Timestamp Second The value in this field indicates the current value in seconds of the System Time maintained by the MAC"
    rgroup.long 0xB0C++0x03
        line.long 0x00 "MAC_System_Time_Nanoseconds,The System Time Nanoseconds register along with System Time Seconds register indicates the current value of the system time maintained by the MAC"
            bitfld.long 0x00 31. "Reserved_31,Reserved" "0,1"
            newline
            hexmask.long 0x00 0.--30. 1. "TSSS,Timestamp Sub Seconds The value in this field has the sub-second representation of time with an accuracy of 0.46 ns"

    group.long 0xB10++0x03
        line.long 0x00 "MAC_System_Time_Seconds_Update,The System Time Seconds Update register along with the System Time Nanoseconds Update register initializes or updates the system time maintained by the MAC"
            hexmask.long 0x00 0.--31. 1. "TSS,Timestamp Seconds The value in this field is the seconds part of the update"
    group.long 0xB14++0x03
        line.long 0x00 "MAC_System_Time_Nanoseconds_Update,MAC System Time Nanoseconds Update register"
            bitfld.long 0x00 31. "ADDSUB,Add or Subtract Time When this bit is set the time value is subtracted with the contents of the update register" "0: Add time,1: Subtract time"
            newline
            abitfld.long 0x00 0.--30. "TSSS,Timestamp Sub Seconds The value in this field is the sub-seconds part of the update" "0x00000000=0: -- The programmed value must be 2^31,0x00000001=1: -- The programmed value must be 10^9"
    group.long 0xB18++0x03
        line.long 0x00 "MAC_Timestamp_Addend,Timestamp Addend register"
            hexmask.long 0x00 0.--31. 1. "TSAR,Timestamp Addend Register This field indicates the 32-bit time value to be added to the Accumulator register to achieve time synchronization"
    group.long 0xB1C++0x03
        line.long 0x00 "MAC_System_Time_Higher_Word_Seconds,System Time - Higher Word Seconds register"
            hexmask.long.word 0x00 16.--31. 1. "Reserved_31_16,Reserved"
            newline
            hexmask.long.word 0x00 0.--15. 1. "TSHWR,Timestamp Higher Word Register This field contains the most-significant 16-bits of timestamp seconds value"

    rgroup.long 0xB20++0x03
        line.long 0x00 "MAC_Timestamp_Status,Timestamp Status register"
            bitfld.long 0x00 30.--31. "Reserved_31_30,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 25.--29. "ATSNS,Number of Auxiliary Timestamp Snapshots This field indicates the number of Snapshots available in the FIFO" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 24. "ATSSTM,Auxiliary Timestamp Snapshot Trigger Missed This bit is set when the Auxiliary timestamp snapshot FIFO is full and external trigger was set" "0: Auxiliary Timestamp Snapshot Trigger Missed..,1: Auxiliary Timestamp Snapshot Trigger Missed.."
            newline
            bitfld.long 0x00 20.--23. "Reserved_23_20,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 16.--19. "ATSSTN,Auxiliary Timestamp Snapshot Trigger Identifier These bits identify the Auxiliary trigger inputs for which the timestamp available in the Auxiliary Snapshot Register is applicable" "0: Bit,1: Bit,2: Bit,?..."
            newline
            bitfld.long 0x00 15. "TXTSSIS,Tx Timestamp Status Interrupt Status This bit is set when the captured transmit timestamp is updated in the MAC_Tx_Timestamp_Status_Nanoseconds and MAC_Tx_Timestamp_Status_Seconds registers" "0: Tx Timestamp Status Interrupt status not..,1: Tx Timestamp Status Interrupt status detected"
            newline
            bitfld.long 0x00 10.--14. "Reserved_14_10,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 9. "TSTRGTERR3,Timestamp Target Time Error This bit is set when the latest target time programmed in the MAC_PPS3_Target_Time_Seconds and MAC_PPS3_Target_Time_Nanoseconds registers elapses" "0: Timestamp Target Time Error status not detected,1: Timestamp Target Time Error status detected"
            newline
            bitfld.long 0x00 8. "TSTARGT3,Timestamp Target Time Reached for Target Time PPS3 When this bit is set and MCGREN3 of MAC_PPS_Control register is reset it indicates that the value of system time is greater than or equal to the value specified in the.." "0: Timestamp Target Time Reached for Target Time..,1: Timestamp Target Time Reached for Target Time.."
            newline
            bitfld.long 0x00 7. "TSTRGTERR2,Timestamp Target Time Error This bit is set when the latest target time programmed in the MAC_PPS2_Target_Time_Seconds and MAC_PPS2_Target_Time_Nanoseconds registers elapses" "0: Timestamp Target Time Error status not detected,1: Timestamp Target Time Error status detected"
            newline
            bitfld.long 0x00 6. "TSTARGT2,Timestamp Target Time Reached for Target Time PPS2 When this bit is set and MCGREN2 of MAC_PPS_Control register is reset it indicates that the value of system time is greater than or equal to the value specified in the.." "0: Timestamp Target Time Reached for Target Time..,1: Timestamp Target Time Reached for Target Time.."
            newline
            bitfld.long 0x00 5. "TSTRGTERR1,Timestamp Target Time Error This bit is set when the latest target time programmed in the MAC_PPS1_Target_Time_Seconds and MAC_PPS1_Target_Time_Nanoseconds registers elapses" "0: Timestamp Target Time Error status not detected,1: Timestamp Target Time Error status detected"
            newline
            bitfld.long 0x00 4. "TSTARGT1,Timestamp Target Time Reached for Target Time PPS1 When this bit is set and MCGREN1 of MAC_PPS_Control register is reset it indicates that the value of system time is greater than or equal to the value specified in the.." "0: Timestamp Target Time Reached for Target Time..,1: Timestamp Target Time Reached for Target Time.."
            newline
            bitfld.long 0x00 3. "TSTRGTERR0,Timestamp Target Time Error This bit is set when the latest target time programmed in the MAC_PPS0_Target_Time_Seconds and MAC_PPS0_Target_Time_Nanoseconds registers elapses" "0: Timestamp Target Time Error status not detected,1: Timestamp Target Time Error status detected"
            newline
            bitfld.long 0x00 2. "AUXTSTRIG,Auxiliary Timestamp Trigger Snapshot This bit is set high when the auxiliary snapshot is written to the FIFO" "0: Auxiliary Timestamp Trigger Snapshot status..,1: Auxiliary Timestamp Trigger Snapshot status.."
            newline
            bitfld.long 0x00 1. "TSTARGT0,Timestamp Target Time Reached When this bit is set and MCGREN0 of MAC_PPS_Control register is reset it indicates that the value of system time is greater than or equal to the value specified in the MAC_PPS0_Target_Time_Seconds and.." "0: Timestamp Target Time Reached status not..,1: Timestamp Target Time Reached status detected"
            newline
            bitfld.long 0x00 0. "TSSOVF,Timestamp Seconds Overflow When this bit is set it indicates that the seconds value of the timestamp (when supporting version 2 format) has overflowed beyond 32'hFFFF_FFFF" "0: Timestamp Seconds Overflow status not detected,1: Timestamp Seconds Overflow status detected"

    group.long 0xB24++0x03
        line.long 0x00 "MAC_Rx_Domain_Time_Incr,This register indicates the increment value of the PTP time maintained in Receive clock domain that is used for timestamping"
            hexmask.long.word 0x00 16.--31. 1. "RXNS,Receive Domain Time Increment Value in Nanoseconds"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "Reserved_RXSNS,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "Reserved_7_0,Reserved"
    group.long 0xB28++0x03
        line.long 0x00 "MAC_Tx_Domain_Time_Incr,This register indicates the increment value of the PTP time maintained in Transmit clock domain that is used for timestamping"
            hexmask.long.word 0x00 16.--31. 1. "TXNS,Transmit Domain Time Increment Value in Nanoseconds"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "Reserved_TXSNS,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "Reserved_7_0,Reserved"

    rgroup.long 0xB30++0x03
        line.long 0x00 "MAC_Tx_Timestamp_Status_Nanoseconds,This register contains the nanosecond part of timestamp captured for Transmit packets when Tx status is disabled"
            bitfld.long 0x00 31. "TXTSSMIS,Transmit Timestamp Status Missed When this bit is set it indicates one of the following: - The timestamp of the current packet is ignored if TXTSSTSM bit of the MAC_Timestamp_Control register is reset - The timestamp of the previous packet is.." "0: Transmit Timestamp Status Missed status not..,1: Transmit Timestamp Status Missed status.."
            newline
            hexmask.long 0x00 0.--30. 1. "TXTSSLO,Transmit Timestamp Status Low This field contains the 31 bits of the Nanoseconds field of the Transmit packet's captured timestamp"
    rgroup.long 0xB34++0x03
        line.long 0x00 "MAC_Tx_Timestamp_Status_Seconds,The register contains the higher 32 bits of the timestamp (in seconds) captured when a PTP packet is transmitted"
            hexmask.long 0x00 0.--31. 1. "TXTSSHI,Transmit Timestamp Status High This field contains the lower 32 bits of the Seconds field of Transmit packet's captured timestamp"

    group.long 0xB40++0x03
        line.long 0x00 "MAC_Auxiliary_Control,The Auxiliary Timestamp Control register controls the Auxiliary Timestamp snapshot"
            hexmask.long.tbyte 0x00 8.--31. 1. "Reserved_31_8,Reserved"
            newline
            rbitfld.long 0x00 7. "Reserved_ATSEN3,Reserved" "0,1"
            newline
            rbitfld.long 0x00 6. "Reserved_ATSEN2,Reserved" "0,1"
            newline
            bitfld.long 0x00 5. "ATSEN1,Auxiliary Snapshot 1 Enable This bit controls the capturing of Auxiliary Snapshot Trigger 1" "0: Auxiliary Snapshot i is disabled,1: Auxiliary Snapshot i is enabled"
            newline
            bitfld.long 0x00 4. "ATSEN0,Auxiliary Snapshot 0 Enable This bit controls the capturing of Auxiliary Snapshot Trigger 0" "0: Auxiliary Snapshot i is disabled,1: Auxiliary Snapshot i is enabled"
            newline
            rbitfld.long 0x00 1.--3. "Reserved_3_1,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0. "ATSFC,Auxiliary Snapshot FIFO Clear When set this bit resets the pointers of the Auxiliary Snapshot FIFO" "0: Auxiliary Snapshot FIFO Clear is disabled,1: Auxiliary Snapshot FIFO Clear is enabled"

    rgroup.long 0xB48++0x03
        line.long 0x00 "MAC_Auxiliary_Timestamp_Nanoseconds,The Auxiliary Timestamp Nanoseconds register along with MAC_Auxiliary_Timestamp_Seconds gives the 64-bit timestamp stored as auxiliary snapshot"
            bitfld.long 0x00 31. "Reserved_31,Reserved" "0,1"
            newline
            hexmask.long 0x00 0.--30. 1. "AUXTSLO,Auxiliary Timestamp Contains the lower 31 bits (nanoseconds field) of the auxiliary timestamp"
    rgroup.long 0xB4C++0x03
        line.long 0x00 "MAC_Auxiliary_Timestamp_Seconds,The Auxiliary Timestamp - Seconds register contains the lower 32 bits of the Seconds field of the auxiliary timestamp register"
            hexmask.long 0x00 0.--31. 1. "AUXTSHI,Auxiliary Timestamp Contains the lower 32 bits of the Seconds field of the auxiliary timestamp"

    group.long 0xB50++0x03
        line.long 0x00 "MAC_Timestamp_Ingress_Asym_Corr,The MAC Timestamp Ingress Asymmetry Correction register contains the Ingress Asymmetry Correction value to be used while updating correction field in PDelay_Resp PTP messages"
            hexmask.long 0x00 0.--31. 1. "OSTIAC,One-Step Timestamp Ingress Asymmetry Correction This field contains the ingress path asymmetry value to be added to correctionField of Pdelay_Resp PTP packet"
    group.long 0xB54++0x03
        line.long 0x00 "MAC_Timestamp_Egress_Asym_Corr,The MAC Timestamp Egress Asymmetry Correction register contains the Egress Asymmetry Correction value to be used while updating the correction field in PDelay_Req PTP messages"
            hexmask.long 0x00 0.--31. 1. "OSTEAC,One-Step Timestamp Egress Asymmetry Correction This field contains the egress path asymmetry value to be subtracted from correctionField of Pdelay_Resp PTP packet"
    group.long 0xB58++0x03
        line.long 0x00 "MAC_Timestamp_Ingress_Corr_Nanosecond,This register contains the correction value in nanoseconds to be used with the captured timestamp value in the ingress path"
            hexmask.long 0x00 0.--31. 1. "TSIC,Timestamp Ingress Correction This field contains the ingress path correction value as defined by the Ingress Correction expression"
    group.long 0xB5C++0x03
        line.long 0x00 "MAC_Timestamp_Egress_Corr_Nanosecond,This register contains the correction value in nanoseconds to be used with the captured timestamp value in the egress path"
            hexmask.long 0x00 0.--31. 1. "TSEC,Timestamp Egress Correction This field contains the nanoseconds part of the egress path correction value as defined by the Egress Correction expression"

    rgroup.long 0xB68++0x03
        line.long 0x00 "MAC_Timestamp_Ingress_Latency,This register holds the Ingress MAC latency"
            bitfld.long 0x00 28.--31. "Reserved_31_28,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.word 0x00 16.--27. 1. "ITLNS,Ingress Timestamp Latency in sub-nanoseconds This register holds the average latency in sub-nanoseconds between the input ports (phy_rxd_i) of MAC and the actual point (GMII/MII) where the ingress timestamp is taken"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "ITLSNS,Ingress Timestamp Latency in nanoseconds This register holds the average latency in nanoseconds between the input ports (phy_rxd_i) of MAC and the actual point (GMII/MII) where the ingress timestamp is taken"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "Reserved_7_0,Reserved"
    rgroup.long 0xB6C++0x03
        line.long 0x00 "MAC_Timestamp_Egress_Latency,This register holds the Egress MAC latency"
            bitfld.long 0x00 28.--31. "Reserved_31_28,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.word 0x00 16.--27. 1. "ETLNS,Egress Timestamp Latency in nanoseconds This register holds the average latency in nanoseconds between the actual point (GMII/MII) where the egress timestamp is taken and the output ports (phy_txd_o) of the MAC"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "ETLSNS,Egress Timestamp Latency in sub-nanoseconds This register holds the average latency in sub-nanoseconds between the actual point (GMII/MII) where the egress timestamp is taken and the output ports (phy_txd_o) of the MAC"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "Reserved_7_0,Reserved"

    group.long 0xB70++0x03
        line.long 0x00 "MAC_PPS_Control,PPS Control register"
            bitfld.long 0x00 31. "MCGREN3,MCGR Mode Enable for PPS3 Output This field enables the 3rd PPS instance to operate in PPS or MCGR mode" "0: Operates in PPS mode,1: Operates in MCGR mode"
            newline
            bitfld.long 0x00 29.--30. "TRGTMODSEL3,Target Time Register Mode for PPS3 Output This field indicates the Target Time registers (MAC_PPS3_Target_Time_Seconds and MAC_PPS3_Target_Time_Nanoseconds) mode for PPS3 output signal" "0: Target Time registers are programmed only for..,1: Enables MCGR Interrupt whose status bit is..,2: Target Time registers are programmed for..,3: Target Time registers are programmed only for.."
            newline
            bitfld.long 0x00 28. "TIMESEL,Time Select When this bit is set 64 bit PTP time is used to capture time at MCGR trigger[0] input When this bit is reset presentation time is used to capture time at trigger input maintaining backward compatibility" "0,1"
            newline
            bitfld.long 0x00 24.--27. "PPSCMD3,Flexible PPS3 Output Control This field controls the flexible PPS3 output (ptp_pps_o[3]) signal" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 23. "MCGREN2,MCGR Mode Enable for PPS2 Output This field enables the 2nd PPS instance to operate in PPS or MCGR mode" "0: 2nd PPS instance is disabled to operate in..,1: 2nd PPS instance is enabled to operate in PPS.."
            newline
            bitfld.long 0x00 21.--22. "TRGTMODSEL2,Target Time Register Mode for PPS2 Output This field indicates the Target Time registers (MAC_PPS2_Target_Time_Seconds and MAC_PPS2_Target_Time_Nanoseconds) mode for PPS2 output signal" "0: Target Time registers are programmed only for..,1: Enables MCGR Interrupt whose status bit is..,2: Target Time registers are programmed for..,3: Target Time registers are programmed only for.."
            newline
            rbitfld.long 0x00 20. "Reserved_20,Reserved" "0,1"
            newline
            bitfld.long 0x00 16.--19. "PPSCMD2,Flexible PPS2 Output Control This field controls the flexible PPS2 output (ptp_pps_o[2]) signal" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 15. "MCGREN1,MCGR Mode Enable for PPS1 Output This field enables the 1st PPS instance to operate in PPS or MCGR mode" "0: 1st PPS instance is disabled to operate in..,1: 1st PPS instance is enabled to operate in PPS.."
            newline
            bitfld.long 0x00 13.--14. "TRGTMODSEL1,Target Time Register Mode for PPS1 Output This field indicates the Target Time registers (MAC_PPS1_Target_Time_Seconds and MAC_PPS1_Target_Time_Nanoseconds) mode for PPS1 output signal" "0: Target Time registers are programmed only for..,1: Enables MCGR Interrupt whose status bit is..,2: Target Time registers are programmed for..,3: Target Time registers are programmed only for.."
            newline
            rbitfld.long 0x00 12. "Reserved_12,Reserved" "0,1"
            newline
            bitfld.long 0x00 8.--11. "PPSCMD1,Flexible PPS1 Output Control This field controls the flexible PPS1 output (ptp_pps_o[1]) signal" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 7. "MCGREN0,MCGR Mode Enable for PPS0 Output This field enables the 0th PPS instance to operate in PPS or MCGR mode" "0: 0th PPS instance is enabled to operate in PPS..,1: 0th PPS instance is enabled to operate in.."
            newline
            bitfld.long 0x00 5.--6. "TRGTMODSEL0,Target Time Register Mode for PPS0 Output This field indicates the Target Time registers (MAC_PPS0_Target_Time_Seconds and MAC_PPS0_Target_Time_Nanoseconds) mode for PPS0 output signal" "0: Target Time registers are programmed only for..,1: Enables MCGR Interrupt whose status bit is..,2: Target Time registers are programmed for..,3: Target Time registers are programmed only for.."
            newline
            bitfld.long 0x00 4. "PPSEN0,Flexible PPS Output Mode Enable When this bit is" "0: Flexible PPS Output Mode is disabled,1: Flexible PPS Output Mode is enabled"
            newline
            bitfld.long 0x00 0.--3. "PPSCTRL_PPSCMD,PPS Output Frequency Control This field controls the frequency of the PPS0 output (ptp_pps_o[0]) signal" "0: MCGR operation is not carried out,1: Capture the Presentation time at the rising..,2: Capture the Presentation time at the falling,3: Capture the Presentation time at both edges of,4: STOP Pulse train at time This command stops the,5: STOP Pulse Train immediately This command,6: Cancel STOP Pulse train This command cancels..,?,?,9: Toggle output on compare,10: Pulse output low on compare for one PTP-clock,11: Pulse output high on compare for one PTP-clock,?,?,?,15: The binary rollover is 32.768 KHz and the"
    group.long 0xB80++0x03
        line.long 0x00 "MAC_PPS0_Target_Time_Seconds,The PPS Target Time Seconds register along with PPS Target Time Nanoseconds register is used to schedule an interrupt event [Bit 1 of MAC_Timestamp_Status] when the system time exceeds the value programmed in these registers"
            hexmask.long 0x00 0.--31. 1. "TSTRH0,PPS Target Time Seconds Register This field stores the time in seconds"
    group.long 0xB84++0x03
        line.long 0x00 "MAC_PPS0_Target_Time_Nanoseconds,PPS0 Target Time Nanoseconds register"
            bitfld.long 0x00 31. "TRGTBUSY0,PPS Target Time Register Busy The MAC sets this bit when the PPSCMD0 field in the MAC_PPS_Control register is programmed to 010 or 011" "0: PPS Target Time Register Busy status is not..,1: PPS Target Time Register Busy is detected"
            newline
            hexmask.long 0x00 0.--30. 1. "TTSL0,Target Time Low for PPS Register This register stores the time in (signed) nanoseconds"
    group.long 0xB88++0x03
        line.long 0x00 "MAC_PPS0_Interval,The PPS0 Interval register contains the number of units of sub-second increment value between the rising edges of PPS0 signal output (ptp_pps_o[0])"
            hexmask.long 0x00 0.--31. 1. "PPSINT0,PPS Output Signal Interval These bits store the interval between the rising edges of PPS0 signal output"
    group.long 0xB8C++0x03
        line.long 0x00 "MAC_PPS0_Width,The PPS0 Width register contains the number of units of sub-second increment value between the rising and corresponding falling edges of PPS0 signal output (ptp_pps_o[0])"
            hexmask.long 0x00 0.--31. 1. "PPSWIDTH0,PPS Output Signal Width These bits store the width between the rising edge and corresponding falling edge of PPS0 signal output"
    group.long 0xB90++0x03
        line.long 0x00 "MAC_PPS1_Target_Time_Seconds,The PPS Target Time Seconds register along with PPS Target Time Nanoseconds register is used to schedule an interrupt event [Bit 1 of MAC_Timestamp_Status] when the system time exceeds the value programmed in these registers"
            hexmask.long 0x00 0.--31. 1. "TSTRH1,PPS Target Time Seconds Register This field stores the time in seconds"
    group.long 0xB94++0x03
        line.long 0x00 "MAC_PPS1_Target_Time_Nanoseconds,PPS1 Target Time Nanoseconds register"
            bitfld.long 0x00 31. "TRGTBUSY1,PPS Target Time Register Busy The MAC sets this bit when the PPSCMD1 field in the MAC_PPS_Control register is programmed to 010 or 011" "0: PPS Target Time Register Busy status is not..,1: PPS Target Time Register Busy is detected"
            newline
            hexmask.long 0x00 0.--30. 1. "TTSL1,Target Time Low for PPS Register This register stores the time in (signed) nanoseconds"
    group.long 0xB98++0x03
        line.long 0x00 "MAC_PPS1_Interval,The PPS1 Interval register contains the number of units of sub-second increment value between the rising edges of PPS1 signal output (ptp_pps_o[1])"
            hexmask.long 0x00 0.--31. 1. "PPSINT1,PPS Output Signal Interval These bits store the interval between the rising edges of PPS1 signal output"
    group.long 0xB9C++0x03
        line.long 0x00 "MAC_PPS1_Width,The PPS1 Width register contains the number of units of sub-second increment value between the rising and corresponding falling edges of PPS1 signal output (ptp_pps_o[1])"
            hexmask.long 0x00 0.--31. 1. "PPSWIDTH1,PPS Output Signal Width These bits store the width between the rising edge and corresponding falling edge of PPS1 signal output"
    group.long 0xBA0++0x03
        line.long 0x00 "MAC_PPS2_Target_Time_Seconds,The PPS Target Time Seconds register along with PPS Target Time Nanoseconds register is used to schedule an interrupt event [Bit 1 of MAC_Timestamp_Status] when the system time exceeds the value programmed in these registers"
            hexmask.long 0x00 0.--31. 1. "TSTRH2,PPS Target Time Seconds Register This field stores the time in seconds"
    group.long 0xBA4++0x03
        line.long 0x00 "MAC_PPS2_Target_Time_Nanoseconds,PPS2 Target Time Nanoseconds register"
            bitfld.long 0x00 31. "TRGTBUSY2,PPS Target Time Register Busy The MAC sets this bit when the PPSCMD2 field in the MAC_PPS_Control register is programmed to 010 or 011" "0: PPS Target Time Register Busy status is not..,1: PPS Target Time Register Busy is detected"
            newline
            hexmask.long 0x00 0.--30. 1. "TTSL2,Target Time Low for PPS Register This register stores the time in (signed) nanoseconds"
    group.long 0xBA8++0x03
        line.long 0x00 "MAC_PPS2_Interval,The PPS2 Interval register contains the number of units of sub-second increment value between the rising edges of PPS2 signal output (ptp_pps_o[2])"
            hexmask.long 0x00 0.--31. 1. "PPSINT2,PPS Output Signal Interval These bits store the interval between the rising edges of PPS2 signal output"
    group.long 0xBAC++0x03
        line.long 0x00 "MAC_PPS2_Width,The PPS2 Width register contains the number of units of sub-second increment value between the rising and corresponding falling edges of PPS2 signal output (ptp_pps_o[2])"
            hexmask.long 0x00 0.--31. 1. "PPSWIDTH2,PPS Output Signal Width These bits store the width between the rising edge and corresponding falling edge of PPS2 signal output"
    group.long 0xBB0++0x03
        line.long 0x00 "MAC_PPS3_Target_Time_Seconds,The PPS Target Time Seconds register along with PPS Target Time Nanoseconds register is used to schedule an interrupt event [Bit 1 of MAC_Timestamp_Status] when the system time exceeds the value programmed in these registers"
            hexmask.long 0x00 0.--31. 1. "TSTRH3,PPS Target Time Seconds Register This field stores the time in seconds"
    group.long 0xBB4++0x03
        line.long 0x00 "MAC_PPS3_Target_Time_Nanoseconds,PPS3 Target Time Nanoseconds register"
            bitfld.long 0x00 31. "TRGTBUSY3,PPS Target Time Register Busy The MAC sets this bit when the PPSCMD3 field in the MAC_PPS_Control register is programmed to 010 or 011" "0: PPS Target Time Register Busy status is not..,1: PPS Target Time Register Busy is detected"
            newline
            hexmask.long 0x00 0.--30. 1. "TTSL3,Target Time Low for PPS Register This register stores the time in (signed) nanoseconds"
    group.long 0xBB8++0x03
        line.long 0x00 "MAC_PPS3_Interval,The PPS3 Interval register contains the number of units of sub-second increment value between the rising edges of PPS3 signal output (ptp_pps_o[3])"
            hexmask.long 0x00 0.--31. 1. "PPSINT3,PPS Output Signal Interval These bits store the interval between the rising edges of PPS3 signal output"
    group.long 0xBBC++0x03
        line.long 0x00 "MAC_PPS3_Width,The PPS3 Width register contains the number of units of sub-second increment value between the rising and corresponding falling edges of PPS3 signal output (ptp_pps_o[3])"
            hexmask.long 0x00 0.--31. 1. "PPSWIDTH3,PPS Output Signal Width These bits store the width between the rising edge and corresponding falling edge of PPS3 signal output"
    group.long 0xBC0++0x03
        line.long 0x00 "MAC_PTO_Control,This register controls the PTP Offload Engine operation"
            hexmask.long.word 0x00 16.--31. 1. "Reserved_31_16,Reserved"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "DN,Domain Number This field indicates the domain Number in which the PTP node is operating"
            newline
            bitfld.long 0x00 7. "PDRDIS,Disable Peer Delay Response response generation When this bit is set the Peer Delay Response (Pdelay_Resp) response is not be generated for received Peer Delay Request (Pdelay_Req) request packet as required by the programmed mode" "0: Peer Delay Response response generation is..,1: Peer Delay Response response generation is.."
            newline
            bitfld.long 0x00 6. "DRRDIS,Disable PTO Delay Request/Response response generation When this bit is set the Delay Request and Delay response is not generated for received SYNC and Delay request packet respectively as required by the programmed mode" "0: PTO Delay Request/Response response..,1: PTO Delay Request/Response response.."
            newline
            bitfld.long 0x00 5. "APDREQTRIG,Automatic PTP Pdelay_Req message Trigger When this bit is set one PTP Pdelay_Req message is transmitted" "0: Automatic PTP Pdelay_Req message Trigger is..,1: Automatic PTP Pdelay_Req message Trigger is.."
            newline
            bitfld.long 0x00 4. "ASYNCTRIG,Automatic PTP SYNC message Trigger When this bit is set one PTP SYNC message is transmitted" "0: Automatic PTP SYNC message Trigger is disabled,1: Automatic PTP SYNC message Trigger is enabled"
            newline
            rbitfld.long 0x00 3. "Reserved_3,Reserved" "0,1"
            newline
            bitfld.long 0x00 2. "APDREQEN,Automatic PTP Pdelay_Req message Enable When this bit is set PTP Pdelay_Req message is generated periodically based on interval programmed or trigger from application when the MAC is programmed to be in Peer-to-Peer Transparent mode" "0: Automatic PTP Pdelay_Req message is disabled,1: Automatic PTP Pdelay_Req message is enabled"
            newline
            bitfld.long 0x00 1. "ASYNCEN,Automatic PTP SYNC message Enable When this bit is set PTP SYNC message is generated periodically based on interval programmed or trigger from application when the MAC is programmed to be in Clock Master mode" "0: Automatic PTP SYNC message is disabled,1: Automatic PTP SYNC message is enabled"
            newline
            bitfld.long 0x00 0. "PTOEN,PTP Offload Enable When this bit is set the PTP Offload feature is enabled" "0: PTP Offload feature is disabled,1: PTP Offload feature is enabled"
    group.long 0xBC4++0x03
        line.long 0x00 "MAC_Source_Port_Identity0,This register contains Bits[31:0] of the 80-bit Source Port Identity of the PTP node"
            hexmask.long 0x00 0.--31. 1. "SPI0,Source Port Identity 0 This field indicates bits [31:0] of sourcePortIdentity of PTP node"
    group.long 0xBC8++0x03
        line.long 0x00 "MAC_Source_Port_Identity1,This register contains Bits[63:32] of the 80-bit Source Port Identity of the PTP node"
            hexmask.long 0x00 0.--31. 1. "SPI1,Source Port Identity 1 This field indicates bits [63:32] of sourcePortIdentity of PTP node"
    group.long 0xBCC++0x03
        line.long 0x00 "MAC_Source_Port_Identity2,This register contains Bits[79:64] of the 80-bit Source Port Identity of the PTP node"
            hexmask.long.word 0x00 16.--31. 1. "Reserved_31_16,Reserved"
            newline
            hexmask.long.word 0x00 0.--15. 1. "SPI2,Source Port Identity 2 This field indicates bits [79:64] of sourcePortIdentity of PTP node"
    group.long 0xBD0++0x03
        line.long 0x00 "MAC_Log_Message_Interval,This register contains the periodic intervals for automatic PTP packet generation"
            hexmask.long.byte 0x00 24.--31. 1. "LMPDRI,Log Min Pdelay_Req Interval This field indicates logMinPdelayReqInterval of PTP node"
            newline
            hexmask.long.word 0x00 11.--23. 1. "Reserved_23_11,Reserved"
            newline
            bitfld.long 0x00 8.--10. "DRSYNCR,Delay_Req to SYNC Ratio In Slave mode it is used for controlling frequency of Delay_Req messages transmitted" "0: DelayReq generated for every received SYNC,1: DelayReq generated every alternate reception..,2: for every 4 SYNC messages,3: for every 8 SYNC messages,4: for every 16 SYNC messages,5: for every 32 SYNC messages,?..."
            newline
            hexmask.long.byte 0x00 0.--7. 1. "LSI,Log Sync Interval This field indicates the periodicity of the automatically generated SYNC message when the PTP node is Master"
    group.long 0xC00++0x03
        line.long 0x00 "MTL_Operation_Mode,The Operation Mode register establishes the Transmit and Receive operating modes and commands"
            hexmask.long.word 0x00 16.--31. 1. "Reserved_31_16,Reserved"
            newline
            rbitfld.long 0x00 15. "Reserved_FRPE,Reserved" "0,1"
            newline
            rbitfld.long 0x00 14. "Reserved_RXPED,Reserved" "0,1"
            newline
            rbitfld.long 0x00 10.--13. "Reserved_13_10,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 9. "CNTCLR,Counters Reset When this bit is set all counters are reset" "0: Counters are not reset,1: All counters are reset"
            newline
            bitfld.long 0x00 8. "CNTPRST,Counters Preset When this bit is set - MTL_TxQ[0-7]_Underflow register is initialized/preset to 12'h7F0" "0: Counters Preset is disabled,1: Counters Preset is enabled"
            newline
            rbitfld.long 0x00 7. "Reserved_7,Reserved" "0,1"
            newline
            bitfld.long 0x00 5.--6. "SCHALG,Tx Scheduling Algorithm This field indicates the algorithm for Tx scheduling" "0: WRR algorithm,1: WFQ algorithm when DCB feature is selected,2: DWRR algorithm when DCB feature is selected,3: Strict priority algorithm"
            newline
            rbitfld.long 0x00 3.--4. "Reserved_4_3,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 2. "RAA,Receive Arbitration Algorithm This field is used to select the arbitration algorithm for the Rx side" "0: Strict priority (SP),1: Weighted Strict Priority (WSP)"
            newline
            bitfld.long 0x00 1. "DTXSTS,Drop Transmit Status" "0: Drop Transmit Status is disabled,1: Drop Transmit Status is enabled"
            newline
            rbitfld.long 0x00 0. "Reserved_0,Reserved" "0,1"
    group.long 0xC08++0x03
        line.long 0x00 "MTL_DBG_CTL,The FIFO Debug Access Control and Status register controls the operation mode of FIFO debug access"
            hexmask.long.word 0x00 19.--31. 1. "Reserved_31_19,Reserved"
            newline
            bitfld.long 0x00 18. "EIEC,ECC Inject Error Control for Tx Rx TSO and DCACHE memories When EIEE or EIAEE bit of this register is set following are the errors inserted based on the value encoded in this field" "0: Insert 1 bit error,1: insert 2 bit errors"
            newline
            bitfld.long 0x00 17. "EIAEE,ECC Inject Address Error for Tx Rx TSO and DCACHE memories" "0: Disables the ECC address error injection,1: Enables the ECC address error injection"
            newline
            bitfld.long 0x00 16. "EIEE,ECC Inject Error Enable for Tx Rx TSO and DCACHE memories" "0: ECC Inject Error for Tx Rx TSO and DCACHE..,1: ECC Inject Error for Tx Rx TSO and DCACHE.."
            newline
            bitfld.long 0x00 15. "STSIE,Transmit Status Available Interrupt Status Enable When this bit is set an interrupt is generated when Transmit status is available in slave mode" "0: Transmit Packet Available Interrupt Status is..,1: Transmit Packet Available Interrupt Status is.."
            newline
            bitfld.long 0x00 14. "PKTIE,Receive Packet Available Interrupt Status Enable When this bit is set an interrupt is generated when EOP of received packet is written to the Rx FIFO" "0: Receive Packet Available Interrupt Status is..,1: Receive Packet Available Interrupt Status is.."
            newline
            bitfld.long 0x00 12.--13. "FIFOSEL,FIFO Selected for Access This field indicates the FIFO selected for debug access" "0: Tx FIFO,1: Tx Status FIFO (only read access when SLVMOD..,2: TSO FIFO (cannot be accessed when SLVMOD is..,3: Rx FIFO"
            newline
            bitfld.long 0x00 11. "FIFOWREN,FIFO Write Enable When this bit is set it enables the Write operation on selected FIFO when FIFO Debug Access is enabled" "0: FIFO Write is disabled,1: FIFO Write is enabled"
            newline
            bitfld.long 0x00 10. "FIFORDEN,FIFO Read Enable When this bit is set it enables the Read operation on selected FIFO when FIFO Debug Access is enabled" "0: FIFO Read is disabled,1: FIFO Read is enabled"
            newline
            bitfld.long 0x00 9. "RSTSEL,Reset Pointers of Selected FIFO When this bit is set the pointers of the currently-selected FIFO are reset when FIFO Debug Access is enabled" "0: Reset Pointers of Selected FIFO is disabled,1: Reset Pointers of Selected FIFO is enabled"
            newline
            bitfld.long 0x00 8. "RSTALL,Reset All Pointers When this bit is set the pointers of all FIFOs are reset when FIFO Debug Access is enabled" "0: Reset All Pointers is disabled,1: Reset All Pointers is enabled"
            newline
            rbitfld.long 0x00 7. "Reserved_7,Reserved" "0,1"
            newline
            bitfld.long 0x00 5.--6. "PKTSTATE,Encoded Packet State This field is used to write the control information to the Tx FIFO or Rx FIFO" "0: Packet Data,1: Control Word/Normal Status,2: SOP Data/Last Status,3: EOP Data/EOP"
            newline
            rbitfld.long 0x00 4. "Reserved_4,Reserved" "0,1"
            newline
            bitfld.long 0x00 2.--3. "BYTEEN,Byte Enables This field indicates the number of data bytes valid in the data register during Write operation" "0: Byte 0 valid,1: Byte 0 and Byte 1 are valid,2: Byte 0 Byte 1 and Byte 2 are valid,3: All four bytes are valid"
            newline
            bitfld.long 0x00 1. "DBGMOD,Debug Mode Access to FIFO" "0: Debug Mode Access to FIFO is disabled,1: Debug Mode Access to FIFO is enabled"
            newline
            bitfld.long 0x00 0. "FDBGEN,FIFO Debug Access Enable" "0: FIFO Debug Access through CSR Slave Interface..,1: FIFO Debug Access through CSR Slave Interface.."
    group.long 0xC0C++0x03
        line.long 0x00 "MTL_DBG_STS,The FIFO Debug Status register contains the status of FIFO debug access"
            hexmask.long.tbyte 0x00 15.--31. 1. "LOCR,Remaining Locations in the FIFO - Slave Access Mode: This field indicates the space available in the selected FIFO"
            newline
            rbitfld.long 0x00 10.--14. "Reserved_14_10,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 9. "STSI,Transmit Status Available Interrupt Status When set this bit indicates that the Slave mode Tx packet is transmitted and the status is available in Tx Status FIFO" "0: Transmit Status Available Interrupt Status..,1: Transmit Status Available Interrupt Status.."
            newline
            bitfld.long 0x00 8. "PKTI,Receive Packet Available Interrupt Status When set this bit indicates that MAC layer has written the EOP of received packet to the Rx FIFO" "0: Receive Packet Available Interrupt Status not..,1: Receive Packet Available Interrupt Status.."
            newline
            rbitfld.long 0x00 5.--7. "Reserved_7_5,Reserved" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 3.--4. "BYTEEN,Byte Enables This field indicates the number of data bytes valid in the data register during Read operation" "0: Byte 0 valid,1: Byte 0 and Byte 1 are valid,2: Byte 0 Byte 1 and Byte 2 are valid,3: All four bytes are valid"
            newline
            rbitfld.long 0x00 1.--2. "PKTSTATE,Encoded Packet State This field is used to get the control or status information of the selected FIFO" "0: Packet Data,1: Control Word/Normal Status,2: SOP Data/Last Status,3: EOP Data/EOP"
            newline
            rbitfld.long 0x00 0. "FIFOBUSY,FIFO Busy When set this bit indicates that a FIFO operation is in progress in the MAC and content of the following fields is not valid: - All other fields of this register - All fields of the MTL_FIFO_Debug_Data register" "0: FIFO Busy not detected,1: FIFO Busy detected"
    group.long 0xC10++0x03
        line.long 0x00 "MTL_FIFO_Debug_Data,The FIFO Debug Data register contains the data to be written to or read from the FIFOs"
            hexmask.long 0x00 0.--31. 1. "FDBGDATA,FIFO Debug Data During debug or slave access write operation this field contains the data to be written to the Tx FIFO Rx FIFO or TSO FIFO"

    rgroup.long 0xC20++0x03
        line.long 0x00 "MTL_Interrupt_Status,The software driver (application) reads this register during interrupt service routine or polling to determine the interrupt status of MTL queues and the MAC"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_31_24,Reserved"
            newline
            bitfld.long 0x00 23. "Reserved_MTLPIS,Reserved" "0,1"
            newline
            bitfld.long 0x00 19.--22. "Reserved_22_19,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 18. "ESTIS,EST (TAS- 802.1Qbv) Interrupt Status This bit indicates an interrupt event during the operation of 802.1Qbv" "0: EST (TAS- 802.1Qbv) Interrupt status not..,1: EST (TAS- 802.1Qbv) Interrupt status detected"
            newline
            bitfld.long 0x00 17. "DBGIS,Debug Interrupt status This bit indicates an interrupt event during the slave access" "0: Debug Interrupt status not detected,1: Debug Interrupt status detected"
            newline
            bitfld.long 0x00 16. "Reserved_MACIS,Reserved" "0,1"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "Reserved_15_8,Reserved"
            newline
            bitfld.long 0x00 7. "Reserved_Q7IS,Reserved" "0,1"
            newline
            bitfld.long 0x00 6. "Reserved_Q6IS,Reserved" "0,1"
            newline
            bitfld.long 0x00 5. "Reserved_Q5IS,Reserved" "0,1"
            newline
            bitfld.long 0x00 4. "Reserved_Q4IS,Reserved" "0,1"
            newline
            bitfld.long 0x00 3. "Reserved_Q3IS,Reserved" "0,1"
            newline
            bitfld.long 0x00 2. "Q2IS,Queue 2 Interrupt status This bit indicates that there is an interrupt from Queue 2" "0: Queue 2 Interrupt status not detected,1: Queue 2 Interrupt status detected"
            newline
            bitfld.long 0x00 1. "Q1IS,Queue 1 Interrupt status This bit indicates that there is an interrupt from Queue 1" "0: Queue 1 Interrupt status not detected,1: Queue 1 Interrupt status detected"
            newline
            bitfld.long 0x00 0. "Q0IS,Queue 0 Interrupt status This bit indicates that there is an interrupt from Queue 0" "0: Queue 0 Interrupt status not detected,1: Queue 0 Interrupt status detected"

    group.long 0xC30++0x03
        line.long 0x00 "MTL_RxQ_DMA_Map0,This register controls the Dynamic (per packet) or Static (all packets in a Receive Queue) DMA Channel Selection for lower numbered Receive Queues"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 28. "Reserved_Q3DDMACH,Reserved" "0,1"
            newline
            rbitfld.long 0x00 25.--27. "Reserved_27_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 24. "Reserved_Q3MDMACH,Reserved" "0,1"
            newline
            rbitfld.long 0x00 21.--23. "Reserved_23_21,Reserved" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 20. "Reserved_Q2DDMACH,Reserved" "0,1"
            newline
            rbitfld.long 0x00 17.--19. "Reserved_19_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 16. "Reserved_Q2MDMACH,Reserved" "0,1"
            newline
            rbitfld.long 0x00 13.--15. "Reserved_15_13,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 12. "Q1DDMACH,Queue 1 Enabled for DA-based DMA Channel Selection When set this bit indicates that the packets received in Queue 1 are routed to a particular DMA channel as decided in the MAC Receiver based on the DMA channel number programmed in the L3-L4.." "0: Queue 1 disabled for DA-based DMA Channel..,1: Queue 1 enabled for DA-based DMA Channel.."
            newline
            rbitfld.long 0x00 9.--11. "Reserved_11_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 8. "Q1MDMACH,Queue 1 Mapped to DMA Channel This field controls the routing of the received packet in Queue 1 to the DMA channel" "0: DMA Channel,1: DMA Channel 1Reserved"
            newline
            rbitfld.long 0x00 5.--7. "Reserved_7_5,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 4. "Q0DDMACH,Queue 0 Enabled for DA-based DMA Channel Selection When set this bit indicates that the packets received in Queue 0 are routed to a particular DMA channel as decided in the MAC Receiver based on the DMA channel number programmed in the L3-L4.." "0: Queue 0 disabled for DA-based DMA Channel..,1: Queue 0 enabled for DA-based DMA Channel.."
            newline
            rbitfld.long 0x00 1.--3. "Reserved_3_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0. "Q0MDMACH,Queue 0 Mapped to DMA Channel This field controls the routing of the packet received in Queue 0 to the DMA channel" "0: DMA Channel,1: DMA Channel 1Reserved"
    group.long 0xC40++0x03
        line.long 0x00 "MTL_TBS_CTRL,This register controls the operation of Time Based Scheduling"
            hexmask.long.tbyte 0x00 8.--31. 1. "LEOS,Launch Expiry Offset The value in units of 256 nanoseconds that has to be added to the Launch time to compute the Launch Expiry time"
            newline
            rbitfld.long 0x00 7. "Reserved_7,Reserved" "0,1"
            newline
            bitfld.long 0x00 4.--6. "LEGOS,Launch Expiry GSN Offset The number GSN slots that has to be added to the Launch GSN to compute the Launch Expiry time" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 2.--3. "Reserved_3_2,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 1. "LEOV,Launch Expiry Offset Valid When set indicates the LEOS field is valid" "0: LEOS field is invalid,1: LEOS field is valid"
            newline
            bitfld.long 0x00 0. "ESTM,EST offset Mode" "0: EST offset Mode is disabled,1: EST offset Mode is enabled"
    group.long 0xC50++0x03
        line.long 0x00 "MTL_EST_Control,This register controls the operation of Enhancements to Scheduled Transmission (IEEE802.1Qbv)"
            hexmask.long.byte 0x00 24.--31. 1. "PTOV,PTP Time Offset Value The value of PTP Clock period multiplied by 9 in nanoseconds"
            newline
            hexmask.long.word 0x00 12.--23. 1. "CTOV,Current Time Offset Value Provides a 12 bit time offset value in nano second that is added to the current time to compensate for all the implementation pipeline delays such as the CDC sync delay buffering delays data path delays and so on"
            newline
            rbitfld.long 0x00 11. "Reserved_11,Reserved" "0,1"
            newline
            bitfld.long 0x00 8.--10. "TILS,Time Interval Left Shift Amount This field provides the left shift amount for the programmed Time Interval values used in the Gate Control Lists" "0: No left shift needed (equal to x1ns),1: Left shift TI by 1 bit (equal to x2ns),2: Left shift TI by 2 bits (equal to x4ns),?,4: Left shift TI by 7 bits (equal to x128ns),?..."
            newline
            bitfld.long 0x00 6.--7. "LCSE,Loop Count to report Scheduling Error Programmable number of GCL list iterations before reporting an HLBS error defined in EST_Status register" "0: 4 iterations,1: 8 iterations,2: 16 iterations,3: 32 iterations"
            newline
            bitfld.long 0x00 5. "DFBS,Drop Frames causing Scheduling Error When set frames reported to cause HOL Blocking due to not getting scheduled (HLBS field of EST_Status register) after 4 8 16 32 (based on LCSE field of this register) GCL iterations are dropped" "0: Do not Drop Frames causing Scheduling Error,1: Drop Frames causing Scheduling Error"
            newline
            bitfld.long 0x00 4. "DDBF,Do not Drop frames during Frame Size Error When set frames are not be dropped during Head-of-Line blocking due to Frame Size Error (HLBF field of EST_Status register)" "0: Drop frames during Frame Size Error,1: Do not Drop frames during Frame Size Error"
            newline
            bitfld.long 0x00 3. "QHLBF,Quick Assertion of HLBF Error When set Time Window for Head-of-Line blocking due to Frame Size Error is 1 to 2 loop count of GCL list.On reset Time Window for Head-of-Line blocking due to Frame Size Error is 2 to 3 loop counts of GCL list" "0: Disable Quick assertion of HLBF error,1: Quick Assertion of HLBF Error"
            newline
            rbitfld.long 0x00 2. "Reserved_2,Reserved" "0,1"
            newline
            bitfld.long 0x00 1. "SSWL,Switch to S/W owned list When set indicates that the software has programmed that list that it currently owns (SWOL) and the HW must switch to the new list based on the new BTR" "0: Switch to S/W owned list is disabled,1: Switch to S/W owned list is enabled"
            newline
            bitfld.long 0x00 0. "EEST,Enable EST When reset the gate control list processing is halted and all gates are assumed to be in Open state" "0: EST is disabled,1: EST is enabled"
    group.long 0xC54++0x03
        line.long 0x00 "MTL_EST_Ext_Control,This register indicates the number of Overhead bytes for EST related scheduling"
            hexmask.long 0x00 6.--31. 1. "Reserved_31_6,Reserved"
            newline
            bitfld.long 0x00 0.--5. "OVHD,Overhead Bytes Value This field indicates the fixed overhead for every packet to account for EST Scheduler Delay IPG or EIPG and Preamble bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
    group.long 0xC58++0x03
        line.long 0x00 "MTL_EST_Status,This register provides Status related to Enhancements to Scheduled Transmission (IEEE802.1Qbv)"
            hexmask.long.word 0x00 20.--31. 1. "Reserved_31_20,Reserved"
            newline
            rbitfld.long 0x00 16.--19. "CGSN,Current GCL Slot Number Indicates the slot number of the GCL list" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "BTRL,BTR Error Loop Count Provides the minimum count (N) for which the equation Current Time =< New BTR + (N * New Cycle Time) becomes true"
            newline
            rbitfld.long 0x00 7. "SWOL,S/W owned list When '0' indicates Gate control list number 0 is owned by software and when 1 indicates the Gate Control list 1 is owned by the software" "0: Gate control list number 0 is owned by software,1: Gate control list number 1 is owned by software"
            newline
            rbitfld.long 0x00 5.--6. "Reserved_6_5,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 4. "CGCE,Constant Gate Control Error This error occurs when the list length (LLR) is 1 and the Cycle Time (CTR) is less than or equal to the programmed Time Interval (TI) value after the optional Left Shifting" "0: Constant Gate Control Error not detected,1: Constant Gate Control Error detected"
            newline
            rbitfld.long 0x00 3. "HLBS,Head-Of-Line Blocking due to Scheduling Set when the frame is not able to win arbitration and get scheduled even after 4 iterations of the GCL" "0: Head-Of-Line Blocking due to Scheduling not..,1: Head-Of-Line Blocking due to Scheduling.."
            newline
            rbitfld.long 0x00 2. "HLBF,Head-Of-Line Blocking due to Frame Size Set when HOL Blocking is noticed on one or more Queues as a result of none of the Time Intervals of gate open in the GCL being greater than or equal to the duration needed for frame size (or frame fragment.." "0: Head-Of-Line Blocking due to Frame Size not..,1: Head-Of-Line Blocking due to Frame Size.."
            newline
            bitfld.long 0x00 1. "BTRE,BTR Error When 1 indicates a programming error in the BTR of SWOL where the programmed value is less than current time" "0: BTR Error not detected,1: BTR Error detected"
            newline
            bitfld.long 0x00 0. "SWLC,Switch to S/W owned list Complete When 1 indicates the hardware has successfully switched to the SWOL and the SWOL bit has been updated to that effect" "0: Switch to S/W owned list Complete not detected,1: Switch to S/W owned list Complete detected"
    group.long 0xC60++0x03
        line.long 0x00 "MTL_EST_Sch_Error,This register provides the One Hot encoded Queue Numbers that are having the Scheduling related error (timeout)"
            hexmask.long 0x00 3.--31. 1. "Reserved_31_x,Reserved"
            newline
            bitfld.long 0x00 0.--2. "SEQN,Schedule Error Queue Number The One Hot Encoded Queue Numbers that have experienced error/timeout described in HLBS field of status register" "0,1,2,3,4,5,6,7"
    group.long 0xC64++0x03
        line.long 0x00 "MTL_EST_Frm_Size_Error,This register provides the One Hot encoded Queue Numbers that are having the Frame Size related error"
            hexmask.long 0x00 3.--31. 1. "Reserved_31_x,Reserved"
            newline
            bitfld.long 0x00 0.--2. "FEQN,Frame Size Error Queue Number The One Hot Encoded Queue Numbers that have experienced error described in HLBF field of status register" "0,1,2,3,4,5,6,7"

    rgroup.long 0xC68++0x03
        line.long 0x00 "MTL_EST_Frm_Size_Capture,This register captures the Frame Size and Queue Number of the first occurrence of the Frame Size related error"
            hexmask.long.word 0x00 18.--31. 1. "Reserved_31_x,Reserved"
            newline
            bitfld.long 0x00 16.--17. "HBFQ,Queue Number of HLBF Captures the binary value of the of the first Queue (number) experiencing HLBF error (see HLBF field of status register)" "0,1,2,3"
            newline
            bitfld.long 0x00 15. "Reserved_15,Reserved" "0,1"
            newline
            hexmask.long.word 0x00 0.--14. 1. "HBFS,Frame Size of HLBF Captures the Frame Size of the dropped frame related to queue number indicated in HBFQ field of this register"

    group.long 0xC70++0x03
        line.long 0x00 "MTL_EST_Intr_Enable,This register implements the Interrupt Enable bits for the various events that generate an interrupt"
            hexmask.long 0x00 5.--31. 1. "Reserved_31_5,Reserved"
            newline
            bitfld.long 0x00 4. "CGCE,Interrupt Enable for CGCE When set generates interrupt when the Constant Gate Control Error occurs and is indicated in the status" "0: Interrupt for CGCE is disabled,1: Interrupt for CGCE is enabled"
            newline
            bitfld.long 0x00 3. "IEHS,Interrupt Enable for HLBS When set generates interrupt when the Head-of-Line Blocking due to Scheduling issue and is indicated in the status" "0: Interrupt for HLBS is disabled,1: Interrupt for HLBS is enabled"
            newline
            bitfld.long 0x00 2. "IEHF,Interrupt Enable for HLBF When set generates interrupt when the Head-of-Line Blocking due to Frame Size error occurs and is indicated in the status" "0: Interrupt for HLBF is disabled,1: Interrupt for HLBF is enabled"
            newline
            bitfld.long 0x00 1. "IEBE,Interrupt Enable for BTR Error When set generates interrupt when the BTR Error occurs and is indicated in the status" "0: Interrupt for BTR Error is disabled,1: Interrupt for BTR Error is enabled"
            newline
            bitfld.long 0x00 0. "IECC,Interrupt Enable for Switch List When set generates interrupt when the configuration change is successful and the hardware has switched to the new list" "0: Interrupt for Switch List is disabled,1: Interrupt for Switch List is enabled"
    group.long 0xC80++0x03
        line.long 0x00 "MTL_EST_GCL_Control,This register provides the control information for reading/writing to the Gate Control lists"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_31_24,Reserved"
            newline
            bitfld.long 0x00 23. "ESTEIEC,ECC Inject Error Control for EST Memory When ESTEIEE or ESTEIAEE bit of this register is set following are the errors inserted based on the value encoded in this field" "0: Insert 1 bit error,1: Insert 2 bit errors"
            newline
            bitfld.long 0x00 22. "ESTEIAEE,EST ECC Inject Address Error Enable When set along with EEST bit of MTL_EST_Control register enables the ECC address error injection feature" "0: EST ECC Inject Address Error is disabled,1: EST ECC Inject Address Error is enabled"
            newline
            bitfld.long 0x00 21. "ESTEIEE,EST ECC Inject Error Enable When set along with EEST bit of MTL_EST_Control register enables the ECC error injection feature" "0: EST ECC Inject Error is disabled,1: EST ECC Inject Error is enabled"
            newline
            rbitfld.long 0x00 17.--20. "Reserved_20_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            abitfld.long 0x00 8.--16. "ADDR,Gate Control List Address: (ADDR when GCRR is 0 )" "0x000=0: BTR Low (31:0),0x001=1: BTR High (63:31),0x00A=10: CTR Low (31:0),0x00B=11: CTR High (39:32),0x064=100: TER (22:0)(26:0)(30:0),0x065=101: LLR (5:0)(6:0)(7:0)(8:0)(9:0) -.."
            newline
            bitfld.long 0x00 6.--7. "Reserved_7_6,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 5. "DBGB,Debug Mode Bank Select When set to 0 indicates R/W in debug mode must be directed to Bank 0 (GCL0 and corresponding Time related registers)" "0: R/W in debug mode should be directed to Bank 0,1: R/W in debug mode should be directed to Bank 1"
            newline
            bitfld.long 0x00 4. "DBGM,Debug Mode When set to 1 indicates R/W in debug mode where the memory bank (for GCL and Time related registers) is explicitly provided by DBGB value when set to 0 SWOL bit is used to determine which bank to use" "0: Debug Mode is disabled,1: Debug Mode is enabled"
            newline
            bitfld.long 0x00 3. "Reserved_3,Reserved" "0,1"
            newline
            bitfld.long 0x00 2. "GCRR,Gate Control Related Registers When set to 1 indicates the R/W access is for the GCL related registers (BTR CTR TER LLR) whose address is provided by ADDR" "0: Gate Control Related Registers are disabled,1: Gate Control Related Registers are enabled"
            newline
            bitfld.long 0x00 1. "R1W0,Read '1' Write '0'" "0: Write Operation,1: Read Operation"
            newline
            bitfld.long 0x00 0. "SRWO,Start Read or Write Operation" "0: Start Read/Write Op disabled,1: Start Read/Write Op enabled"
    group.long 0xC84++0x03
        line.long 0x00 "MTL_EST_GCL_Data,This register holds the read data or write data in case of reads and writes respectively"
            hexmask.long 0x00 0.--31. 1. "GCD,Gate Control Data The data corresponding to the address selected in the GCL_Control register"
    group.long 0xCC0++0x03
        line.long 0x00 "MTL_ECC_Control,The MTL_ECC_Control register establishes the operating mode of ECC related to MTL memories"
            hexmask.long.tbyte 0x00 9.--31. 1. "Reserved_31_9,Reserved"
            newline
            bitfld.long 0x00 8. "MEEAO,MTL ECC Error Address Status Over-ride" "0: MTL ECC Error Address Status Over-ride is..,1: MTL ECC Error Address Status Over-ride is.."
            newline
            rbitfld.long 0x00 6.--7. "Reserved_7_6,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 5. "DSCEE,DCACHE memory ECC Enable" "0: DCACHE memory ECC is disabled,1: DCACHE memory ECC is enabled"
            newline
            bitfld.long 0x00 4. "TSOEE,TSO memory ECC Enable" "0: TSO memory ECC is disabled,1: TSO memory ECC is enabled"
            newline
            rbitfld.long 0x00 3. "Reserved_MRXPEE,Reserved" "0,1"
            newline
            bitfld.long 0x00 2. "MESTEE,MTL EST ECC Enable" "0: MTL EST ECC is disabled,1: MTL EST ECC is enabled"
            newline
            bitfld.long 0x00 1. "MRXEE,MTL Rx FIFO ECC Enable" "0: MTL Rx FIFO ECC is disabled,1: MTL Rx FIFO ECC is enabled"
            newline
            bitfld.long 0x00 0. "MTXEE,MTL Tx FIFO ECC Enable" "0: MTL Tx FIFO ECC is disabled,1: MTL Tx FIFO ECC is enabled"

    rgroup.long 0xCC4++0x03
        line.long 0x00 "MTL_Safety_Interrupt_Status,The MTL_Safety_Interrupt_Status registers provides Safety interrupt status"
            bitfld.long 0x00 31. "Reserved_MCSIS,Reserved" "0: MAC Safety Uncorrectable Interrupt Status not..,1: MAC Safety Uncorrectable Interrupt Status.."
            newline
            hexmask.long 0x00 2.--30. 1. "Reserved_30_2,Reserved"
            newline
            bitfld.long 0x00 1. "MEUIS,MTL ECC Uncorrectable error Interrupt Status This bit indicates that an uncorrectable error interrupt event in the MTL ECC safety feature" "0: MTL ECC Uncorrectable error Interrupt Status..,1: MTL ECC Uncorrectable error Interrupt Status.."
            newline
            bitfld.long 0x00 0. "MECIS,MTL ECC Correctable error Interrupt Status This bit indicates that a correctable error interrupt event in the MTL ECC safety feature" "0: MTL ECC Correctable error Interrupt Status..,1: MTL ECC Correctable error Interrupt Status.."

    group.long 0xCC8++0x03
        line.long 0x00 "MTL_ECC_Interrupt_Enable,The MTL_ECC_Interrupt_Enable register provides enable bits for the ECC interrupts"
            hexmask.long.tbyte 0x00 13.--31. 1. "Reserved_31_13,Reserved"
            newline
            rbitfld.long 0x00 12. "Reserved_RPCEIE,Reserved" "0,1"
            newline
            rbitfld.long 0x00 9.--11. "Reserved_11_9,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 8. "ECEIE,EST memory Correctable Error Interrupt Enable When set generates an interrupt when a correctable error is detected at the MTL EST memory interface" "0: EST memory Correctable Error Interrupt is..,1: EST memory Correctable Error Interrupt is.."
            newline
            rbitfld.long 0x00 5.--7. "Reserved_7_5,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 4. "RXCEIE,Rx memory Correctable Error Interrupt Enable When set generates an interrupt when a correctable error is detected at the MTL Rx memory interface" "0: Rx memory Correctable Error Interrupt is..,1: Rx memory Correctable Error Interrupt is.."
            newline
            rbitfld.long 0x00 1.--3. "Reserved_3_1,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0. "TXCEIE,Tx memory Correctable Error Interrupt Enable When set generates an interrupt when a correctable error is detected at the MTL Tx memory interface" "0: Tx memory Correctable Error Interrupt is..,1: Tx memory Correctable Error Interrupt is.."
    group.long 0xCCC++0x03
        line.long 0x00 "MTL_ECC_Interrupt_Status,The MTL_ECC_Interrupt_Status register provides MTL ECC Interrupt Status"
            hexmask.long.tbyte 0x00 15.--31. 1. "Reserved_31_15,Reserved"
            newline
            rbitfld.long 0x00 14. "Reserved_RPUES,Reserved" "0,1"
            newline
            rbitfld.long 0x00 13. "Reserved_RPAMS,Reserved" "0,1"
            newline
            rbitfld.long 0x00 12. "Reserved_RPCES,Reserved" "0,1"
            newline
            rbitfld.long 0x00 11. "Reserved_11,Reserved" "0,1"
            newline
            bitfld.long 0x00 10. "EUES,MTL EST memory Uncorrectable Error Status When set indicates that an uncorrectable error is detected at MTL EST memory interface" "0: MTL EST memory Uncorrectable Error Status not..,1: MTL EST memory Uncorrectable Error Status.."
            newline
            bitfld.long 0x00 9. "EAMS,MTL EST memory Address Mismatch Status This bit when set indicates that address mismatch is found for address bus of MTL EST memory" "0: MTL EST memory Address Mismatch Status not..,1: MTL EST memory Address Mismatch Status detected"
            newline
            bitfld.long 0x00 8. "ECES,MTL EST memory Correctable Error Status This bit when set indicates that correctable error is detected at the MTL EST memory" "0: MTL EST memory Correctable Error Status not..,1: MTL EST memory Correctable Error Status.."
            newline
            rbitfld.long 0x00 7. "Reserved_7,Reserved" "0,1"
            newline
            bitfld.long 0x00 6. "RXUES,MTL Rx memory Uncorrectable Error Status When set indicates that an uncorrectable error is detected at the MTL Rx memory interface" "0: MTL Rx memory Uncorrectable Error Status not..,1: MTL Rx memory Uncorrectable Error Status.."
            newline
            bitfld.long 0x00 5. "RXAMS,MTL Rx memory Address Mismatch Status This bit when set indicates that address mismatch is found for address bus of the MTL Rx memory" "0: MTL Rx memory Address Mismatch Status not..,1: MTL Rx memory Address Mismatch Status detected"
            newline
            bitfld.long 0x00 4. "RXCES,MTL Rx memory Correctable Error Status This bit when set indicates that correctable error is detected at the MTL Rx memory" "0: MTL Rx memory correctable Error Status not..,1: MTL Rx memory correctable Error Status detected"
            newline
            rbitfld.long 0x00 3. "Reserved_3,Reserved" "0,1"
            newline
            bitfld.long 0x00 2. "TXUES,MTL Tx memory Uncorrectable Error Status When set indicates that an uncorrectable error is detected at the MTL TX memory interface" "0: MTL Tx memory Uncorrectable Error Status not..,1: MTL Tx memory Uncorrectable Error Status.."
            newline
            bitfld.long 0x00 1. "TXAMS,MTL Tx memory Address Mismatch Status This bit when set indicates that address mismatch is found for address bus of the MTL Tx memory" "0: MTL Tx memory Address Mismatch Status not..,1: MTL Tx memory Address Mismatch Status detected"
            newline
            bitfld.long 0x00 0. "TXCES,MTL Tx memory Correctable Error Status This bit when set indicates that a correctable error is detected at the MTL Tx memory" "0: MTL Tx memory Correctable Error Status not..,1: MTL Tx memory Correctable Error Status detected"
    group.long 0xCD0++0x03
        line.long 0x00 "MTL_ECC_Err_Sts_Rctl,The MTL_ECC_Err_Sts_Rctl register establishes the control for ECC Error status capture"
            hexmask.long 0x00 6.--31. 1. "Reserved_31_6,Reserved"
            newline
            bitfld.long 0x00 5. "CUES,Clear Uncorrectable Error Status When this bit is set along with EESRE bit of this register based on the EMS field of this register the respective memory's uncorrectable error address and uncorrectable error count values are cleared upon reading" "0: Clear Uncorrectable Error Status not detected,1: Clear Uncorrectable Error Status detected"
            newline
            bitfld.long 0x00 4. "CCES,Clear Correctable Error Status When this bit is set along with EESRE bit of this register based on the EMS field of this register the respective memory's correctable error address and correctable error count values are cleared upon reading" "0: Clear Correctable Error Status not detected,1: Clear Correctable Error Status detected"
            newline
            bitfld.long 0x00 1.--3. "EMS,MTL ECC Memory Selection When EESRE bit of this register is set this field indicates which memory's error status value to be read" "0: MTL Tx memory,1: MTL Rx memory,2: MTL EST memory,3: MTL Rx Parser memory,4: DMA TSO memory,5: DMA DCACHE memory,?..."
            newline
            bitfld.long 0x00 0. "EESRE,MTL ECC Error Status Read Enable When this bit is set based on the EMS field of this register the respective memory's error status values are captured as described: - The correctable and uncorrectable error count values are captured into.." "0: MTL ECC Error Status Read is disabled,1: MTL ECC Error Status Read is enabled"

    rgroup.long 0xCD4++0x03
        line.long 0x00 "MTL_ECC_Err_Addr_Status,The MTL_ECC_Err_Addr_Status register provides the memory addresses for the correctable and uncorrectable errors"
            abitfld.long 0x00 16.--31. "EUEAS,MTL ECC Uncorrectable Error Address Status Based on the EMS field of MTL_ECC_Err_Sts_Rctl register this field holds the respective memory's address locations for which an uncorrectable error or address mismatch is detected" "0x0000=0: This field holds the first address of..,0x0001=1: This field holds the last valid.."
            newline
            abitfld.long 0x00 0.--15. "ECEAS,MTL ECC Correctable Error Address Status Based on the EMS field of MTL_ECC_Err_Sts_Rctl register this field holds the respective memory's address locations for which a correctable error is detected" "0x0000=0: This field holds the first address of..,0x0001=1: This field holds the last valid.."
    rgroup.long 0xCD8++0x03
        line.long 0x00 "MTL_ECC_Err_Cntr_Status,The MTL_ECC_Err_Cntr_Status register provides ECC Error count for Correctable and uncorrectable errors"
            hexmask.long.word 0x00 20.--31. 1. "Reserved_31_20,Reserved"
            newline
            bitfld.long 0x00 16.--19. "EUECS,MTL ECC Uncorrectable Error Counter Status Based on the EMS field of MTL_ECC_Err_Cntr_Rctl register this field holds the respective memory's uncorrectable error count value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "Reserved_15_8,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "ECECS,MTL ECC Correctable Error Counter Status Based on the EMS field of MTL_ECC_Err_Cntr_Rctl register this field holds the respective memory's correctable error count value"

    group.long 0xCE0++0x03
        line.long 0x00 "MTL_DPP_Control,The MTL_DPP_Control establishes the operating mode of Data Parity protection and error injection"
            hexmask.long.word 0x00 17.--31. 1. "Reserved_31_17,Reserved"
            newline
            bitfld.long 0x00 16. "IPEDC,Insert Parity Error in DCACHE parity checker When set to 1 parity/data bit of first valid input parity/data of the DMA DCACHE parity checker (or at PC-dbg as shown in DCACHE parity protection diagram) is flipped" "0: Insert Parity Error in DCACHE parity checker..,1: Insert Parity Error in DCACHE Header parity.."
            newline
            bitfld.long 0x00 15. "IPEMRWC,Insert Parity error in MTL RWC data parity checker When set to 1 parity/data bit of first valid input parity/data of the MTL RWC data parity checker (or at PC12 as shown in Recieve data path parity protection diagram) is flipped" "0: Insert Parity error in MTL RWC data parity..,1: Insert Parity error in MTL RWC data parity.."
            newline
            bitfld.long 0x00 14. "IPEMTFC,Insert Parity error in MAC TFC data parity checker When set to 1 parity/data bit of first valid input parity/data of the MAC TFC data parity checker (or at PC11 as shown in Transmit Data path parity protection diagram) is flipped" "0: Insert Parity error in MAC TFC data parity..,1: Insert Parity error in MAC TFC data parity.."
            newline
            bitfld.long 0x00 13. "IPEMTBU,Insert Parity error in MAC TBU data parity checker When set to 1 parity/data bit of first valid input parity/data of the MAC TBU data parity checker (or at PC10 as shown in Transmit data path parity protection diagram) is flipped" "0: Insert Parity error in MAC TBU data parity..,1: Insert Parity error in MAC TBU data parity.."
            newline
            rbitfld.long 0x00 12. "Reserved_IPEASR,Reserved" "0,1"
            newline
            rbitfld.long 0x00 11. "Reserved_IPEMSW,Reserved" "0,1"
            newline
            bitfld.long 0x00 10. "IPEASW,Insert Parity error in AXI Slave Write data parity checker When set to 1 parity/data bit of first valid input parity/data of the AXI Slave Write data parity checker(or at PC7 as shown in AXI slave Interface Data path protection diagram) is flipped" "0: Insert Parity error in AXI slave write data..,1: Insert Parity error in AXI slave write data.."
            newline
            bitfld.long 0x00 9. "IPERID,Insert Parity Error in RX Interface Data parity checker When set to 1 parity/data bit of first valid input parity/data of the RX Interface Data parity checker is (or at PC6 as shown in Receive data path parity protection diagram) flipped" "0: Insert Parity Error in Rx Interface Data..,1: Insert Parity Error in Rx Interface Data.."
            newline
            bitfld.long 0x00 8. "IPEMTS,Insert Parity Error in MTL Tx Status FIFO parity checker When set to 1 parity/data bit of first valid input parity/data of the MTL Tx Status FIFO parity checker (or at PC5 as shown in Transmit data path parity protection diagram) is flipped" "0: Insert Parity Error in MTL TX Status FIFO..,1: Insert Parity Error in MTL TX Status FIFO.."
            newline
            bitfld.long 0x00 7. "IPEMTF,Insert Parity Error in MTL Tx FIFO write data parity checker When set to 1 parity/data bit of first valid input parity/data of the MTL Tx FIFO write data parity checker (or at PC4 as shown in Transmit data path parity protection diagram) is flipped" "0: Insert Parity Error in MTL Tx FIFO write data..,1: Insert Parity Error in MTL Tx FIFO write data.."
            newline
            bitfld.long 0x00 6. "IPETRD,Insert Parity Error in DMA Tx/Rx Descriptor parity checker When set to 1 parity/data bit of first valid input parity/data of the DMA Tx/Rx Descriptor parity checker (or at PC3 as shown in Transmit data path parity protection diagram) is flipped" "0: Insert Parity Error in DMA Tx/Rx Descriptor..,1: Insert Parity Error in DMA Tx/Rx Descriptor.."
            newline
            bitfld.long 0x00 5. "IPETH,Insert Parity Error in DMA TSO header parity checker When set to 1 parity/data bit of first valid input parity/data of the DMA TSO header parity checker (or at PC2 as shown in Transmit data path parity protection diagram) is flipped" "0: Insert Parity Error in DMA TSO Header parity..,1: Insert Parity Error in DMA TSO Header parity.."
            newline
            bitfld.long 0x00 4. "IPETID,Insert Parity Error in Tx Interface Data parity checker When set to 1 parity/data bit of first valid input parity/data of the Tx Interface data parity checker(or at PC1 as shown in Transmit data path parity protection diagram) is flipped" "0: Insert Parity Error in Tx Interface Data..,1: Insert Parity Error in Tx Interface Data.."
            newline
            rbitfld.long 0x00 3. "Reserved_3,Reserved" "0,1"
            newline
            bitfld.long 0x00 2. "EPSI,Enable Parity on Slave Interface port When set to 1 enables the parity check for the slave interface ports and disables the internal generation of parity for the input slave data port" "0: Parity on Slave Interface port is disabled,1: Parity on Slave Interface port is enabled"
            newline
            bitfld.long 0x00 1. "OPE,Odd Parity Enable When set to 1 enables odd parity protection on all the external interfaces and when set to 0 enables even parity protection on all the external interfaces" "0: Odd Parity is disabled,1: Odd Parity is enabled"
            newline
            bitfld.long 0x00 0. "EDPP,Enable Data path Parity Protection When set to 1 enables the parity protection for EQOS datapath by generating and checking the parity on EQOS datapath" "0: Data path Parity Protection is disabled,1: Data path Parity Protection is enabled"
    group.long 0xCE4++0x03
        line.long 0x00 "MTL_DPP_ECC_EIC,The MTL_DPP_ECC_EIC establishes the operating mode of ECC/DPP error injection"
            hexmask.long.word 0x00 17.--31. 1. "Reserved_31_17,Reserved"
            newline
            bitfld.long 0x00 16. "EIM,Error Injection Mode" "0: Indicate error injection on data,1: Indicate error injection on ECC/Parity bits"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "Reserved_15_8,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "BLEI,Bit Location of error injection This field indicates the bit location of DPP/ECC error injection determination of error in Parity/ECC bits or Data (being protected) depends on the Error Injection Mode (EIM field)"
    group.long 0xD00++0x03
        line.long 0x00 "MTL_TxQ0_Operation_Mode,The Queue 0 Transmit Operation Mode register establishes the Transmit queue operating modes and commands"
            hexmask.long.word 0x00 20.--31. 1. "Reserved_31_y,Reserved"
            newline
            bitfld.long 0x00 16.--19. "TQS,Transmit Queue Size This field indicates the size of the allocated Transmit queues in blocks of 256 bytes the reset value is 0x0 and indicates size of 256 bytes" "0: 256 bytes,1: 512 bytes and so on,?..."
            newline
            hexmask.long.word 0x00 7.--15. 1. "Reserved_15_7,Reserved"
            newline
            bitfld.long 0x00 4.--6. "TTC,Transmit Threshold Control These bits control the threshold level of the MTL Tx Queue" "0: M_32BYTES,1: M_64BYTES,2: M_96BYTES,3: M_128BYTES,4: M_192BYTES,5: M_256BYTES,6: M_384BYTES,7: M_512BYTES"
            newline
            bitfld.long 0x00 2.--3. "TXQEN,Transmit Queue Enable This field is used to enable/disable the transmit queue 0" "0: Not enabled,1: Enable in AV mode,2: Enabled,?..."
            newline
            bitfld.long 0x00 1. "TSF,Transmit Store and Forward When this bit is set the transmission starts when a full packet resides in the MTL Tx queue" "0: Transmit Store and Forward is disabled,1: Transmit Store and Forward is enabled"
            newline
            bitfld.long 0x00 0. "FTQ,Flush Transmit Queue When this bit is set the Tx queue controller logic is reset to its default values" "0: Flush Transmit Queue is disabled,1: Flush Transmit Queue is enabled"

    rgroup.long 0xD04++0x03
        line.long 0x00 "MTL_TxQ0_Underflow,The Queue 0 Underflow Counter register contains the counter for packets aborted because of Transmit queue underflow and packets missed because of Receive queue packet flush"
            hexmask.long.tbyte 0x00 12.--31. 1. "Reserved_31_12,Reserved"
            newline
            bitfld.long 0x00 11. "UFCNTOVF,Overflow Bit for Underflow Packet Counter This bit is set every time the Tx queue Underflow Packet Counter field overflows that is it has crossed the maximum count" "0: Overflow not detected for Underflow Packet..,1: Overflow detected for Underflow Packet Counter"
            newline
            hexmask.long.word 0x00 0.--10. 1. "UFFRMCNT,Underflow Packet Counter This field indicates the number of packets aborted by the controller because of Tx Queue Underflow"
    rgroup.long 0xD08++0x03
        line.long 0x00 "MTL_TxQ0_Debug,The Queue 0 Transmit Debug register gives the debug status of various blocks related to the Transmit queue"
            hexmask.long.word 0x00 23.--31. 1. "Reserved_31_23,Reserved"
            newline
            bitfld.long 0x00 20.--22. "STXSTSF,Number of Status Words in Tx Status FIFO of Queue This field indicates the current number of status in the Tx Status FIFO of this queue" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 19. "Reserved_19,Reserved" "0,1"
            newline
            bitfld.long 0x00 16.--18. "PTXQ,Number of Packets in the Transmit Queue This field indicates the current number of packets in the Tx Queue" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long.word 0x00 6.--15. 1. "Reserved_15_6,Reserved"
            newline
            bitfld.long 0x00 5. "TXSTSFSTS,MTL Tx Status FIFO Full Status When high this bit indicates that the MTL Tx Status FIFO is full" "0: MTL Tx Status FIFO Full status is not detected,1: MTL Tx Status FIFO Full status is detected"
            newline
            bitfld.long 0x00 4. "TXQSTS,MTL Tx Queue Not Empty Status When this bit is high it indicates that the MTL Tx Queue is not empty and some data is left for transmission" "0: MTL Tx Queue Not Empty status is not detected,1: MTL Tx Queue Not Empty status is detected"
            newline
            bitfld.long 0x00 3. "TWCSTS,MTL Tx Queue Write Controller Status When high this bit indicates that the MTL Tx Queue Write Controller is active and it is transferring the data to the Tx Queue" "0: MTL Tx Queue Write Controller status is not..,1: MTL Tx Queue Write Controller status is.."
            newline
            bitfld.long 0x00 1.--2. "TRCSTS,MTL Tx Queue Read Controller Status This field indicates the state of the Tx Queue Read Controller" "0: Idle state,1: Read state (transferring data to the MAC..,2: Waiting for pending Tx Status from the MAC..,3: Flushing the Tx queue because of the Packet.."
            newline
            bitfld.long 0x00 0. "TXQPAUSED,Transmit Queue in Pause When this bit is high and the Rx flow control is enabled it indicates that the Tx Queue is in the Pause condition (in the full-duplex only mode) because of the following: - Reception of the PFC packet for the priorities.." "0: Transmit Queue in Pause status is not detected,1: Transmit Queue in Pause status is detected"
    rgroup.long 0xD14++0x03
        line.long 0x00 "MTL_TxQ0_ETS_Status,The Queue 0 ETS Status register provides the average traffic transmitted in Queue 0"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_31_24,Reserved"
            newline
            hexmask.long.tbyte 0x00 0.--23. 1. "ABS,Average Bits per Slot This field contains the average transmitted bits per slot"

    group.long 0xD18++0x03
        line.long 0x00 "MTL_TxQ0_Quantum_Weight,The Queue 0 Quantum or Weights register contains the quantum value for Deficit Weighted Round Robin (DWRR) weights for the Weighted Round Robin (WRR) and Weighted Fair Queuing (WFQ) for Queue 0"
            hexmask.long.word 0x00 21.--31. 1. "Reserved_31_21,Reserved"
            newline
            hexmask.long.tbyte 0x00 0.--20. 1. "ISCQW,Quantum or Weights When the DCB operation is enabled with DWRR algorithm for Queue 0 traffic this field contains the quantum value in bytes to be added to credit during every queue scanning cycle"
    group.long 0xD2C++0x03
        line.long 0x00 "MTL_Q0_Interrupt_Control_Status,This register contains the interrupt enable and status bits for the queue 0 interrupts"
            hexmask.long.byte 0x00 25.--31. 1. "Reserved_31_25,Reserved"
            newline
            bitfld.long 0x00 24. "RXOIE,Receive Queue Overflow Interrupt Enable When this bit is set the Receive Queue Overflow interrupt is enabled" "0: Receive Queue Overflow Interrupt is disabled,1: Receive Queue Overflow Interrupt is enabled"
            newline
            hexmask.long.byte 0x00 17.--23. 1. "Reserved_23_17,Reserved"
            newline
            bitfld.long 0x00 16. "RXOVFIS,Receive Queue Overflow Interrupt Status This bit indicates that the Receive Queue had an overflow while receiving the packet" "0: Receive Queue Overflow Interrupt Status not..,1: Receive Queue Overflow Interrupt Status.."
            newline
            rbitfld.long 0x00 10.--15. "Reserved_15_10,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 9. "ABPSIE,Average Bits Per Slot Interrupt Enable When this bit is set the MAC asserts the sbd_intr_o or mci_intr_o interrupt when the average bits per slot status is updated" "0: Average Bits Per Slot Interrupt is disabled,1: Average Bits Per Slot Interrupt is enabled"
            newline
            bitfld.long 0x00 8. "TXUIE,Transmit Queue Underflow Interrupt Enable When this bit is set the Transmit Queue Underflow interrupt is enabled" "0: Transmit Queue Underflow Interrupt Status is..,1: Transmit Queue Underflow Interrupt Status is.."
            newline
            rbitfld.long 0x00 2.--7. "Reserved_7_2,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 1. "ABPSIS,Average Bits Per Slot Interrupt Status When set this bit indicates that the MAC has updated the ABS value" "0: Average Bits Per Slot Interrupt Status not..,1: Average Bits Per Slot Interrupt Status detected"
            newline
            bitfld.long 0x00 0. "TXUNFIS,Transmit Queue Underflow Interrupt Status This bit indicates that the Transmit Queue had an underflow while transmitting the packet" "0: Transmit Queue Underflow Interrupt Status not..,1: Transmit Queue Underflow Interrupt Status.."
    group.long 0xD30++0x03
        line.long 0x00 "MTL_RxQ0_Operation_Mode,The Queue 0 Receive Operation Mode register establishes the Receive queue operating modes and command"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_31_y,Reserved"
            newline
            bitfld.long 0x00 20.--23. "RQS,Receive Queue Size This field indicates the size of the allocated Receive queues in blocks of 256 bytesthe reset value is 0x0 and indicates size of 256 bytes" "0: 256 bytes,1: 512 bytes and so on,?..."
            newline
            rbitfld.long 0x00 17.--19. "Reserved_19_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 14.--16. "RFD,Threshold for Deactivating Flow Control (in half-duplex and full-duplex modes) These bits control the threshold (fill-level of Rx queue) at which the flow control is de-asserted after activation" "0: Full minus 1 KB that is FULL 1 KB,1: Full minus 1.5 KB that is FULL 1.5 KB,2: Full minus 2 KB that is FULL 2 KB,3: Full minus 2.5 KB that is FULL 2.5 KB,?,?,6: Full minus 4 KB that is FULL 4 KB,7: Full minus 4.5 KB that is FULL 4.5 KB The"
            newline
            rbitfld.long 0x00 11.--13. "Reserved_13_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 8.--10. "RFA,Threshold for Activating Flow Control (in half-duplex and full-duplex These bits control the threshold (fill-level of Rx queue) at which the flow control is activated: For more information on encoding for this field see RFD" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 7. "EHFC,Enable Hardware Flow Control When this bit is set the flow control signal operation based on the fill-level of Rx queue is enabled" "0: Hardware Flow Control is disabled,1: Hardware Flow Control is enabled"
            newline
            bitfld.long 0x00 6. "DIS_TCP_EF,Disable Dropping of TCP/IP Checksum Error Packets When this bit is set the MAC does not drop the packets which only have the errors detected by the Receive Checksum Offload engine" "0: Dropping of TCP/IP Checksum Error Packets is..,1: Dropping of TCP/IP Checksum Error Packets is.."
            newline
            bitfld.long 0x00 5. "RSF,Receive Queue Store and Forward When this bit is set the DWC_ether_qos reads a packet from the Rx queue only after the complete packet has been written to it ignoring the RTC field of this register" "0: Receive Queue Store and Forward is disabled,1: Receive Queue Store and Forward is enabled"
            newline
            bitfld.long 0x00 4. "FEP,Forward Error Packets When this bit is reset the Rx queue drops packets with error status (CRC error GMII_ER watchdog timeout or overflow)" "0: Forward Error Packets is disabled,1: Forward Error Packets is enabled"
            newline
            bitfld.long 0x00 3. "FUP,Forward Undersized Good Packets When this bit is set the Rx queue forwards the undersized good packets (packets with no error and length less than 64 bytes) including pad-bytes and CRC" "0: Forward Undersized Good Packets is disabled,1: Forward Undersized Good Packets is enabled"
            newline
            rbitfld.long 0x00 2. "Reserved_2,Reserved" "0,1"
            newline
            bitfld.long 0x00 0.--1. "RTC,Receive Queue Threshold Control These bits control the threshold level of the MTL Rx queue (in bytes): The received packet is transferred to the application or DMA when the packet size within the MTL Rx queue is larger than the threshold" "0: M_64BYTE,1: M_32BYTE,2: M_96BYTE,3: M_128BYTE"

    rgroup.long 0xD34++0x03
        line.long 0x00 "MTL_RxQ0_Missed_Packet_Overflow_Cnt,The Queue 0 Missed Packet and Overflow Counter register contains the counter for packets missed because of Receive queue packet flush and packets discarded because of Receive queue overflow"
            bitfld.long 0x00 28.--31. "Reserved_31_28,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 27. "MISCNTOVF,Missed Packet Counter Overflow Bit When set this bit indicates that the Rx Queue Missed Packet Counter crossed the maximum limit" "0: Missed Packet Counter overflow not detected,1: Missed Packet Counter overflow detected"
            newline
            hexmask.long.word 0x00 16.--26. 1. "MISPKTCNT,Missed Packet Counter This field indicates the number of packets missed by the DWC_ether_qos because the application asserted ari_pkt_flush_i[] for this queue"
            newline
            bitfld.long 0x00 12.--15. "Reserved_15_12,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 11. "OVFCNTOVF,Overflow Counter Overflow Bit When set this bit indicates that the Rx Queue Overflow Packet Counter field crossed the maximum limit" "0: Overflow Counter overflow not detected,1: Overflow Counter overflow detected"
            newline
            hexmask.long.word 0x00 0.--10. 1. "OVFPKTCNT,Overflow Packet Counter This field indicates the number of packets discarded by the DWC_ether_qos because of Receive queue overflow"
    rgroup.long 0xD38++0x03
        line.long 0x00 "MTL_RxQ0_Debug,The Queue 0 Receive Debug register gives the debug status of various blocks related to the Receive queue"
            bitfld.long 0x00 30.--31. "Reserved_31_30,Reserved" "0,1,2,3"
            newline
            hexmask.long.word 0x00 16.--29. 1. "PRXQ,Number of Packets in Receive Queue This field indicates the current number of packets in the Rx Queue that is Max_Queue_Size/Min_Packet_Size"
            newline
            hexmask.long.word 0x00 6.--15. 1. "Reserved_15_6,Reserved"
            newline
            bitfld.long 0x00 4.--5. "RXQSTS,MTL Rx Queue Fill-Level Status This field gives the status of the fill-level of the Rx Queue" "0: Rx Queue empty,1: Rx Queue fill-level below flow-control..,2: Rx Queue fill-level above flow-control..,3: Rx Queue full"
            newline
            bitfld.long 0x00 3. "Reserved_3,Reserved" "0,1"
            newline
            bitfld.long 0x00 1.--2. "RRCSTS,MTL Rx Queue Read Controller State This field gives the state of the Rx queue Read controller" "0: Idle state,1: Reading packet data,2: Reading packet status (or timestamp),3: Flushing the packet data and status"
            newline
            bitfld.long 0x00 0. "RWCSTS,MTL Rx Queue Write Controller Active Status When high this bit indicates that the MTL Rx queue Write controller is active and it is transferring a received packet to the Rx Queue" "0: MTL Rx Queue Write Controller Active Status..,1: MTL Rx Queue Write Controller Active Status.."

    group.long 0xD3C++0x03
        line.long 0x00 "MTL_RxQ0_Control,The Queue Receive Control register controls the receive arbitration and passing of received packets to the application"
            hexmask.long 0x00 4.--31. 1. "Reserved_31_4,Reserved"
            newline
            bitfld.long 0x00 3. "RXQ_FRM_ARBIT,Receive Queue Packet Arbitration When this bit is set the DWC_ether_qos drives the packet data to the ARI interface such that the entire packet data of currently-selected queue is transmitted before switching to other queue" "0: Receive Queue Packet Arbitration is disabled,1: Receive Queue Packet Arbitration is enabled"
            newline
            bitfld.long 0x00 0.--2. "RXQ_WEGT,Receive Queue Weight This field indicates the weight assigned to the Rx Queue 0" "0,1,2,3,4,5,6,7"
    group.long 0xD40++0x03
        line.long 0x00 "MTL_TxQ1_Operation_Mode,The Queue 1 Transmit Operation Mode register establishes the Transmit queue operating modes and commands"
            hexmask.long.word 0x00 20.--31. 1. "Reserved_31_y,Reserved"
            newline
            bitfld.long 0x00 16.--19. "TQS,Transmit Queue Size This field indicates the size of the allocated Transmit queues in blocks of 256 bytes the reset value is 0x0 and indicates size of 256 bytes" "0: 256 bytes,1: 512 bytes and so on,?..."
            newline
            hexmask.long.word 0x00 7.--15. 1. "Reserved_15_7,Reserved"
            newline
            bitfld.long 0x00 4.--6. "TTC,Transmit Threshold Control These bits control the threshold level of the MTL Tx Queue" "0: M_32BYTES,1: M_64BYTES,2: M_96BYTES,3: M_128BYTES,4: M_192BYTES,5: M_256BYTES,6: M_384BYTES,7: M_512BYTES"
            newline
            bitfld.long 0x00 2.--3. "TXQEN,Transmit Queue Enable This field is used to enable/disable the transmit queue 1" "0: Not enabled,1: Enable in AV mode,2: Enabled,?..."
            newline
            bitfld.long 0x00 1. "TSF,Transmit Store and Forward When this bit is set the transmission starts when a full packet resides in the MTL Tx queue" "0: Transmit Store and Forward is disabled,1: Transmit Store and Forward is enabled"
            newline
            bitfld.long 0x00 0. "FTQ,Flush Transmit Queue When this bit is set the Tx queue controller logic is reset to its default values" "0: Flush Transmit Queue is disabled,1: Flush Transmit Queue is enabled"

    rgroup.long 0xD44++0x03
        line.long 0x00 "MTL_TxQ1_Underflow,The Queue 1 Underflow Counter register contains the counter for packets aborted because of Transmit queue underflow and packets missed because of Receive queue packet flush"
            hexmask.long.tbyte 0x00 12.--31. 1. "Reserved_31_12,Reserved"
            newline
            bitfld.long 0x00 11. "UFCNTOVF,Overflow Bit for Underflow Packet Counter This bit is set every time the Tx queue Underflow Packet Counter field overflows that is it has crossed the maximum count" "0: Overflow not detected for Underflow Packet..,1: Overflow detected for Underflow Packet Counter"
            newline
            hexmask.long.word 0x00 0.--10. 1. "UFFRMCNT,Underflow Packet Counter This field indicates the number of packets aborted by the controller because of Tx Queue Underflow"
    rgroup.long 0xD48++0x03
        line.long 0x00 "MTL_TxQ1_Debug,The Queue 1 Transmit Debug register gives the debug status of various blocks related to the Transmit queue"
            hexmask.long.word 0x00 23.--31. 1. "Reserved_31_23,Reserved"
            newline
            bitfld.long 0x00 20.--22. "STXSTSF,Number of Status Words in Tx Status FIFO of Queue This field indicates the current number of status in the Tx Status FIFO of this queue" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 19. "Reserved_19,Reserved" "0,1"
            newline
            bitfld.long 0x00 16.--18. "PTXQ,Number of Packets in the Transmit Queue This field indicates the current number of packets in the Tx Queue" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long.word 0x00 6.--15. 1. "Reserved_15_6,Reserved"
            newline
            bitfld.long 0x00 5. "TXSTSFSTS,MTL Tx Status FIFO Full Status When high this bit indicates that the MTL Tx Status FIFO is full" "0: MTL Tx Status FIFO Full status is not detected,1: MTL Tx Status FIFO Full status is detected"
            newline
            bitfld.long 0x00 4. "TXQSTS,MTL Tx Queue Not Empty Status When this bit is high it indicates that the MTL Tx Queue is not empty and some data is left for transmission" "0: MTL Tx Queue Not Empty status is not detected,1: MTL Tx Queue Not Empty status is detected"
            newline
            bitfld.long 0x00 3. "TWCSTS,MTL Tx Queue Write Controller Status When high this bit indicates that the MTL Tx Queue Write Controller is active and it is transferring the data to the Tx Queue" "0: MTL Tx Queue Write Controller status is not..,1: MTL Tx Queue Write Controller status is.."
            newline
            bitfld.long 0x00 1.--2. "TRCSTS,MTL Tx Queue Read Controller Status This field indicates the state of the Tx Queue Read Controller" "0: Idle state,1: Read state (transferring data to the MAC..,2: Waiting for pending Tx Status from the MAC..,3: Flushing the Tx queue because of the Packet.."
            newline
            bitfld.long 0x00 0. "TXQPAUSED,Transmit Queue in Pause When this bit is high and the Rx flow control is enabled it indicates that the Tx Queue is in the Pause condition (in the full-duplex only mode) because of the following: - Reception of the PFC packet for the priorities.." "0: Transmit Queue in Pause status is not detected,1: Transmit Queue in Pause status is detected"

    group.long 0xD50++0x03
        line.long 0x00 "MTL_TxQ1_ETS_Control,The Queue ETS Control register controls the enhanced transmission selection operation"
            hexmask.long 0x00 7.--31. 1. "Reserved_31_7,Reserved"
            newline
            bitfld.long 0x00 4.--6. "SLC,Slot Count If the credit-based shaper algorithm is enabled the software can program the number of slots (of duration programmed in DMA_CH1_Slot_Interval register) over which the average transmitted bits per slot provided in the MTL_TxQ1_ETS_Status.." "0: M_1_SLOT,1: M_2_SLOT,2: M_4_SLOT,3: M_8_SLOT,4: M_16_SLOT,?..."
            newline
            bitfld.long 0x00 3. "CC,Credit Control When this bit is set the accumulated credit parameter in the credit-based shaper algorithm logic is not reset to zero when there is positive credit and no packet to transmit in Tx Queue 1" "0: Credit Control is disabled,1: Credit Control is enabled"
            newline
            bitfld.long 0x00 2. "AVALG,AV Algorithm When Queue 1 is programmed for AV this field configures the scheduling algorithm for this queue: This bit when set indicates credit based shaper algorithm (CBS) is selected for Queue 1 traffic" "0: CBS Algorithm is disabled,1: CBS Algorithm is enabled"
            newline
            rbitfld.long 0x00 0.--1. "Reserved_1_0,Reserved" "0,1,2,3"

    rgroup.long 0xD54++0x03
        line.long 0x00 "MTL_TxQ1_ETS_Status,The Queue 1 ETS Status register provides the average traffic transmitted in Queue 1"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_31_24,Reserved"
            newline
            hexmask.long.tbyte 0x00 0.--23. 1. "ABS,Average Bits per Slot This field contains the average transmitted bits per slot"

    group.long 0xD58++0x03
        line.long 0x00 "MTL_TxQ1_Quantum_Weight,The Queue 1 idleSlopeCredit Quantum or Weights register provides the average traffic transmitted in Queue 1"
            hexmask.long.word 0x00 21.--31. 1. "Reserved_31_21,Reserved"
            newline
            abitfld.long 0x00 0.--20. "ISCQW,idleSlopeCredit Quantum or Weights - idleSlopeCredit When AV feature is enabled this field contains the idleSlopeCredit value required for the credit-based shaper algorithm for Queue 1" "0x000001=1: In multiple Queue configuration this..,0x000002=2: For WFQ algorithm higher the..,0x000003=3: The weights programmed do not.."
    group.long 0xD5C++0x03
        line.long 0x00 "MTL_TxQ1_SendSlopeCredit,The sendSlopeCredit register contains the sendSlope credit value required for the credit-based shaper algorithm for the Queue"
            hexmask.long.tbyte 0x00 14.--31. 1. "Reserved_31_14,Reserved"
            newline
            hexmask.long.word 0x00 0.--13. 1. "SSC,sendSlopeCredit Value When AV operation is enabled this field contains the sendSlopeCredit value required for credit-based shaper algorithm for Tx Queue 1"
    group.long 0xD60++0x03
        line.long 0x00 "MTL_TxQ1_HiCredit,The hiCredit register contains the hiCredit value required for the credit-based shaper algorithm for the Queue"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long 0x00 0.--28. 1. "HC,hiCredit Value When the AV feature is enabled this field contains the hiCredit value required for the credit-based shaper algorithm"
    group.long 0xD64++0x03
        line.long 0x00 "MTL_TxQ1_LoCredit,The loCredit register contains the loCredit value required for the credit-based shaper algorithm for the Queue"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long 0x00 0.--28. 1. "LC,loCredit Value When AV operation is enabled this field contains the loCredit value required for the credit-based shaper algorithm"
    group.long 0xD6C++0x03
        line.long 0x00 "MTL_Q1_Interrupt_Control_Status,This register contains the interrupt enable and status bits for the queue 1 interrupts"
            hexmask.long.byte 0x00 25.--31. 1. "Reserved_31_25,Reserved"
            newline
            bitfld.long 0x00 24. "RXOIE,Receive Queue Overflow Interrupt Enable When this bit is set the Receive Queue Overflow interrupt is enabled" "0: Receive Queue Overflow Interrupt is disabled,1: Receive Queue Overflow Interrupt is enabled"
            newline
            hexmask.long.byte 0x00 17.--23. 1. "Reserved_23_17,Reserved"
            newline
            bitfld.long 0x00 16. "RXOVFIS,Receive Queue Overflow Interrupt Status This bit indicates that the Receive Queue had an overflow while receiving the packet" "0: Receive Queue Overflow Interrupt Status not..,1: Receive Queue Overflow Interrupt Status.."
            newline
            rbitfld.long 0x00 10.--15. "Reserved_15_10,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 9. "ABPSIE,Average Bits Per Slot Interrupt Enable When this bit is set the MAC asserts the sbd_intr_o or mci_intr_o interrupt when the average bits per slot status is updated" "0: Average Bits Per Slot Interrupt is disabled,1: Average Bits Per Slot Interrupt is enabled"
            newline
            bitfld.long 0x00 8. "TXUIE,Transmit Queue Underflow Interrupt Enable When this bit is set the Transmit Queue Underflow interrupt is enabled" "0: Transmit Queue Underflow Interrupt Status is..,1: Transmit Queue Underflow Interrupt Status is.."
            newline
            rbitfld.long 0x00 2.--7. "Reserved_7_2,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 1. "ABPSIS,Average Bits Per Slot Interrupt Status When set this bit indicates that the MAC has updated the ABS value" "0: Average Bits Per Slot Interrupt Status not..,1: Average Bits Per Slot Interrupt Status detected"
            newline
            bitfld.long 0x00 0. "TXUNFIS,Transmit Queue Underflow Interrupt Status This bit indicates that the Transmit Queue had an underflow while transmitting the packet" "0: Transmit Queue Underflow Interrupt Status not..,1: Transmit Queue Underflow Interrupt Status.."
    group.long 0xD70++0x03
        line.long 0x00 "MTL_RxQ1_Operation_Mode,The Queue 1 Receive Operation Mode register establishes the Receive queue operating modes and command"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_31_y,Reserved"
            newline
            bitfld.long 0x00 20.--23. "RQS,Receive Queue Size This field indicates the size of the allocated Receive queues in blocks of 256 bytesthe reset value is 0x0 and indicates size of 256 bytes" "0: 256 bytes,1: 512 bytes and so on,?..."
            newline
            rbitfld.long 0x00 17.--19. "Reserved_19_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 14.--16. "RFD,Threshold for Deactivating Flow Control (in half-duplex and full-duplex modes) These bits control the threshold (fill-level of Rx queue) at which the flow control is de-asserted after activation" "0: Full minus 1 KB that is FULL 1 KB,1: Full minus 1.5 KB that is FULL 1.5 KB,2: Full minus 2 KB that is FULL 2 KB,3: Full minus 2.5 KB that is FULL 2.5 KB,?,?,6: Full minus 4 KB that is FULL 4 KB,7: Full minus 4.5 KB that is FULL 4.5 KB The"
            newline
            rbitfld.long 0x00 11.--13. "Reserved_13_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 8.--10. "RFA,Threshold for Activating Flow Control (in half-duplex and full-duplex These bits control the threshold (fill-level of Rx queue) at which the flow control is activated: For more information on encoding for this field see RFD" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 7. "EHFC,Enable Hardware Flow Control When this bit is set the flow control signal operation based on the fill-level of Rx queue is enabled" "0: Hardware Flow Control is disabled,1: Hardware Flow Control is enabled"
            newline
            bitfld.long 0x00 6. "DIS_TCP_EF,Disable Dropping of TCP/IP Checksum Error Packets When this bit is set the MAC does not drop the packets which only have the errors detected by the Receive Checksum Offload engine" "0: Dropping of TCP/IP Checksum Error Packets is..,1: Dropping of TCP/IP Checksum Error Packets is.."
            newline
            bitfld.long 0x00 5. "RSF,Receive Queue Store and Forward When this bit is set the DWC_ether_qos reads a packet from the Rx queue only after the complete packet has been written to it ignoring the RTC field of this register" "0: Receive Queue Store and Forward is disabled,1: Receive Queue Store and Forward is enabled"
            newline
            bitfld.long 0x00 4. "FEP,Forward Error Packets When this bit is reset the Rx queue drops packets with error status (CRC error GMII_ER watchdog timeout or overflow)" "0: Forward Error Packets is disabled,1: Forward Error Packets is enabled"
            newline
            bitfld.long 0x00 3. "FUP,Forward Undersized Good Packets When this bit is set the Rx queue forwards the undersized good packets (packets with no error and length less than 64 bytes) including pad-bytes and CRC" "0: Forward Undersized Good Packets is disabled,1: Forward Undersized Good Packets is enabled"
            newline
            rbitfld.long 0x00 2. "Reserved_2,Reserved" "0,1"
            newline
            bitfld.long 0x00 0.--1. "RTC,Receive Queue Threshold Control These bits control the threshold level of the MTL Rx queue (in bytes): The received packet is transferred to the application or DMA when the packet size within the MTL Rx queue is larger than the threshold" "0: M_64BYTE,1: M_32BYTE,2: M_96BYTE,3: M_128BYTE"

    rgroup.long 0xD74++0x03
        line.long 0x00 "MTL_RxQ1_Missed_Packet_Overflow_Cnt,The Queue 1 Missed Packet and Overflow Counter register contains the counter for packets missed because of Receive queue packet flush and packets discarded because of Receive queue overflow"
            bitfld.long 0x00 28.--31. "Reserved_31_28,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 27. "MISCNTOVF,Missed Packet Counter Overflow Bit When set this bit indicates that the Rx Queue Missed Packet Counter crossed the maximum limit" "0: Missed Packet Counter overflow not detected,1: Missed Packet Counter overflow detected"
            newline
            hexmask.long.word 0x00 16.--26. 1. "MISPKTCNT,Missed Packet Counter This field indicates the number of packets missed by the DWC_ether_qos because the application asserted ari_pkt_flush_i[] for this queue"
            newline
            bitfld.long 0x00 12.--15. "Reserved_15_12,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 11. "OVFCNTOVF,Overflow Counter Overflow Bit When set this bit indicates that the Rx Queue Overflow Packet Counter field crossed the maximum limit" "0: Overflow Counter overflow not detected,1: Overflow Counter overflow detected"
            newline
            hexmask.long.word 0x00 0.--10. 1. "OVFPKTCNT,Overflow Packet Counter This field indicates the number of packets discarded by the DWC_ether_qos because of Receive queue overflow"
    rgroup.long 0xD78++0x03
        line.long 0x00 "MTL_RxQ1_Debug,The Queue 1 Receive Debug register gives the debug status of various blocks related to the Receive queue"
            bitfld.long 0x00 30.--31. "Reserved_31_30,Reserved" "0,1,2,3"
            newline
            hexmask.long.word 0x00 16.--29. 1. "PRXQ,Number of Packets in Receive Queue This field indicates the current number of packets in the Rx Queue that is Max_Queue_Size/Min_Packet_Size"
            newline
            hexmask.long.word 0x00 6.--15. 1. "Reserved_15_6,Reserved"
            newline
            bitfld.long 0x00 4.--5. "RXQSTS,MTL Rx Queue Fill-Level Status This field gives the status of the fill-level of the Rx Queue" "0: Rx Queue empty,1: Rx Queue fill-level below flow-control..,2: Rx Queue fill-level above flow-control..,3: Rx Queue full"
            newline
            bitfld.long 0x00 3. "Reserved_3,Reserved" "0,1"
            newline
            bitfld.long 0x00 1.--2. "RRCSTS,MTL Rx Queue Read Controller State This field gives the state of the Rx queue Read controller" "0: Idle state,1: Reading packet data,2: Reading packet status (or timestamp),3: Flushing the packet data and status"
            newline
            bitfld.long 0x00 0. "RWCSTS,MTL Rx Queue Write Controller Active Status When high this bit indicates that the MTL Rx queue Write controller is active and it is transferring a received packet to the Rx Queue" "0: MTL Rx Queue Write Controller Active Status..,1: MTL Rx Queue Write Controller Active Status.."

    group.long 0xD7C++0x03
        line.long 0x00 "MTL_RxQ1_Control,The Queue Receive Control register controls the receive arbitration and passing of received packets to the application"
            hexmask.long 0x00 4.--31. 1. "Reserved_31_4,Reserved"
            newline
            bitfld.long 0x00 3. "RXQ_FRM_ARBIT,Receive Queue Packet Arbitration When this bit is set the DWC_ether_qos drives the packet data to the ARI interface such that the entire packet data of currently-selected queue is transmitted before switching to other queue" "0: Receive Queue Packet Arbitration is disabled,1: Receive Queue Packet Arbitration is enabled"
            newline
            bitfld.long 0x00 0.--2. "RXQ_WEGT,Receive Queue Weight This field indicates the weight assigned to the Rx Queue 1" "0,1,2,3,4,5,6,7"
    group.long 0xD80++0x03
        line.long 0x00 "MTL_TxQ2_Operation_Mode,The Queue 2 Transmit Operation Mode register establishes the Transmit queue operating modes and commands"
            hexmask.long.word 0x00 20.--31. 1. "Reserved_31_y,Reserved"
            newline
            bitfld.long 0x00 16.--19. "TQS,Transmit Queue Size This field indicates the size of the allocated Transmit queues in blocks of 256 bytes the reset value is 0x0 and indicates size of 256 bytes" "0: 256 bytes,1: 512 bytes and so on,?..."
            newline
            hexmask.long.word 0x00 7.--15. 1. "Reserved_15_7,Reserved"
            newline
            bitfld.long 0x00 4.--6. "TTC,Transmit Threshold Control These bits control the threshold level of the MTL Tx Queue" "0: M_32BYTES,1: M_64BYTES,2: M_96BYTES,3: M_128BYTES,4: M_192BYTES,5: M_256BYTES,6: M_384BYTES,7: M_512BYTES"
            newline
            bitfld.long 0x00 2.--3. "TXQEN,Transmit Queue Enable This field is used to enable/disable the transmit queue 2" "0: Not enabled,1: Enable in AV mode,2: Enabled,?..."
            newline
            bitfld.long 0x00 1. "TSF,Transmit Store and Forward When this bit is set the transmission starts when a full packet resides in the MTL Tx queue" "0: Transmit Store and Forward is disabled,1: Transmit Store and Forward is enabled"
            newline
            bitfld.long 0x00 0. "FTQ,Flush Transmit Queue When this bit is set the Tx queue controller logic is reset to its default values" "0: Flush Transmit Queue is disabled,1: Flush Transmit Queue is enabled"

    rgroup.long 0xD84++0x03
        line.long 0x00 "MTL_TxQ2_Underflow,The Queue 2 Underflow Counter register contains the counter for packets aborted because of Transmit queue underflow and packets missed because of Receive queue packet flush"
            hexmask.long.tbyte 0x00 12.--31. 1. "Reserved_31_12,Reserved"
            newline
            bitfld.long 0x00 11. "UFCNTOVF,Overflow Bit for Underflow Packet Counter This bit is set every time the Tx queue Underflow Packet Counter field overflows that is it has crossed the maximum count" "0: Overflow not detected for Underflow Packet..,1: Overflow detected for Underflow Packet Counter"
            newline
            hexmask.long.word 0x00 0.--10. 1. "UFFRMCNT,Underflow Packet Counter This field indicates the number of packets aborted by the controller because of Tx Queue Underflow"
    rgroup.long 0xD88++0x03
        line.long 0x00 "MTL_TxQ2_Debug,The Queue 2 Transmit Debug register gives the debug status of various blocks related to the Transmit queue"
            hexmask.long.word 0x00 23.--31. 1. "Reserved_31_23,Reserved"
            newline
            bitfld.long 0x00 20.--22. "STXSTSF,Number of Status Words in Tx Status FIFO of Queue This field indicates the current number of status in the Tx Status FIFO of this queue" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 19. "Reserved_19,Reserved" "0,1"
            newline
            bitfld.long 0x00 16.--18. "PTXQ,Number of Packets in the Transmit Queue This field indicates the current number of packets in the Tx Queue" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long.word 0x00 6.--15. 1. "Reserved_15_6,Reserved"
            newline
            bitfld.long 0x00 5. "TXSTSFSTS,MTL Tx Status FIFO Full Status When high this bit indicates that the MTL Tx Status FIFO is full" "0: MTL Tx Status FIFO Full status is not detected,1: MTL Tx Status FIFO Full status is detected"
            newline
            bitfld.long 0x00 4. "TXQSTS,MTL Tx Queue Not Empty Status When this bit is high it indicates that the MTL Tx Queue is not empty and some data is left for transmission" "0: MTL Tx Queue Not Empty status is not detected,1: MTL Tx Queue Not Empty status is detected"
            newline
            bitfld.long 0x00 3. "TWCSTS,MTL Tx Queue Write Controller Status When high this bit indicates that the MTL Tx Queue Write Controller is active and it is transferring the data to the Tx Queue" "0: MTL Tx Queue Write Controller status is not..,1: MTL Tx Queue Write Controller status is.."
            newline
            bitfld.long 0x00 1.--2. "TRCSTS,MTL Tx Queue Read Controller Status This field indicates the state of the Tx Queue Read Controller" "0: Idle state,1: Read state (transferring data to the MAC..,2: Waiting for pending Tx Status from the MAC..,3: Flushing the Tx queue because of the Packet.."
            newline
            bitfld.long 0x00 0. "TXQPAUSED,Transmit Queue in Pause When this bit is high and the Rx flow control is enabled it indicates that the Tx Queue is in the Pause condition (in the full-duplex only mode) because of the following: - Reception of the PFC packet for the priorities.." "0: Transmit Queue in Pause status is not detected,1: Transmit Queue in Pause status is detected"

    group.long 0xD90++0x03
        line.long 0x00 "MTL_TxQ2_ETS_Control,The Queue ETS Control register controls the enhanced transmission selection operation"
            hexmask.long 0x00 7.--31. 1. "Reserved_31_7,Reserved"
            newline
            bitfld.long 0x00 4.--6. "SLC,Slot Count If the credit-based shaper algorithm is enabled the software can program the number of slots (of duration programmed in DMA_CH2_Slot_Interval register) over which the average transmitted bits per slot provided in the MTL_TxQ2_ETS_Status.." "0: M_1_SLOT,1: M_2_SLOT,2: M_4_SLOT,3: M_8_SLOT,4: M_16_SLOT,?..."
            newline
            bitfld.long 0x00 3. "CC,Credit Control When this bit is set the accumulated credit parameter in the credit-based shaper algorithm logic is not reset to zero when there is positive credit and no packet to transmit in Tx Queue 2" "0: Credit Control is disabled,1: Credit Control is enabled"
            newline
            bitfld.long 0x00 2. "AVALG,AV Algorithm When Queue 2 is programmed for AV this field configures the scheduling algorithm for this queue: This bit when set indicates credit based shaper algorithm (CBS) is selected for Queue 2 traffic" "0: CBS Algorithm is disabled,1: CBS Algorithm is enabled"
            newline
            rbitfld.long 0x00 0.--1. "Reserved_1_0,Reserved" "0,1,2,3"

    rgroup.long 0xD94++0x03
        line.long 0x00 "MTL_TxQ2_ETS_Status,The Queue 2 ETS Status register provides the average traffic transmitted in Queue 2"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_31_24,Reserved"
            newline
            hexmask.long.tbyte 0x00 0.--23. 1. "ABS,Average Bits per Slot This field contains the average transmitted bits per slot"

    group.long 0xD98++0x03
        line.long 0x00 "MTL_TxQ2_Quantum_Weight,The Queue 2 idleSlopeCredit Quantum or Weights register provides the average traffic transmitted in Queue 2"
            hexmask.long.word 0x00 21.--31. 1. "Reserved_31_21,Reserved"
            newline
            abitfld.long 0x00 0.--20. "ISCQW,idleSlopeCredit Quantum or Weights - idleSlopeCredit When AV feature is enabled this field contains the idleSlopeCredit value required for the credit-based shaper algorithm for Queue 2" "0x000001=1: In multiple Queue configuration this..,0x000002=2: For WFQ algorithm higher the..,0x000003=3: The weights programmed do not.."
    group.long 0xD9C++0x03
        line.long 0x00 "MTL_TxQ2_SendSlopeCredit,The sendSlopeCredit register contains the sendSlope credit value required for the credit-based shaper algorithm for the Queue"
            hexmask.long.tbyte 0x00 14.--31. 1. "Reserved_31_14,Reserved"
            newline
            hexmask.long.word 0x00 0.--13. 1. "SSC,sendSlopeCredit Value When AV operation is enabled this field contains the sendSlopeCredit value required for credit-based shaper algorithm for Tx Queue 2"
    group.long 0xDA0++0x03
        line.long 0x00 "MTL_TxQ2_HiCredit,The hiCredit register contains the hiCredit value required for the credit-based shaper algorithm for the Queue"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long 0x00 0.--28. 1. "HC,hiCredit Value When the AV feature is enabled this field contains the hiCredit value required for the credit-based shaper algorithm"
    group.long 0xDA4++0x03
        line.long 0x00 "MTL_TxQ2_LoCredit,The loCredit register contains the loCredit value required for the credit-based shaper algorithm for the Queue"
            rbitfld.long 0x00 29.--31. "Reserved_31_29,Reserved" "0,1,2,3,4,5,6,7"
            newline
            hexmask.long 0x00 0.--28. 1. "LC,loCredit Value When AV operation is enabled this field contains the loCredit value required for the credit-based shaper algorithm"
    group.long 0xDAC++0x03
        line.long 0x00 "MTL_Q2_Interrupt_Control_Status,This register contains the interrupt enable and status bits for the queue 2 interrupts"
            hexmask.long.byte 0x00 25.--31. 1. "Reserved_31_25,Reserved"
            newline
            rbitfld.long 0x00 24. "Reserved_RXOIE,Reserved" "0,1"
            newline
            hexmask.long.byte 0x00 17.--23. 1. "Reserved_23_17,Reserved"
            newline
            rbitfld.long 0x00 16. "Reserved_RXOVFIS,Reserved" "0,1"
            newline
            rbitfld.long 0x00 10.--15. "Reserved_15_10,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 9. "ABPSIE,Average Bits Per Slot Interrupt Enable When this bit is set the MAC asserts the sbd_intr_o or mci_intr_o interrupt when the average bits per slot status is updated" "0: Average Bits Per Slot Interrupt is disabled,1: Average Bits Per Slot Interrupt is enabled"
            newline
            bitfld.long 0x00 8. "TXUIE,Transmit Queue Underflow Interrupt Enable When this bit is set the Transmit Queue Underflow interrupt is enabled" "0: Transmit Queue Underflow Interrupt Status is..,1: Transmit Queue Underflow Interrupt Status is.."
            newline
            rbitfld.long 0x00 2.--7. "Reserved_7_2,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 1. "ABPSIS,Average Bits Per Slot Interrupt Status When set this bit indicates that the MAC has updated the ABS value" "0: Average Bits Per Slot Interrupt Status not..,1: Average Bits Per Slot Interrupt Status detected"
            newline
            bitfld.long 0x00 0. "TXUNFIS,Transmit Queue Underflow Interrupt Status This bit indicates that the Transmit Queue had an underflow while transmitting the packet" "0: Transmit Queue Underflow Interrupt Status not..,1: Transmit Queue Underflow Interrupt Status.."
    group.long 0x1000++0x03
        line.long 0x00 "DMA_Mode,The Bus Mode register establishes the bus operating modes for the DMA"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_31_24,Reserved"
            newline
            bitfld.long 0x00 22.--23. "RNDF,Rx DMA's Maximum Number of Descriptors to be fetched in a burst" "0: DWC_EQOS_DCRX_DEP,1: DWC_EQOS_DCRX_DEP/2,2: DWC_EQOS_DCRX_DEP/4,3: DWC_EQOS_DCRX_DEP/8 (Reserved when"
            newline
            bitfld.long 0x00 20.--21. "TNDF,Tx DMA's Maximum Number of Descriptors to be fetched in a burst" "0: DWC_EQOS_DCTX_DEP,1: DWC_EQOS_DCTX_DEP/2,2: DWC_EQOS_DCTX_DEP/4,3: DWC_EQOS_DCTX_DEP/8 (Reserved when"
            newline
            bitfld.long 0x00 19. "DCHE,Descriptor Cache Enable" "0: Descriptor Cache Support is disabled,1: Descriptor Cache Support is enabled"
            newline
            rbitfld.long 0x00 18. "Reserved_18,Reserved" "0,1"
            newline
            bitfld.long 0x00 16.--17. "INTM,Interrupt Mode This field defines the interrupt mode of DWC_ether_qos" "0: See above description,1: See above description,2: See above description,?..."
            newline
            rbitfld.long 0x00 15. "Reserved_15,Reserved" "0,1"
            newline
            rbitfld.long 0x00 12.--14. "Reserved_PR,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 11. "TXPR,Transmit Priority" "0: Transmit Priority is disabled,1: Transmit Priority is enabled"
            newline
            bitfld.long 0x00 10. "SCSW,SCSW is Synopsys Reserved This field must be set to 0" "0: Synopsys reserved field disabled,1: Synopsys reserved field enabled up on.."
            newline
            rbitfld.long 0x00 9. "Reserved_ARBC,Reserved" "0,1"
            newline
            bitfld.long 0x00 8. "DSPW,Descriptor Posted Write" "0: Descriptor Posted Write is disabled,1: Descriptor Posted Write is enabled"
            newline
            rbitfld.long 0x00 5.--7. "Reserved_7_5,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 2.--4. "TAA,Transmit Arbitration Algorithm This field is used to select the arbitration policy for the Transmit side when you select multiple Tx DMAs" "0: Fixed priority (Channel 0 has the lowest..,1: Weighted Strict Priority (WSP),2: Weighted Round-Robin (WRR),3: Reserved (for 3'b011 to 3'b111),?..."
            newline
            rbitfld.long 0x00 1. "Reserved_DA,Reserved" "0,1"
            newline
            bitfld.long 0x00 0. "SWR,Software Reset" "0: Software Reset is disabled,1: Software Reset is enabled"
    group.long 0x1004++0x03
        line.long 0x00 "DMA_SysBus_Mode,System Bus Mode This register controls the behavior of the AXI master"
            bitfld.long 0x00 31. "EN_LPI,Enable Low Power Interface (LPI)" "0: Low Power Interface (LPI) is disabled,1: Low Power Interface (LPI) is enabled"
            newline
            rbitfld.long 0x00 30. "Reserved_LPI_XIT_PKT,Reserved" "0,1"
            newline
            rbitfld.long 0x00 27.--29. "Reserved_29_y,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 24.--26. "WR_OSR_LMT,AXI Maximum Write Outstanding Request Limit This value limits the maximum outstanding request on the AXI write interface" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 19.--23. "Reserved_23_y,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
            newline
            bitfld.long 0x00 16.--18. "RD_OSR_LMT,AXI Maximum Read Outstanding Request Limit This value limits the maximum outstanding request on the AXI read interface" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 15. "Reserved_RB,Reserved" "0,1"
            newline
            rbitfld.long 0x00 14. "Reserved_MB,Reserved" "0,1"
            newline
            bitfld.long 0x00 13. "ONEKBBE,1 KB Boundary Crossing Enable for the EQOS-AXI Master" "0: 1 KB Boundary Crossing for the EQOS-AXI..,1: 1 KB Boundary Crossing for the EQOS-AXI.."
            newline
            bitfld.long 0x00 12. "AAL,Address-Aligned Beats" "0: Address-Aligned Beats is disabled,1: Address-Aligned Beats is enabled"
            newline
            rbitfld.long 0x00 11. "Reserved_EAME,Reserved" "0,1"
            newline
            bitfld.long 0x00 10. "AALE,Automatic AXI LPI enable" "0: Automatic AXI LPI is disabled,1: Automatic AXI LPI is enabled"
            newline
            rbitfld.long 0x00 8.--9. "Reserved_9_8,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 7. "BLEN256,AXI Burst Length 256 When set to" "0: No effect,1: AXI Burst Length 256"
            newline
            bitfld.long 0x00 6. "BLEN128,AXI Burst Length 128 When set to" "0: No effect,1: AXI Burst Length 128"
            newline
            bitfld.long 0x00 5. "BLEN64,AXI Burst Length 64 When set to" "0: No effect,1: AXI Burst Length 64"
            newline
            bitfld.long 0x00 4. "BLEN32,AXI Burst Length 32 When set to" "0: No effect,1: AXI Burst Length 32"
            newline
            bitfld.long 0x00 3. "BLEN16,AXI Burst Length" "0: No effect,1: AXI Burst Length 16"
            newline
            bitfld.long 0x00 2. "BLEN8,AXI Burst Length" "0: No effect,1: AXI Burst Length 8"
            newline
            bitfld.long 0x00 1. "BLEN4,AXI Burst Length" "0: No effect,1: AXI Burst Length 4"
            newline
            bitfld.long 0x00 0. "FB,Fixed Burst Length" "0: Fixed Burst Length is disabled,1: Fixed Burst Length is enabled"

    rgroup.long 0x1008++0x03
        line.long 0x00 "DMA_Interrupt_Status,The application reads this Interrupt Status register during interrupt service routine or polling to determine the interrupt status of DMA channels MTL queues and the MAC"
            hexmask.long.word 0x00 18.--31. 1. "Reserved_31_18,Reserved"
            newline
            bitfld.long 0x00 17. "MACIS,MAC Interrupt Status Indicates an interrupt event in the MAC" "0: MAC Interrupt Status not detected,1: MAC Interrupt Status detected"
            newline
            bitfld.long 0x00 16. "MTLIS,MTL Interrupt Status Indicates an interrupt event in the MTL" "0: MTL Interrupt Status not detected,1: MTL Interrupt Status detected"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "Reserved_15_8,Reserved"
            newline
            bitfld.long 0x00 7. "Reserved_DC7IS,Reserved" "0,1"
            newline
            bitfld.long 0x00 6. "Reserved_DC6IS,Reserved" "0,1"
            newline
            bitfld.long 0x00 5. "Reserved_DC5IS,Reserved" "0,1"
            newline
            bitfld.long 0x00 4. "Reserved_DC4IS,Reserved" "0,1"
            newline
            bitfld.long 0x00 3. "Reserved_DC3IS,Reserved" "0,1"
            newline
            bitfld.long 0x00 2. "DC2IS,DMA Channel 2 Interrupt Status This bit indicates an interrupt event in DMA Channel 2" "0: DMA Channel 2 Interrupt Status not detected,1: DMA Channel 2 Interrupt Status detected"
            newline
            bitfld.long 0x00 1. "DC1IS,DMA Channel 1 Interrupt Status This bit indicates an interrupt event in DMA Channel 1" "0: DMA Channel 1 Interrupt Status not detected,1: DMA Channel 1 Interrupt Status detected"
            newline
            bitfld.long 0x00 0. "DC0IS,DMA Channel 0 Interrupt Status This bit indicates an interrupt event in DMA Channel 0" "0: DMA Channel 0 Interrupt Status not detected,1: DMA Channel 0 Interrupt Status detected"
    rgroup.long 0x100C++0x03
        line.long 0x00 "DMA_Debug_Status0,The Debug Status 0 register gives the Receive and Transmit process status for DMA Channel 0-Channel 2 for debugging purpose"
            bitfld.long 0x00 28.--31. "TPS2,DMA Channel 2 Transmit Process State This field indicates the Tx DMA FSM state for Channel 2" "0: Stopped (Reset or Stop Transmit Command issued),1: Running (Fetching Tx Transfer Descriptor),2: Running (Waiting for status),3: Running (Reading Data from system memory..,4: Timestamp write state,5: Reserved for future use,6: Suspended (Tx Descriptor Unavailable or Tx..,7: Running (Closing Tx Descriptor),?..."
            newline
            bitfld.long 0x00 24.--27. "Reserved_RPS2,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            bitfld.long 0x00 20.--23. "TPS1,DMA Channel 1 Transmit Process State This field indicates the Tx DMA FSM state for Channel 1" "0: Stopped (Reset or Stop Transmit Command issued),1: Running (Fetching Tx Transfer Descriptor),2: Running (Waiting for status),3: Running (Reading Data from system memory..,4: Timestamp write state,5: Reserved for future use,6: Suspended (Tx Descriptor Unavailable or Tx..,7: Running (Closing Tx Descriptor),?..."
            newline
            bitfld.long 0x00 16.--19. "RPS1,DMA Channel 1 Receive Process State This field indicates the Rx DMA FSM state for Channel 1" "0: Stopped (Reset or Stop Receive Command issued),1: Running (Fetching Rx Transfer Descriptor),2: Reserved for future use,3: Running (Waiting for Rx packet),4: Suspended (Rx Descriptor Unavailable),5: Running (Closing the Rx Descriptor),6: Timestamp write state,7: Running (Transferring the received packet..,?..."
            newline
            bitfld.long 0x00 12.--15. "TPS0,DMA Channel 0 Transmit Process State This field indicates the Tx DMA FSM state for Channel 0" "0: Stopped (Reset or Stop Transmit Command issued),1: Running (Fetching Tx Transfer Descriptor),2: Running (Waiting for status),3: Running (Reading Data from system memory..,4: Timestamp write state,5: Reserved for future use,6: Suspended (Tx Descriptor Unavailable or Tx..,7: Running (Closing Tx Descriptor),?..."
            newline
            bitfld.long 0x00 8.--11. "RPS0,DMA Channel 0 Receive Process State This field indicates the Rx DMA FSM state for Channel 0" "0: Stopped (Reset or Stop Receive Command issued),1: Running (Fetching Rx Transfer Descriptor),2: Reserved for future use,3: Running (Waiting for Rx packet),4: Suspended (Rx Descriptor Unavailable),5: Running (Closing the Rx Descriptor),6: Timestamp write state,7: Running (Transferring the received packet..,?..."
            newline
            bitfld.long 0x00 2.--7. "Reserved_7_2,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 1. "AXRHSTS,AXI Master Read Channel Status" "0: AXI Master Read Channel Status not detected,1: AXI Master Read Channel Status detected"
            newline
            bitfld.long 0x00 0. "AXWHSTS,AXI Master Write Channel When high this bit indicates that the write channel of the AXI master is active and it is transferring data" "0: AXI Master Write Channel or AHB Master Status..,1: AXI Master Write Channel or AHB Master Status.."

    group.long 0x1020++0x03
        line.long 0x00 "AXI4_Tx_AR_ACE_Control,This register is used to control the AXI4 Cache Coherency Signals for read transactions by all the Transmit DMA channels"
            hexmask.long.word 0x00 22.--31. 1. "Reserved_31_22,Reserved"
            newline
            bitfld.long 0x00 20.--21. "THD,Transmit DMA First Packet Buffer or TSO Header Domain Control When TSO is NOT enabled This field is used to drive ardomain_m_o[1:0] signal when Transmit DMA is accessing First Buffer of the Packet (First valid buffer with FD being set in the TDES3.." "0,1,2,3"
            newline
            bitfld.long 0x00 16.--19. "THC,Transmit DMA First Packet Buffer or TSO Header Cache Control When TSO is NOT enabled This field is used to drive arcache_m_o[3:0] signal when Transmit DMA is accessing First Buffer of the Packet (First valid buffer with FD being set in the TDES3 of.." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 14.--15. "Reserved_15_14,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 12.--13. "TED,Transmit DMA Extended Packet Buffer or TSO Payload Domain Control When TSO is NOT enabled This field is used to drive ardomain_m_o[1:0] signal when Transmit DMA is accessing the extended buffers (when packet is distributed across multiple buffers)" "0,1,2,3"
            newline
            bitfld.long 0x00 8.--11. "TEC,Transmit DMA Extended Packet Buffer or TSO Payload Cache Control When TSO is NOT enabled This field is used to drive arcache_m_o[3:0] signal when Transmit DMA is accessing the extended buffers (when packet is distributed across multiple buffers)" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 6.--7. "Reserved_7_6,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 4.--5. "TDRD,Transmit DMA Read Descriptor Domain Control This field is used to drive ardomain_m_o[1:0] signal when Transmit DMA engines access the Descriptor" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--3. "TDRC,Transmit DMA Read Descriptor Cache Control This field is used to drive arcache_m_o[3:0] signal when Transmit DMA engines access the Descriptor" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x1024++0x03
        line.long 0x00 "AXI4_Rx_AW_ACE_Control,This register is used to control the AXI4 Cache Coherency Signals for write transactions by all the Receive DMA channels"
            rbitfld.long 0x00 30.--31. "Reserved_31_30,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 28.--29. "RDD,Receive DMA Buffer Domain Control This field is used to drive the awdomain_m_o[1:0] signal when Receive DMA is accessing the Buffer when Header and payload are NOT separated" "0,1,2,3"
            newline
            bitfld.long 0x00 24.--27. "RDC,Receive DMA Buffer Cache Control This field is used to drive awcache_m_o[3:0] signal when Receive DMA is accessing the Buffer when Header and payload are NOT separated" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 22.--23. "Reserved_23_22,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 20.--21. "RHD,Receive DMA Header Domain Control This field is used to drive awdomain_m_o[1:0] and signal when Receive DMA is accessing the header Buffer when Header and payload are separated" "0,1,2,3"
            newline
            bitfld.long 0x00 16.--19. "RHC,Receive DMA Header Cache Control This field is used to drive awcache_m_o[3:0] and signal when Receive DMA is accessing the header Buffer when Header and payload are separated" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 14.--15. "Reserved_15_14,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 12.--13. "RPD,Receive DMA Payload Domain Control This field is used to drive awdomain_m_o[1:0] signal when Receive DMA is accessing the Payload Buffer when Header and payload are separated" "0,1,2,3"
            newline
            bitfld.long 0x00 8.--11. "RPC,Receive DMA Payload Cache Control This field is used to drive awcache_m_o[3:0] signal when Receive DMA is accessing the Payload Buffer when Header and payload are separated" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 6.--7. "Reserved_7_6,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 4.--5. "RDWD,Receive DMA Write Descriptor Domain Control This field is used to drive awdomain_m_o[1:0] signal when Receive DMA accesses the Descriptor" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--3. "RDWC,Receive DMA Write Descriptor Cache Control This field is used to drive awcache_m_o[3:0] signal when Receive DMA accesses the Descriptor" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x1028++0x03
        line.long 0x00 "AXI4_TxRx_AWAR_ACE_Control,This register is used to control the AXI4 Cache Coherency Signals for Descriptor write transactions by all the TxDMA channels and Descriptor read transactions by all the RxDMA channels"
            hexmask.long.word 0x00 23.--31. 1. "Reserved_31_23,Reserved"
            newline
            bitfld.long 0x00 20.--22. "WRP,DMA Write Protection control This field is used to drive awprot_m_o[2:0] signal on the AXI Write Channel" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 19. "Reserved_19,Reserved" "0,1"
            newline
            bitfld.long 0x00 16.--18. "RDP,DMA Read Protection control This field is used to drive arprot_m_o[2:0] signal during all read requests" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 14.--15. "Reserved_15_14,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 12.--13. "RDRD,Receive DMA Read Descriptor Domain control This field is used to drive ardomain_m_o[1:0] signal when Receive DMA engines read the Descriptor" "0,1,2,3"
            newline
            bitfld.long 0x00 8.--11. "RDRC,Receive DMA Read Descriptor Cache control This field is used to drive arcache_m_o[3:0] signal when Receive DMA engines read the Descriptor" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 6.--7. "Reserved_7_6,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 4.--5. "TDWD,Transmit DMA Write Descriptor Domain control This field is used to drive awdomain_m_o[1:0] signal when Transmit DMA write to the Descriptor" "0,1,2,3"
            newline
            bitfld.long 0x00 0.--3. "TDWC,Transmit DMA Write Descriptor Cache control This field is used to drive awcache_m_o[3:0] signal when Transmit DMA writes to the Descriptor" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x1040++0x03
        line.long 0x00 "AXI_LPI_Entry_Interval,This register is used to control the AXI LPI entry interval"
            hexmask.long 0x00 4.--31. 1. "Reserved_31_4,Reserved"
            newline
            bitfld.long 0x00 0.--3. "LPIEI,LPI Entry Interval Contains the number of system clock cycles multiplied by 64 to wait for an activity in the DWC_ether_qos to enter into the AXI low power state 0 indicates 64 clock cycles" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
    group.long 0x1050++0x03
        line.long 0x00 "DMA_TBS_CTRL0,This register is used to control the TBS attributes"
            hexmask.long.tbyte 0x00 8.--31. 1. "FTOS,Fetch Time Offset The value in units of 256 ns that has to be deducted from the Launch time to compute the Fetch Time"
            newline
            rbitfld.long 0x00 7. "Reserved_7,Reserved" "0,1"
            newline
            bitfld.long 0x00 4.--6. "FGOS,Fetch GSN Offset The number GSN slots that must be deducted from the Launch GSN to compute the Fetch GSN" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 1.--3. "Reserved_3_1,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0. "FTOV,Fetch Time Offset Valid When set indicates the FTOS field is valid" "0: Fetch Time Offset is invalid,1: Fetch Time Offset is valid"
    repeat 3. (strings "1" "2" "3" )(list 0x00 0x04 0x08 )
        group.long ($2+0x1054)++0x03
            line.long 0x00 "DMA_TBS_CTRL$1,This register is used to control the TBS attributes"
                hexmask.long.tbyte 0x00 8.--31. 1. "FTOS,Fetch Time Offset The value in units of 256 nanoseconds that has to be deducted from the Launch time to compute the Fetch Time"
                newline
                rbitfld.long 0x00 7. "Reserved_7,Reserved" "0,1"
                newline
                bitfld.long 0x00 4.--6. "FGOS,Fetch GSN Offset The number GSN slots that must be deducted from the Launch GSN to compute the Fetch GSN" "0,1,2,3,4,5,6,7"
                newline
                rbitfld.long 0x00 1.--3. "Reserved_3_1,Reserved" "0,1,2,3,4,5,6,7"
                newline
                bitfld.long 0x00 0. "FTOV,Fetch Time Offset Valid When set indicates the FTOS field is valid" "0: Fetch Time Offset is invalid,1: Fetch Time Offset is valid"
    repeat.end

    rgroup.long 0x1080++0x03
        line.long 0x00 "DMA_Safety_Interrupt_Status,This register indicates summary (whether error occurred in DMA/MTL/MAC and correctable/uncorrectable) of the Automotive Safety related error interrupts"
            bitfld.long 0x00 31. "MCSIS,MAC Safety Uncorrectable Interrupt Status Indicates a uncorrectable Safety related Interrupt is set in the MAC module" "0: MAC Safety Uncorrectable Interrupt Status not..,1: MAC Safety Uncorrectable Interrupt Status.."
            newline
            bitfld.long 0x00 30. "Reserved_30,Reserved" "0,1"
            newline
            bitfld.long 0x00 29. "MSUIS,MTL Safety Uncorrectable error Interrupt Status This bit indicates an uncorrectable error interrupt event in MTL" "0: MTL Safety Uncorrectable error Interrupt..,1: MTL Safety Uncorrectable error Interrupt.."
            newline
            bitfld.long 0x00 28. "MSCIS,MTL Safety Correctable error Interrupt Status This bit indicates a correctable error interrupt event in MTL" "0: MTL Safety Correctable error Interrupt Status..,1: MTL Safety Correctable error Interrupt Status.."
            newline
            hexmask.long 0x00 2.--27. 1. "Reserved_27_2,Reserved"
            newline
            bitfld.long 0x00 1. "DEUIS,DMA ECC Uncorrectable error Interrupt Status This bit indicates an interrupt event in the DMA ECC safety feature" "0: DMA ECC Uncorrectable error Interrupt Status..,1: DMA ECC Uncorrectable error Interrupt Status.."
            newline
            bitfld.long 0x00 0. "DECIS,DMA ECC Correctable error Interrupt Status This bit indicates an interrupt event in the DMA ECC safety feature" "0: DMA ECC Correctable error Interrupt Status..,1: DMA ECC Correctable error Interrupt Status.."

    group.long 0x1084++0x03
        line.long 0x00 "DMA_ECC_Interrupt_enable,This register is used to enable the Automotive Safety related TSO memory/DCACHE ECC error interrupt"
            hexmask.long 0x00 2.--31. 1. "Reserved_31_2,Reserved"
            newline
            bitfld.long 0x00 1. "DCEIE,DCACHE memory Correctable Error Interrupt Enable" "0: Does not generates an interrupt,1: Generates an interrupt when a correctable error"
            newline
            bitfld.long 0x00 0. "TCEIE,TSO memory Correctable Error Interrupt Enable" "0: Does not generates an interrupt,1: Generates an interrupt when a correctable error"
    group.long 0x1088++0x03
        line.long 0x00 "DMA_ECC_Interrupt_Status,This register indicates the Automotive Safety related TSO memory/DCACHE memory ECC error interrupt status"
            hexmask.long 0x00 7.--31. 1. "Reserved_31_7,Reserved"
            newline
            bitfld.long 0x00 6. "DUES,DMA DCACHE memory Uncorrectable Error status" "0,1"
            newline
            bitfld.long 0x00 5. "DAMS,DMA DCACHE memory Address Mismatch status" "0,1"
            newline
            bitfld.long 0x00 4. "DCES,DMA DCACHE memory Correctable Error status" "0,1"
            newline
            rbitfld.long 0x00 3. "Reserved_3,Reserved" "0,1"
            newline
            bitfld.long 0x00 2. "TUES,DMA TSO memory Uncorrectable Error status" "0,1"
            newline
            bitfld.long 0x00 1. "TAMS,DMA TSO memory Address Mismatch status" "0,1"
            newline
            bitfld.long 0x00 0. "TCES,DMA TSO memory Correctable Error status" "0,1"
    group.long 0x1100++0x03
        line.long 0x00 "DMA_CH0_Control,The DMA Channel0 Control register specifies the MSS value for segmentation length to skip between two descriptors and also the features such as header splitting and 8xPBL mode"
            hexmask.long.byte 0x00 25.--31. 1. "Reserved_31_25,Reserved"
            newline
            bitfld.long 0x00 24. "SPH,Split Headers" "0: Split Headers feature is disabled,1: Split Headers feature is enabled"
            newline
            rbitfld.long 0x00 21.--23. "Reserved_23_21,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 18.--20. "DSL,Descriptor Skip Length This bit specifies the Dword (64-bit) number of locations to skip between two descriptors" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 17. "Reserved_17,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "PBLx8,8xPBL mode" "0: 8xPBL mode is disabled,1: 8xPBL mode is enabled"
            newline
            rbitfld.long 0x00 14.--15. "Reserved_15_14,Reserved" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--13. 1. "MSS,Maximum Segment Size This field specifies the maximum segment size that must be used while segmenting the packet"
    group.long 0x1104++0x03
        line.long 0x00 "DMA_CH0_Tx_Control,The DMA Channel0 Transmit Control register controls the Tx features such as PBL TCP segmentation and Tx Channel weights"
            rbitfld.long 0x00 31. "Reserved_31,Reserved" "0,1"
            newline
            bitfld.long 0x00 29.--30. "TFSEL,TBS Fetch Select Select bits for one of the four DMA_TBS_CTRL register fields (FTOS FGSN FTOV) for the channel Values" "0: DMA_TBS_CTRL0,1: DMA_TBS_CTRL1,2: DMA_TBS_CTRL2,3: DMA_TBS_CTRL3 (Reserved if"
            newline
            bitfld.long 0x00 28. "EDSE,Enhanced Descriptor Enable" "0: Enhanced Descriptor is disabled,1: Enhanced Descriptor is enabled"
            newline
            bitfld.long 0x00 24.--27. "TQOS,Transmit QOS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 23. "Reserved_23,Reserved" "0,1"
            newline
            rbitfld.long 0x00 22. "Reserved_ETIC,Reserved" "0,1"
            newline
            bitfld.long 0x00 16.--21. "TxPBL,Transmit Programmable Burst Length These bits indicate the maximum number of beats to be transferred in one DMA block data transfer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 15. "IPBL,Ignore PBL Requirement" "0: Ignore PBL Requirement is disabled,1: Ignore PBL Requirement is enabled"
            newline
            bitfld.long 0x00 13.--14. "TSE_MODE,TSE Mode" "0: TSO_USO,1: UFO with Checksum,2: UFO without Checksum,?..."
            newline
            bitfld.long 0x00 12. "TSE,TCP Segmentation Enabled" "0: TCP Segmentation is disabled,1: TCP Segmentation is enabled"
            newline
            hexmask.long.byte 0x00 5.--11. 1. "Reserved_11_5,Reserved"
            newline
            bitfld.long 0x00 4. "OSF,Operate on Second Packet" "0: Operate on Second Packet disabled,1: Operate on Second Packet enabled"
            newline
            bitfld.long 0x00 1.--3. "TCW,Transmit Channel Weight This field indicates the weight assigned to the corresponding Tx channel" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0. "ST,Start or Stop Transmission Command" "0: Stop Transmission Command,1: Start Transmission Command"
    group.long 0x1108++0x03
        line.long 0x00 "DMA_CH0_Rx_Control,The DMA Channel0 Receive Control register controls the Rx features such as PBL buffer size and extended status"
            bitfld.long 0x00 31. "RPF,Rx Packet Flush" "0: Rx Packet Flush is disabled,1: Rx Packet Flush is enabled"
            newline
            rbitfld.long 0x00 28.--30. "Reserved_30_28,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 24.--27. "RQOS,Rx AXI4 QOS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 23. "Reserved_23,Reserved" "0,1"
            newline
            rbitfld.long 0x00 22. "Reserved_ERIC,Reserved" "0,1"
            newline
            bitfld.long 0x00 16.--21. "RxPBL,Receive Programmable Burst Length These bits indicate the maximum number of beats to be transferred in one DMA block data transfer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            rbitfld.long 0x00 15. "Reserved_15,Reserved" "0,1"
            newline
            hexmask.long.word 0x00 4.--14. 1. "RBSZ_13_y,Receive Buffer size High RBSZ[13:0] is split into two fields higher RBSZ_13_y and lower RBSZ_x_0"
            newline
            rbitfld.long 0x00 1.--3. "RBSZ_x_0,Receive Buffer size Low RBSZ[13:0] is split into two fields RBSZ_13_y and RBSZ_x_0" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0. "SR,Start or Stop Receive" "0: Stop Receive,1: Start Receive"
    group.long 0x1114++0x03
        line.long 0x00 "DMA_CH0_TxDesc_List_Address,The Channel0 Tx Descriptor List Address register points the DMA to the start of Transmit descriptor list"
            hexmask.long 0x00 3.--31. 1. "TDESLA,Start of Transmit List This field contains the base address of the first descriptor in the Transmit descriptor list"
            newline
            rbitfld.long 0x00 0.--2. "Reserved_LSb,Reserved" "0,1,2,3,4,5,6,7"
    group.long 0x111C++0x03
        line.long 0x00 "DMA_CH0_RxDesc_List_Address,The Channel0 Rx Descriptor List Address register points the DMA to the start of Receive descriptor list"
            hexmask.long 0x00 3.--31. 1. "RDESLA,Start of Receive List This field contains the base address of the first descriptor in the Rx Descriptor list"
            newline
            rbitfld.long 0x00 0.--2. "Reserved_LSb,Reserved" "0,1,2,3,4,5,6,7"
    group.long 0x1120++0x03
        line.long 0x00 "DMA_CH0_TxDesc_Tail_Pointer,The Channel0 Tx Descriptor Tail Pointer register points to an offset from the base and indicates the location of the last valid descriptor"
            hexmask.long 0x00 3.--31. 1. "TDTP,Transmit Descriptor Tail Pointer This field contains the tail pointer for the Tx descriptor ring"
            newline
            rbitfld.long 0x00 0.--2. "Reserved_LSb,Reserved" "0,1,2,3,4,5,6,7"
    group.long 0x1128++0x03
        line.long 0x00 "DMA_CH0_RxDesc_Tail_Pointer,The Channel0 Rx Descriptor Tail Pointer Points to an offset from the base and indicates the location of the last valid descriptor"
            hexmask.long 0x00 3.--31. 1. "RDTP,Receive Descriptor Tail Pointer This field contains the tail pointer for the Rx descriptor ring"
            newline
            rbitfld.long 0x00 0.--2. "Reserved_LSb,Reserved" "0,1,2,3,4,5,6,7"
    group.long 0x112C++0x03
        line.long 0x00 "DMA_CH0_TxDesc_Ring_Length,The Tx Descriptor Ring Length register contains the length of the Transmit descriptor ring"
            hexmask.long.tbyte 0x00 10.--31. 1. "Reserved_31_10,Reserved"
            newline
            hexmask.long.word 0x00 0.--9. 1. "TDRL,Transmit Descriptor Ring Length This field sets the maximum number of Tx descriptors in the circular descriptor ring"
    group.long 0x1130++0x03
        line.long 0x00 "DMA_CH0_Rx_Control2,The Channel0 Receive Control register controls the Rx features such as Rx Descriptor Ring Length and Alternate Rx Buffer Size"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_31_24,Reserved"
            newline
            hexmask.long.byte 0x00 17.--23. 1. "ARBS,Alternate Receive Buffer Size Indicates size in bytes for Buffer 1 when ARBS is programmed to a non-zero value (when split header feature is not enabled)"
            newline
            hexmask.long.byte 0x00 10.--16. 1. "Reserved_x_10,Reserved"
            newline
            hexmask.long.word 0x00 0.--9. 1. "RDRL,Receive Descriptor Ring Length This register sets the maximum number of Rx descriptors in the circular descriptor ring"
    group.long 0x1134++0x03
        line.long 0x00 "DMA_CH0_Interrupt_Enable,The Channel0 Interrupt Enable register enables the interrupts reported by the Status register"
            hexmask.long.word 0x00 16.--31. 1. "Reserved_31_16,Reserved"
            newline
            bitfld.long 0x00 15. "NIE,Normal Interrupt Summary Enable When this bit is set the normal interrupt summary is enabled" "0: Normal Interrupt Summary is disabled,1: Normal Interrupt Summary is enabled"
            newline
            bitfld.long 0x00 14. "AIE,Abnormal Interrupt Summary Enable When this bit is set the abnormal interrupt summary is enabled" "0: Abnormal Interrupt Summary is disabled,1: Abnormal Interrupt Summary is enabled"
            newline
            bitfld.long 0x00 13. "CDEE,Context Descriptor Error Enable When this bit is set along with the AIE bit the Descriptor error interrupt is enabled" "0: Context Descriptor Error is disabled,1: Context Descriptor Error is enabled"
            newline
            bitfld.long 0x00 12. "FBEE,Fatal Bus Error Enable When this bit is set along with the AIE bit the Fatal Bus error interrupt is enabled" "0: Fatal Bus Error is disabled,1: Fatal Bus Error is enabled"
            newline
            bitfld.long 0x00 11. "ERIE,Early Receive Interrupt Enable When this bit is set along with the NIE bit the Early Receive interrupt is enabled" "0: Early Receive Interrupt is disabled,1: Early Receive Interrupt is enabled"
            newline
            bitfld.long 0x00 10. "ETIE,Early Transmit Interrupt Enable When this bit is set along with the AIE bit the Early Transmit interrupt is enabled" "0: Early Transmit Interrupt is disabled,1: Early Transmit Interrupt is enabled"
            newline
            bitfld.long 0x00 9. "RWTE,Receive Watchdog Timeout Enable When this bit is set along with the AIE bit the Receive Watchdog Timeout interrupt is enabled" "0: Receive Watchdog Timeout is disabled,1: Receive Watchdog Timeout is enabled"
            newline
            bitfld.long 0x00 8. "RSE,Receive Stopped Enable When this bit is set along with the AIE bit the Receive Stopped Interrupt is enabled" "0: Receive Stopped is disabled,1: Receive Stopped is enabled"
            newline
            bitfld.long 0x00 7. "RBUE,Receive Buffer Unavailable Enable When this bit is set along with the AIE bit the Receive Buffer Unavailable interrupt is enabled" "0: Receive Buffer Unavailable is disabled,1: Receive Buffer Unavailable is enabled"
            newline
            bitfld.long 0x00 6. "RIE,Receive Interrupt Enable When this bit is set along with the NIE bit the Receive Interrupt is enabled" "0: Receive Interrupt is disabled,1: Receive Interrupt is enabled"
            newline
            rbitfld.long 0x00 3.--5. "Reserved_5_3,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 2. "TBUE,Transmit Buffer Unavailable Enable When this bit is set along with the NIE bit the Transmit Buffer Unavailable interrupt is enabled" "0: Transmit Buffer Unavailable is disabled,1: Transmit Buffer Unavailable is enabled"
            newline
            bitfld.long 0x00 1. "TXSE,Transmit Stopped Enable When this bit is set along with the AIE bit the Transmission Stopped interrupt is enabled" "0: Transmit Stopped is disabled,1: Transmit Stopped is enabled"
            newline
            bitfld.long 0x00 0. "TIE,Transmit Interrupt Enable When this bit is set along with the NIE bit the Transmit Interrupt is enabled" "0: Transmit Interrupt is disabled,1: Transmit Interrupt is enabled"
    group.long 0x1138++0x03
        line.long 0x00 "DMA_CH0_Rx_Interrupt_Watchdog_Timer,The Receive Interrupt Watchdog Timer register indicates the watchdog timeout for Receive Interrupt (RI) from the DMA"
            hexmask.long.word 0x00 18.--31. 1. "Reserved_31_18,Reserved"
            newline
            bitfld.long 0x00 16.--17. "RWTU,Receive Interrupt Watchdog Timer Count Units This fields indicates the number of system clock cycles corresponding to one unit in RWT field" "0: ,1: ,2: ,3: 2048 For"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "Reserved_15_8,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "RWT,Receive Interrupt Watchdog Timer Count This field indicates the number of system clock cycles multiplied by factor indicated in RWTU field for which the watchdog timer is set"
    group.long 0x113C++0x03
        line.long 0x00 "DMA_CH0_Slot_Function_Control_Status,The Slot Function Control and Status register contains the control bits for slot function and the status for Transmit path"
            hexmask.long.word 0x00 20.--31. 1. "Reserved_31_20,Reserved"
            newline
            rbitfld.long 0x00 16.--19. "RSN,Reference Slot Number This field gives the current value of the reference slot number in the DMA" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.word 0x00 4.--15. 1. "SIV,Slot Interval Value This field controls the period of the slot interval in which the TxDMA fetches the scheduled packets"
            newline
            rbitfld.long 0x00 2.--3. "Reserved_3_2,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 1. "ASC,Advance Slot Check When set this bit enables the DMA to fetch the data from the buffer when the slot number (SLOTNUM) programmed in the Tx descriptor is - equal to the reference slot number given in the RSN field or - ahead of the reference slot.." "0: Advance Slot Check is disabled,1: Advance Slot Check is enabled"
            newline
            bitfld.long 0x00 0. "ESC,Enable Slot Comparison When set this bit enables the checking of the slot numbers programmed in the Tx descriptor with the current reference given in the RSN field" "0: Slot Comparison is disabled,1: Slot Comparison is enabled"

    rgroup.long 0x1144++0x03
        line.long 0x00 "DMA_CH0_Current_App_TxDesc,The Channel0 Current Application Transmit Descriptor register points to the current Transmit descriptor read by the DMA"
            hexmask.long 0x00 0.--31. 1. "CURTDESAPTR,Application Transmit Descriptor Address Pointer The DMA updates this pointer during Tx operation"
    rgroup.long 0x114C++0x03
        line.long 0x00 "DMA_CH0_Current_App_RxDesc,The Channel0 Current Application Receive Descriptor register points to the current Receive descriptor read by the DMA"
            hexmask.long 0x00 0.--31. 1. "CURRDESAPTR,Application Receive Descriptor Address Pointer The DMA updates this pointer during Rx operation"
    rgroup.long 0x1154++0x03
        line.long 0x00 "DMA_CH0_Current_App_TxBuffer,The Channel0 Current Application Transmit Buffer Address register points to the current Tx buffer address read by the DMA"
            hexmask.long 0x00 0.--31. 1. "CURTBUFAPTR,Application Transmit Buffer Address Pointer The DMA updates this pointer during Tx operation"
    rgroup.long 0x115C++0x03
        line.long 0x00 "DMA_CH0_Current_App_RxBuffer,The Channel 0 Current Application Receive Buffer Address register points to the current Rx buffer address read by the DMA"
            hexmask.long 0x00 0.--31. 1. "CURRBUFAPTR,Application Receive Buffer Address Pointer The DMA updates this pointer during Rx operation"

    group.long 0x1160++0x03
        line.long 0x00 "DMA_CH0_Status,The software driver (application) reads the Status register during interrupt service routine or polling to determine the status of the DMA"
            hexmask.long.word 0x00 22.--31. 1. "Reserved_31_22,Reserved"
            newline
            rbitfld.long 0x00 19.--21. "REB,Rx DMA Error Bits This field indicates the type of error that caused a Bus Error" "0: Error during write transfer This field is valid,1: Error during read transfer,?..."
            newline
            rbitfld.long 0x00 16.--18. "TEB,Tx DMA Error Bits This field indicates the type of error that caused a Bus Error" "0: Error during write transfer This field is valid,1: Error during read transfer,?..."
            newline
            bitfld.long 0x00 15. "NIS,Normal Interrupt Summary Normal Interrupt Summary bit value is the logical OR of the following bits when the corresponding interrupt bits are enabled in the DMA_CH0_Interrupt_Enable register: - Bit" "0: Normal Interrupt Summary status not detected,1: Normal Interrupt Summary status detected"
            newline
            bitfld.long 0x00 14. "AIS,Abnormal Interrupt Summary Abnormal Interrupt Summary bit value is the logical OR of the following when the corresponding interrupt bits are enabled in the DMA_CH0_Interrupt_Enable register: - Bit" "0: Abnormal Interrupt Summary status not detected,1: Abnormal Interrupt Summary status detected"
            newline
            bitfld.long 0x00 13. "CDE,Context Descriptor Error This bit indicates that the DMA Tx/Rx engine received a descriptor error which indicates invalid context in the middle of packet flow ( intermediate descriptor) or all one's descriptor in Tx case and on Rx side it indicates.." "0: Context Descriptor Error status not detected,1: Context Descriptor Error status detected"
            newline
            bitfld.long 0x00 12. "FBE,Fatal Bus Error This bit indicates that a bus error occurred (as described in the EB field)" "0: Fatal Bus Error status not detected,1: Fatal Bus Error status detected"
            newline
            bitfld.long 0x00 11. "ERI,Early Receive Interrupt This bit when set indicates that the RxDMA has completed the transfer of packet data to the memory" "0: Early Receive Interrupt status not detected,1: Early Receive Interrupt status detected"
            newline
            bitfld.long 0x00 10. "ETI,Early Transmit Interrupt This bit when set indicates that the TxDMA has completed the transfer of packet data to the MTL TXFIFO memory" "0: Early Transmit Interrupt status not detected,1: Early Transmit Interrupt status detected"
            newline
            bitfld.long 0x00 9. "RWT,Receive Watchdog Timeout This bit is asserted when a packet with length greater than 2 048 bytes (10 240 bytes when Jumbo Packet mode is enabled) is received" "0: Receive Watchdog Timeout status not detected,1: Receive Watchdog Timeout status detected"
            newline
            bitfld.long 0x00 8. "RPS,Receive Process Stopped This bit is asserted when the Rx process enters the Stopped state" "0: Receive Process Stopped status not detected,1: Receive Process Stopped status detected"
            newline
            bitfld.long 0x00 7. "RBU,Receive Buffer Unavailable This bit indicates that the application owns the next descriptor in the Receive list and the DMA cannot acquire it" "0: Receive Buffer Unavailable status not detected,1: Receive Buffer Unavailable status detected"
            newline
            bitfld.long 0x00 6. "RI,Receive Interrupt This bit indicates that the packet reception is complete" "0: Receive Interrupt status not detected,1: Receive Interrupt status detected"
            newline
            rbitfld.long 0x00 3.--5. "Reserved_5_3,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 2. "TBU,Transmit Buffer Unavailable This bit indicates that the application owns the next descriptor in the Transmit list and the DMA cannot acquire it" "0: Transmit Buffer Unavailable status not detected,1: Transmit Buffer Unavailable status detected"
            newline
            bitfld.long 0x00 1. "TPS,Transmit Process Stopped This bit is set when the transmission is stopped" "0: Transmit Process Stopped status not detected,1: Transmit Process Stopped status detected"
            newline
            bitfld.long 0x00 0. "TI,Transmit Interrupt This bit indicates that the packet transmission is complete" "0: Transmit Interrupt status not detected,1: Transmit Interrupt status detected"

    rgroup.long 0x1164++0x03
        line.long 0x00 "DMA_CH0_Miss_Frame_Cnt,This register has the number of packet counter that got dropped by the DMA either due to Bus Error or due to programming RPF field in DMA_CH0_Rx_Control register"
            hexmask.long.word 0x00 16.--31. 1. "Reserved_31_16,Reserved"
            newline
            bitfld.long 0x00 15. "MFCO,Overflow status of the MFC Counter When this bit is set then the MFC counter does not get incremented further" "0: Miss Frame Counter overflow not occurred,1: Miss Frame Counter overflow occurred"
            newline
            bitfld.long 0x00 11.--14. "Reserved_14_11,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.word 0x00 0.--10. 1. "MFC,Dropped Packet Counters This counter indicates the number of packet counters that are dropped by the DMA either because of bus error or because of programing RPF field in DMA_CH0_Rx_Control register"

    group.long 0x1180++0x03
        line.long 0x00 "DMA_CH1_Control,The DMA Channel1 Control register specifies the MSS value for segmentation length to skip between two descriptors and also the features such as header splitting and 8xPBL mode"
            hexmask.long.byte 0x00 25.--31. 1. "Reserved_31_25,Reserved"
            newline
            bitfld.long 0x00 24. "SPH,Split Headers" "0: Split Headers feature is disabled,1: Split Headers feature is enabled"
            newline
            rbitfld.long 0x00 21.--23. "Reserved_23_21,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 18.--20. "DSL,Descriptor Skip Length This bit specifies the Dword (64-bit) number of locations to skip between two descriptors" "0,1,2,3,4,5,6,7"
            newline
            rbitfld.long 0x00 17. "Reserved_17,Reserved" "0,1"
            newline
            bitfld.long 0x00 16. "PBLx8,8xPBL mode" "0: 8xPBL mode is disabled,1: 8xPBL mode is enabled"
            newline
            rbitfld.long 0x00 14.--15. "Reserved_15_14,Reserved" "0,1,2,3"
            newline
            hexmask.long.word 0x00 0.--13. 1. "MSS,Maximum Segment Size This field specifies the maximum segment size that must be used while segmenting the packet"
    group.long 0x1184++0x03
        line.long 0x00 "DMA_CH1_Tx_Control,The DMA Channel1 Transmit Control register controls the Tx features such as PBL TCP segmentation and Tx Channel weights"
            rbitfld.long 0x00 31. "Reserved_31,Reserved" "0,1"
            newline
            bitfld.long 0x00 29.--30. "TFSEL,TBS Fetch Select Select bits for one of the four DMA_TBS_CTRL register fields (FTOS FGSN FTOV) for the channel Values" "0: DMA_TBS_CTRL0,1: DMA_TBS_CTRL1,2: DMA_TBS_CTRL2,3: DMA_TBS_CTRL3 (Reserved if"
            newline
            bitfld.long 0x00 28. "EDSE,Enhanced Descriptor Enable" "0: Enhanced Descriptor is disabled,1: Enhanced Descriptor is enabled"
            newline
            bitfld.long 0x00 24.--27. "TQOS,Transmit QOS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 23. "Reserved_23,Reserved" "0,1"
            newline
            rbitfld.long 0x00 22. "Reserved_ETIC,Reserved" "0,1"
            newline
            bitfld.long 0x00 16.--21. "TxPBL,Transmit Programmable Burst Length These bits indicate the maximum number of beats to be transferred in one DMA block data transfer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            bitfld.long 0x00 15. "IPBL,Ignore PBL Requirement" "0: Ignore PBL Requirement is disabled,1: Ignore PBL Requirement is enabled"
            newline
            bitfld.long 0x00 13.--14. "TSE_MODE,TSE Mode" "0: TSO_USO,1: UFO with Checksum,2: UFO without Checksum,?..."
            newline
            bitfld.long 0x00 12. "TSE,TCP Segmentation Enabled" "0: TCP Segmentation is disabled,1: TCP Segmentation is enabled"
            newline
            hexmask.long.byte 0x00 5.--11. 1. "Reserved_11_5,Reserved"
            newline
            bitfld.long 0x00 4. "OSF,Operate on Second Packet" "0: Operate on Second Packet disabled,1: Operate on Second Packet enabled"
            newline
            bitfld.long 0x00 1.--3. "TCW,Transmit Channel Weight This field indicates the weight assigned to the corresponding Tx channel" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0. "ST,Start or Stop Transmission Command" "0: Stop Transmission Command,1: Start Transmission Command"
    group.long 0x1188++0x03
        line.long 0x00 "DMA_CH1_Rx_Control,The DMA Channel1 Receive Control register controls the Rx features such as PBL buffer size and extended status"
            bitfld.long 0x00 31. "RPF,Rx Packet Flush" "0: Rx Packet Flush is disabled,1: Rx Packet Flush is enabled"
            newline
            rbitfld.long 0x00 28.--30. "Reserved_30_28,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 24.--27. "RQOS,Rx AXI4 QOS" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            rbitfld.long 0x00 23. "Reserved_23,Reserved" "0,1"
            newline
            rbitfld.long 0x00 22. "Reserved_ERIC,Reserved" "0,1"
            newline
            bitfld.long 0x00 16.--21. "RxPBL,Receive Programmable Burst Length These bits indicate the maximum number of beats to be transferred in one DMA block data transfer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63"
            newline
            rbitfld.long 0x00 15. "Reserved_15,Reserved" "0,1"
            newline
            hexmask.long.word 0x00 4.--14. 1. "RBSZ_13_y,Receive Buffer size High RBSZ[13:0] is split into two fields higher RBSZ_13_y and lower RBSZ_x_0"
            newline
            rbitfld.long 0x00 1.--3. "RBSZ_x_0,Receive Buffer size Low RBSZ[13:0] is split into two fields RBSZ_13_y and RBSZ_x_0" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 0. "SR,Start or Stop Receive" "0: Stop Receive,1: Start Receive"
    group.long 0x1194++0x03
        line.long 0x00 "DMA_CH1_TxDesc_List_Address,The Channel1 Tx Descriptor List Address register points the DMA to the start of Transmit descriptor list"
            hexmask.long 0x00 3.--31. 1. "TDESLA,Start of Transmit List This field contains the base address of the first descriptor in the Transmit descriptor list"
            newline
            rbitfld.long 0x00 0.--2. "Reserved_LSb,Reserved" "0,1,2,3,4,5,6,7"
    group.long 0x119C++0x03
        line.long 0x00 "DMA_CH1_RxDesc_List_Address,The Channel1 Rx Descriptor List Address register points the DMA to the start of Receive descriptor list"
            hexmask.long 0x00 3.--31. 1. "RDESLA,Start of Receive List This field contains the base address of the first descriptor in the Rx Descriptor list"
            newline
            rbitfld.long 0x00 0.--2. "Reserved_LSb,Reserved" "0,1,2,3,4,5,6,7"
    group.long 0x11A0++0x03
        line.long 0x00 "DMA_CH1_TxDesc_Tail_Pointer,The Channel1 Tx Descriptor Tail Pointer register points to an offset from the base and indicates the location of the last valid descriptor"
            hexmask.long 0x00 3.--31. 1. "TDTP,Transmit Descriptor Tail Pointer This field contains the tail pointer for the Tx descriptor ring"
            newline
            rbitfld.long 0x00 0.--2. "Reserved_LSb,Reserved" "0,1,2,3,4,5,6,7"
    group.long 0x11A8++0x03
        line.long 0x00 "DMA_CH1_RxDesc_Tail_Pointer,The Channel1 Rx Descriptor Tail Pointer Points to an offset from the base and indicates the location of the last valid descriptor"
            hexmask.long 0x00 3.--31. 1. "RDTP,Receive Descriptor Tail Pointer This field contains the tail pointer for the Rx descriptor ring"
            newline
            rbitfld.long 0x00 0.--2. "Reserved_LSb,Reserved" "0,1,2,3,4,5,6,7"
    group.long 0x11AC++0x03
        line.long 0x00 "DMA_CH1_TxDesc_Ring_Length,The Tx Descriptor Ring Length register contains the length of the Transmit descriptor ring"
            hexmask.long.tbyte 0x00 10.--31. 1. "Reserved_31_10,Reserved"
            newline
            hexmask.long.word 0x00 0.--9. 1. "TDRL,Transmit Descriptor Ring Length This field sets the maximum number of Tx descriptors in the circular descriptor ring"
    group.long 0x11B0++0x03
        line.long 0x00 "DMA_CH1_Rx_Control2,The Channel1 Receive Control register controls the Rx features such as Rx Descriptor Ring Length and Alternate Rx Buffer Size"
            hexmask.long.byte 0x00 24.--31. 1. "Reserved_31_24,Reserved"
            newline
            hexmask.long.byte 0x00 17.--23. 1. "ARBS,Alternate Receive Buffer Size Indicates size in bytes for Buffer 1 when ARBS is programmed to a non-zero value (when split header feature is not enabled)"
            newline
            hexmask.long.byte 0x00 10.--16. 1. "Reserved_x_10,Reserved"
            newline
            hexmask.long.word 0x00 0.--9. 1. "RDRL,Receive Descriptor Ring Length This register sets the maximum number of Rx descriptors in the circular descriptor ring"
    group.long 0x11B4++0x03
        line.long 0x00 "DMA_CH1_Interrupt_Enable,The Channel1 Interrupt Enable register enables the interrupts reported by the Status register"
            hexmask.long.word 0x00 16.--31. 1. "Reserved_31_16,Reserved"
            newline
            bitfld.long 0x00 15. "NIE,Normal Interrupt Summary Enable When this bit is set the normal interrupt summary is enabled" "0: Normal Interrupt Summary is disabled,1: Normal Interrupt Summary is enabled"
            newline
            bitfld.long 0x00 14. "AIE,Abnormal Interrupt Summary Enable When this bit is set the abnormal interrupt summary is enabled" "0: Abnormal Interrupt Summary is disabled,1: Abnormal Interrupt Summary is enabled"
            newline
            bitfld.long 0x00 13. "CDEE,Context Descriptor Error Enable When this bit is set along with the AIE bit the Descriptor error interrupt is enabled" "0: Context Descriptor Error is disabled,1: Context Descriptor Error is enabled"
            newline
            bitfld.long 0x00 12. "FBEE,Fatal Bus Error Enable When this bit is set along with the AIE bit the Fatal Bus error interrupt is enabled" "0: Fatal Bus Error is disabled,1: Fatal Bus Error is enabled"
            newline
            bitfld.long 0x00 11. "ERIE,Early Receive Interrupt Enable When this bit is set along with the NIE bit the Early Receive interrupt is enabled" "0: Early Receive Interrupt is disabled,1: Early Receive Interrupt is enabled"
            newline
            bitfld.long 0x00 10. "ETIE,Early Transmit Interrupt Enable When this bit is set along with the AIE bit the Early Transmit interrupt is enabled" "0: Early Transmit Interrupt is disabled,1: Early Transmit Interrupt is enabled"
            newline
            bitfld.long 0x00 9. "RWTE,Receive Watchdog Timeout Enable When this bit is set along with the AIE bit the Receive Watchdog Timeout interrupt is enabled" "0: Receive Watchdog Timeout is disabled,1: Receive Watchdog Timeout is enabled"
            newline
            bitfld.long 0x00 8. "RSE,Receive Stopped Enable When this bit is set along with the AIE bit the Receive Stopped Interrupt is enabled" "0: Receive Stopped is disabled,1: Receive Stopped is enabled"
            newline
            bitfld.long 0x00 7. "RBUE,Receive Buffer Unavailable Enable When this bit is set along with the AIE bit the Receive Buffer Unavailable interrupt is enabled" "0: Receive Buffer Unavailable is disabled,1: Receive Buffer Unavailable is enabled"
            newline
            bitfld.long 0x00 6. "RIE,Receive Interrupt Enable When this bit is set along with the NIE bit the Receive Interrupt is enabled" "0: Receive Interrupt is disabled,1: Receive Interrupt is enabled"
            newline
            rbitfld.long 0x00 3.--5. "Reserved_5_3,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 2. "TBUE,Transmit Buffer Unavailable Enable When this bit is set along with the NIE bit the Transmit Buffer Unavailable interrupt is enabled" "0: Transmit Buffer Unavailable is disabled,1: Transmit Buffer Unavailable is enabled"
            newline
            bitfld.long 0x00 1. "TXSE,Transmit Stopped Enable When this bit is set along with the AIE bit the Transmission Stopped interrupt is enabled" "0: Transmit Stopped is disabled,1: Transmit Stopped is enabled"
            newline
            bitfld.long 0x00 0. "TIE,Transmit Interrupt Enable When this bit is set along with the NIE bit the Transmit Interrupt is enabled" "0: Transmit Interrupt is disabled,1: Transmit Interrupt is enabled"
    group.long 0x11B8++0x03
        line.long 0x00 "DMA_CH1_Rx_Interrupt_Watchdog_Timer,The Receive Interrupt Watchdog Timer register indicates the watchdog timeout for Receive Interrupt (RI) from the DMA"
            hexmask.long.word 0x00 18.--31. 1. "Reserved_31_18,Reserved"
            newline
            bitfld.long 0x00 16.--17. "RWTU,Receive Interrupt Watchdog Timer Count Units This fields indicates the number of system clock cycles corresponding to one unit in RWT field" "0: ,1: ,2: ,3: 2048 For"
            newline
            hexmask.long.byte 0x00 8.--15. 1. "Reserved_15_8,Reserved"
            newline
            hexmask.long.byte 0x00 0.--7. 1. "RWT,Receive Interrupt Watchdog Timer Count This field indicates the number of system clock cycles multiplied by factor indicated in RWTU field for which the watchdog timer is set"
    group.long 0x11BC++0x03
        line.long 0x00 "DMA_CH1_Slot_Function_Control_Status,The Slot Function Control and Status register contains the control bits for slot function and the status for Transmit path"
            hexmask.long.word 0x00 20.--31. 1. "Reserved_31_20,Reserved"
            newline
            rbitfld.long 0x00 16.--19. "RSN,Reference Slot Number This field gives the current value of the reference slot number in the DMA" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.word 0x00 4.--15. 1. "SIV,Slot Interval Value This field controls the period of the slot interval in which the TxDMA fetches the scheduled packets"
            newline
            rbitfld.long 0x00 2.--3. "Reserved_3_2,Reserved" "0,1,2,3"
            newline
            bitfld.long 0x00 1. "ASC,Advance Slot Check When set this bit enables the DMA to fetch the data from the buffer when the slot number (SLOTNUM) programmed in the Tx descriptor is - equal to the reference slot number given in the RSN field or - ahead of the reference slot.." "0: Advance Slot Check is disabled,1: Advance Slot Check is enabled"
            newline
            bitfld.long 0x00 0. "ESC,Enable Slot Comparison When set this bit enables the checking of the slot numbers programmed in the Tx descriptor with the current reference given in the RSN field" "0: Slot Comparison is disabled,1: Slot Comparison is enabled"

    rgroup.long 0x11C4++0x03
        line.long 0x00 "DMA_CH1_Current_App_TxDesc,The Channel1 Current Application Transmit Descriptor register points to the current Transmit descriptor read by the DMA"
            hexmask.long 0x00 0.--31. 1. "CURTDESAPTR,Application Transmit Descriptor Address Pointer The DMA updates this pointer during Tx operation"
    rgroup.long 0x11CC++0x03
        line.long 0x00 "DMA_CH1_Current_App_RxDesc,The Channel1 Current Application Receive Descriptor register points to the current Receive descriptor read by the DMA"
            hexmask.long 0x00 0.--31. 1. "CURRDESAPTR,Application Receive Descriptor Address Pointer The DMA updates this pointer during Rx operation"
    rgroup.long 0x11D4++0x03
        line.long 0x00 "DMA_CH1_Current_App_TxBuffer,The Channel1 Current Application Transmit Buffer Address register points to the current Tx buffer address read by the DMA"
            hexmask.long 0x00 0.--31. 1. "CURTBUFAPTR,Application Transmit Buffer Address Pointer The DMA updates this pointer during Tx operation"
    rgroup.long 0x11DC++0x03
        line.long 0x00 "DMA_CH1_Current_App_RxBuffer,The Channel 1 Current Application Receive Buffer Address register points to the current Rx buffer address read by the DMA"
            hexmask.long 0x00 0.--31. 1. "CURRBUFAPTR,Application Receive Buffer Address Pointer The DMA updates this pointer during Rx operation"

    group.long 0x11E0++0x03
        line.long 0x00 "DMA_CH1_Status,The software driver (application) reads the Status register during interrupt service routine or polling to determine the status of the DMA"
            hexmask.long.word 0x00 22.--31. 1. "Reserved_31_22,Reserved"
            newline
            rbitfld.long 0x00 19.--21. "REB,Rx DMA Error Bits This field indicates the type of error that caused a Bus Error" "0: Error during write transfer This field is valid,1: Error during read transfer,?..."
            newline
            rbitfld.long 0x00 16.--18. "TEB,Tx DMA Error Bits This field indicates the type of error that caused a Bus Error" "0: Error during write transfer This field is valid,1: Error during read transfer,?..."
            newline
            bitfld.long 0x00 15. "NIS,Normal Interrupt Summary Normal Interrupt Summary bit value is the logical OR of the following bits when the corresponding interrupt bits are enabled in the DMA_CH1_Interrupt_Enable register: - Bit" "0: Normal Interrupt Summary status not detected,1: Normal Interrupt Summary status detected"
            newline
            bitfld.long 0x00 14. "AIS,Abnormal Interrupt Summary Abnormal Interrupt Summary bit value is the logical OR of the following when the corresponding interrupt bits are enabled in the DMA_CH1_Interrupt_Enable register: - Bit" "0: Abnormal Interrupt Summary status not detected,1: Abnormal Interrupt Summary status detected"
            newline
            bitfld.long 0x00 13. "CDE,Context Descriptor Error This bit indicates that the DMA Tx/Rx engine received a descriptor error which indicates invalid context in the middle of packet flow ( intermediate descriptor) or all one's descriptor in Tx case and on Rx side it indicates.." "0: Context Descriptor Error status not detected,1: Context Descriptor Error status detected"
            newline
            bitfld.long 0x00 12. "FBE,Fatal Bus Error This bit indicates that a bus error occurred (as described in the EB field)" "0: Fatal Bus Error status not detected,1: Fatal Bus Error status detected"
            newline
            bitfld.long 0x00 11. "ERI,Early Receive Interrupt This bit when set indicates that the RxDMA has completed the transfer of packet data to the memory" "0: Early Receive Interrupt status not detected,1: Early Receive Interrupt status detected"
            newline
            bitfld.long 0x00 10. "ETI,Early Transmit Interrupt This bit when set indicates that the TxDMA has completed the transfer of packet data to the MTL TXFIFO memory" "0: Early Transmit Interrupt status not detected,1: Early Transmit Interrupt status detected"
            newline
            bitfld.long 0x00 9. "RWT,Receive Watchdog Timeout This bit is asserted when a packet with length greater than 2 048 bytes (10 240 bytes when Jumbo Packet mode is enabled) is received" "0: Receive Watchdog Timeout status not detected,1: Receive Watchdog Timeout status detected"
            newline
            bitfld.long 0x00 8. "RPS,Receive Process Stopped This bit is asserted when the Rx process enters the Stopped state" "0: Receive Process Stopped status not detected,1: Receive Process Stopped status detected"
            newline
            bitfld.long 0x00 7. "RBU,Receive Buffer Unavailable This bit indicates that the application owns the next descriptor in the Receive list and the DMA cannot acquire it" "0: Receive Buffer Unavailable status not detected,1: Receive Buffer Unavailable status detected"
            newline
            bitfld.long 0x00 6. "RI,Receive Interrupt This bit indicates that the packet reception is complete" "0: Receive Interrupt status not detected,1: Receive Interrupt status detected"
            newline
            rbitfld.long 0x00 3.--5. "Reserved_5_3,Reserved" "0,1,2,3,4,5,6,7"
            newline
            bitfld.long 0x00 2. "TBU,Transmit Buffer Unavailable This bit indicates that the application owns the next descriptor in the Transmit list and the DMA cannot acquire it" "0: Transmit Buffer Unavailable status not detected,1: Transmit Buffer Unavailable status detected"
            newline
            bitfld.long 0x00 1. "TPS,Transmit Process Stopped This bit is set when the transmission is stopped" "0: Transmit Process Stopped status not detected,1: Transmit Process Stopped status detected"
            newline
            bitfld.long 0x00 0. "TI,Transmit Interrupt This bit indicates that the packet transmission is complete" "0: Transmit Interrupt status not detected,1: Transmit Interrupt status detected"

    rgroup.long 0x11E4++0x03
        line.long 0x00 "DMA_CH1_Miss_Frame_Cnt,This register has the number of packet counter that got dropped by the DMA either due to Bus Error or due to programming RPF field in DMA_CH1_Rx_Control register"
            hexmask.long.word 0x00 16.--31. 1. "Reserved_31_16,Reserved"
            newline
            bitfld.long 0x00 15. "MFCO,Overflow status of the MFC Counter When this bit is set then the MFC counter does not get incremented further" "0: Miss Frame Counter overflow not occurred,1: Miss Frame Counter overflow occurred"
            newline
            bitfld.long 0x00 11.--14. "Reserved_14_11,Reserved" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
            newline
            hexmask.long.word 0x00 0.--10. 1. "MFC,Dropped Packet Counters This counter indicates the number of packet counters that are dropped by the DMA either because of bus error or because of programing RPF field in DMA_CH1_Rx_Control register"

    group.long 0x1200++0x03
        line.long 0x00 "DMA_CH2_Control,The DMA Channel2 Control register specifies the MSS value for segmentation length to skip between two descriptors and also the features such as header splitting and 8xPBL mode"
            hexmask.long.byte 0x00 25.--31. 1. "Reserved_31_25,Reserved"
            newline
